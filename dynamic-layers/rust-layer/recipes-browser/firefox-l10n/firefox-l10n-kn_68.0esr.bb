# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "90702ce0a0cb9ec3bb506ffff35a6960"
SRC_URI[sha256sum] = "7cd95b40ac3e73f70ef2daa3abb4288ffb86ff641001e2b856ad162f694aa95f"
