# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7f85a61b2d926bf221437a82e4fd5b93"
SRC_URI[sha256sum] = "4fd7c13c3f7d3b35f4e8e6b78c0ffc346ac997dabdbcdc4ae325b32ba9205f53"
