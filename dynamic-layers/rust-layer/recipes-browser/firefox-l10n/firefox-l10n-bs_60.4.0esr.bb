# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a69bc3ebafc6a26a0d37a091846a7cbc"
SRC_URI[sha256sum] = "b9c140cc80ea283c014b14261fdb9a9ef3b80a555bf82006d75ac4e1ca267e0a"
