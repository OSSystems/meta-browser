# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2fe7f4969f481f21174b1739e35c2f8b"
SRC_URI[sha256sum] = "b3146a23988fed470c20a464e24bccaa32436b1c496a7c3cb7b6f88c7c445966"
