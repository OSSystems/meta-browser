# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5e6b00d850a5fe08e2c5d2fe16f652e6"
SRC_URI[sha256sum] = "d4bf54a03f8340cef80ff2bb2f052d64904da6b861bd69da8d13d65eaeef9ecf"
