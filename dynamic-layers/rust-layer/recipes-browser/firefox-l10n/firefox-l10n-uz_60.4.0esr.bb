# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ceb43d21ca3ce15abd4e1bd6d29b6ba1"
SRC_URI[sha256sum] = "c0a2ed70997900393a4db969603a7acf20418a2fd998768ced127bb507a061a0"
