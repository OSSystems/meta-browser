# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6aa2ee41742216bd5105c46c98ae9ae9"
SRC_URI[sha256sum] = "cd470e9980bcd4695c144cb6015e3daa35a996743916404574959d9dd441076d"
