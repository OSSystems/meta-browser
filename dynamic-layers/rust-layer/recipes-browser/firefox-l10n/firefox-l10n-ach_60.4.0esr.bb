# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "934fcc0f7cbadd7cc97e38f8278c8c59"
SRC_URI[sha256sum] = "6c5994f79cd186bd9c12b309f7fe4dcccfea6467cdef752e5808f8b999f4e863"
