# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bd78d511c7992e66c98eb39c80377936"
SRC_URI[sha256sum] = "a18b68b566a82950dc6dee3fe9f27ac8e2e6308bbe508d1690b19975b82a5dab"
