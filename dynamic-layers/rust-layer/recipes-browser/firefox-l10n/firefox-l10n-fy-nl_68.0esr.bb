# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "46ec63bf194ef78e6cbc8c24c65cdf49"
SRC_URI[sha256sum] = "fd93ba7c19573afe22af1d5c63cdc98ee5145234203cf6fdc979a3876044448d"
