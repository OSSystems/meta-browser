# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e96cf90d702891ffd40e5f5a775344b7"
SRC_URI[sha256sum] = "8b0ea6983a234e50fa502ed7d8e42201fb8dc186395296a52bbf282c4a66b9b0"
