# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "555a489e17ffbbc664da45f83f05a254"
SRC_URI[sha256sum] = "aa76272480d526d462c33809b90d018ad8f2bfa23f62703623c85c18329bab60"
