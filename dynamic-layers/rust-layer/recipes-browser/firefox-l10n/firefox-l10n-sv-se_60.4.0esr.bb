# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e60f7aa0ebfeea799cb4b4c2718ef78a"
SRC_URI[sha256sum] = "1800232094c7155114105002dd33c08f2fdcc92e41551ba1d480f4612e7f7077"
