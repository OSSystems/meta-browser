# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "39f511ff59791c40fb1697cf6ed0c89c"
SRC_URI[sha256sum] = "f0428fe69468ebd2eea170d9d7257f86c348b233dafb5ff351e8e026158ffe54"
