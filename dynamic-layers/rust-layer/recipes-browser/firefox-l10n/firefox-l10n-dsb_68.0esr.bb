# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e99a34acde91c2ab3065ce5192ca32fa"
SRC_URI[sha256sum] = "c9182149cb49df9edcafc9431bd4e8ea3bfb717b7bfb3b1f6eb47152b1571cbf"
