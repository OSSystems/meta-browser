# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "81c35c4c14b92ff53dc637cbece7a383"
SRC_URI[sha256sum] = "d80186be24ddceee96b87f80138a370e8879b4100954bf18d2e38b7785482a61"
