# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ecc0b11822aceb28e400e948ab9e2b5a"
SRC_URI[sha256sum] = "1386a3c3ec49171f0f36cc402e42947da237f685c337c350190de260b65d0c08"
