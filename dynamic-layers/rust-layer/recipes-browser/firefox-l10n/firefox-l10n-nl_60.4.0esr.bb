# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8ca2859448cfa078e6c6b9b4cfa9a22d"
SRC_URI[sha256sum] = "ff01bbc0b7f14bdcac59c172772607cbd2e7b39fa6606eb823e5c7b836b8c6be"
