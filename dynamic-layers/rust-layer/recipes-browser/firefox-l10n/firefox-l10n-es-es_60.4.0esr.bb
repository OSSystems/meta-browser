# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c5a92ecb5725157ed2d9b287edb701e1"
SRC_URI[sha256sum] = "e99b60f519a100303c7a36af33cf65146043a74f676e9c7996f7e21c211ea01d"
