# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4e1ea9920d6222344459b773b9b94907"
SRC_URI[sha256sum] = "d1ceea4c1fa3213b4ae6da7e288f5012872354d140acacd8322817e442934876"
