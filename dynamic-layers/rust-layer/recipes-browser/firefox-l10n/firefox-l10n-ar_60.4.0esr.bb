# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "45fb995b314307582daa685031ab6070"
SRC_URI[sha256sum] = "28c1493982afd32ccb1533140fdc2f72cf5202be6917a6ee549d44a93180ce91"
