# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6aa179c7dad6514b95e67d177a0ff4c6"
SRC_URI[sha256sum] = "a4ee451c41411dc4ffeca0c12ceab7f3278d6d3382d5bd24b66f5419b69da216"
