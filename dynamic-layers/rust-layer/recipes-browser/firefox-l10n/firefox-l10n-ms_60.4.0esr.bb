# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c751038214d161f7daaddac1c076e91"
SRC_URI[sha256sum] = "b30f0459ab5450a32d4afce816358506fe2893407f83b1766e397ad523616cc7"
