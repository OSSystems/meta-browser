# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c4d63026c12896a0336ba1e0a26f089d"
SRC_URI[sha256sum] = "ab61375642c30b68e4f2ba07331b6459c6f68f2b79236445ab2158a93915ad22"
