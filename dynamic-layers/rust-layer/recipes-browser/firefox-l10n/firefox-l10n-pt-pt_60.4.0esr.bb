# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3af0a9f3b13873a9d7e91c5f005cfa95"
SRC_URI[sha256sum] = "50ab49d5a76a234f65b2577af92a2e0805743212e3995f58d66e61540b4790b7"
