# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9d71274f7c37ce091d759049d057a6ed"
SRC_URI[sha256sum] = "60437b90b11c35ae0071d491a17af9b9708fd570db85a0c1643178ac1d9fa65e"
