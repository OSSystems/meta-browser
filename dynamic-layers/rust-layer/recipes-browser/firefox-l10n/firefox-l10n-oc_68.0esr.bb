# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c34ae85e7903fdbb8f6c0a02611e05e5"
SRC_URI[sha256sum] = "97378da0d350d698a2e880573309a218610ad349babeb370b9b6981a0b349f46"
