# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "22f1663f5185242d5b7f32adc2ea042c"
SRC_URI[sha256sum] = "db7fe6e379a2bcfb5dec76870d4ba040904d619e6c6214199cb908d00314e720"
