# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2471f410c25a9e97ffaaad4e4b362509"
SRC_URI[sha256sum] = "3ae7e912052724a7b9c63a51889a49596cadd8718db53aaad91a41aaf4bdbd7b"
