# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0726bb0db82933bdc8c7134aaa58bad8"
SRC_URI[sha256sum] = "2344003da0d5761b7f7e294d2a18f894cfcd07f580cab468bfb08561d0ddabaf"
