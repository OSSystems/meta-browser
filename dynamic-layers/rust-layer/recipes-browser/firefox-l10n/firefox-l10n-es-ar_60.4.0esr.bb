# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "efd052454d545adf90a1e62bc86db7fc"
SRC_URI[sha256sum] = "014b6a3dd4fba99c19c61ebc9a886147aedd69fbc4d5f5d26970cd14319f9d8b"
