# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "05fea24cf2167ed35b7810bb871b1cb5"
SRC_URI[sha256sum] = "31870f3e69c7c4c87b933ccde828da337012a1cd48c90d585ce878fea235557f"
