# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "82383de1cd515093be03c09f23199c9f"
SRC_URI[sha256sum] = "5bee6ca745bc28ecc64c7d89fc9c4914e8d9fc22b2add02b94a8b856b77a8f19"
