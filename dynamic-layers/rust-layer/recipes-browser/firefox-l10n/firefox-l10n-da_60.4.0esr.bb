# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a95825687abdbe1ceb58a2f9ec69b15d"
SRC_URI[sha256sum] = "9a4cdbfa1d7a8df5d8d0cf593e702ab9a64a0d7bf8f7e5e5f52c0b926a1a2bb9"
