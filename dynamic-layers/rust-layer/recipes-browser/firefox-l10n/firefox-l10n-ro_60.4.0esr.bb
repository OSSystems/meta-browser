# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "55f5e8dd0b4687efd3c9ee2c53238dd3"
SRC_URI[sha256sum] = "1417b4da31080b1d9a1e4fba9d8dbd8127150cac276f1754522ec40a7f2dbfbc"
