# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fd9861941ab82d11eea7b7ffdbd573f4"
SRC_URI[sha256sum] = "56fd2362e3472b24fa9f193c1bb518a45fc8f66ec761f1cd0a2d6ab50d7931b9"
