# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0eadf23e7d46c01ad1a827b00f2cbd90"
SRC_URI[sha256sum] = "f9a80dd819a039c4923eb6be6b99bad8ddfa3929b8fd0aa033a020c1d271bebd"
