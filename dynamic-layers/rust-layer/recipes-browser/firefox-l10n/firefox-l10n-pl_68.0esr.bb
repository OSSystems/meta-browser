# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d40adb9f2bbc4a4bd3bf327681fd2062"
SRC_URI[sha256sum] = "20a3c1157b580730e3f6f8824673a2a110f325660e04d24d70354a25517ec9d8"
