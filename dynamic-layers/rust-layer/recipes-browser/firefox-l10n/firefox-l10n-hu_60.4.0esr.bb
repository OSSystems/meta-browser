# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f2caed06731413eec2c08b019eadc865"
SRC_URI[sha256sum] = "ca76e1ad2f5b0566d1e724173482131d0dbf001e0f7ffd15eff2108e645155c9"
