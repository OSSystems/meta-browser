# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "acd360252bc49c0a53af2ff7151228de"
SRC_URI[sha256sum] = "247ea7d7505d4b628cb61f2e3cc3f117ad6361b4068651e7ef9e1e2d6e2daaa9"
