# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eb4ae9692a40ed5f7633cb60cb4f05ac"
SRC_URI[sha256sum] = "f9278c95c96c097597a3c226ae3bf516c47be6967f96ee993c47eb382b185a1d"
