# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "87d3c856cc8c5eb39cad4df4b70475e0"
SRC_URI[sha256sum] = "6ea6ba19dc93c9d4c3cffd9d493bb6dbfb3b853ac563dcfc4b1b09a78d1c946d"
