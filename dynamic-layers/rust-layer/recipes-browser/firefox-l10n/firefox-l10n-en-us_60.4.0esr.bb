# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aa80a8cf34f4752988c7289dc3524cad"
SRC_URI[sha256sum] = "c253f340f02c8c3a1d0dbf7b68fde4055892e69fc45c0e144ff74fd487dadacd"
