# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a077bc86712dd901f870be80e97731d3"
SRC_URI[sha256sum] = "976cd458c7740fd9985d2644559ba238e2121b58365d20fe0bf4c63f844d96c0"
