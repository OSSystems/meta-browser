# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0b54a30573a212355f350cb1db922ec6"
SRC_URI[sha256sum] = "dc4067cf0f3637415f1356da47d66d32fd59930b92a27f5e809d404192302189"
