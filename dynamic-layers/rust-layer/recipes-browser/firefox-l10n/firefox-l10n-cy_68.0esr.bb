# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2ba4f68c42dde624ac40aba115d381fa"
SRC_URI[sha256sum] = "c992352b4a4e7f5360a8b2bafe3108b1d29e88ca033d72d65a12d54a6b9eed51"
