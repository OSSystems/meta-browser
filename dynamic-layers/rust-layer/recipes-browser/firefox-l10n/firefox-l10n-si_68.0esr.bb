# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5f8edada0536e6f40e31a133e3049eed"
SRC_URI[sha256sum] = "afbbcf5a8213ab217ef190f1a4036a0770797bfde9a4648092e5b7dbb46a3b55"
