# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2a430f0bf57732a11c3a4c94ea5af8f1"
SRC_URI[sha256sum] = "6a83361baf41d8458c7ed6a86f0f18ad40e0f144d9ee84b4e00be3a63745c3c6"
