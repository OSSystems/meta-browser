# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e89e24abc1a904db32f6a590ba2c8eaa"
SRC_URI[sha256sum] = "5270288b98966f6b3fa3276b2a02e03ca38dca33bb757190ee2999d5b64d309c"
