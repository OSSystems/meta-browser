# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "495712849858b6460b79adbad75de82d"
SRC_URI[sha256sum] = "4ded1be2105453f6a223e89cc3286349e3582241ff8beb0647628ca756f90274"
