# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a2f1b43f47345684f2e089bc45a114eb"
SRC_URI[sha256sum] = "7e769f0f1f18321045df2f860f9eb58e08def46f786c26ac99edb3a7fba67917"
