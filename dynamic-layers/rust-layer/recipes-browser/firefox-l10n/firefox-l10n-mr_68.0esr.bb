# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "353f7636787b950993d503f1cbd70ab5"
SRC_URI[sha256sum] = "48b7508fb813041a4f308043912b68daa6a34bfde1e01c31a6080b64db953bc6"
