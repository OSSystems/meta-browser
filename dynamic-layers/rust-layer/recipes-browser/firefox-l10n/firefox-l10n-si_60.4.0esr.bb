# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d9a1daff919ba2b172e85c8564ac08d1"
SRC_URI[sha256sum] = "2d30b26181b6cf1f62f21e58c8220cf4f07fdef498c6501f9f62b164af282eee"
