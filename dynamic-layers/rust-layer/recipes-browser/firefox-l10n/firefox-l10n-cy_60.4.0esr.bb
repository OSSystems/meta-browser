# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e46efdebf7670e0ab444207fd9b823a1"
SRC_URI[sha256sum] = "973c736b181fe17fa9178a56520ee1fe859bd29fb34ee4d608025e9ad32daa79"
