# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f77f3cc3104f4e7dba7fb9923ec81578"
SRC_URI[sha256sum] = "6aec8e5f2ec6e6022a64ffa78d362355fad1b1bc244bd98bdf8ed357e0c27c51"
