# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e212dac2a5d317e7cdc6e84f6b6e307d"
SRC_URI[sha256sum] = "3a30240c7c2d3d8428a6c2a902ebcc8c427f6348b4f0115b3dc16ebde87b9081"
