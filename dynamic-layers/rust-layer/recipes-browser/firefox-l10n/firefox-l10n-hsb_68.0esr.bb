# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "218aada307b481b6f18cb3554e9c2c4c"
SRC_URI[sha256sum] = "b7da5e29484a558ed728153f7317e5d3e1d91685f4dc5314519e60592ab63c47"
