# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "efc7870f14a135e82fd841463e300eb6"
SRC_URI[sha256sum] = "b54cb486377eaaf7a5ff5c01e3ee6eaab55a0c893afd513868dbc29df38a6eb8"
