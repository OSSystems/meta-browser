# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "09b57e2dda5850d528267e561051718f"
SRC_URI[sha256sum] = "9876de5ac0d45af3a2f97e7a354215b3bdc766674565ee1a2fabd4d97b3388c5"
