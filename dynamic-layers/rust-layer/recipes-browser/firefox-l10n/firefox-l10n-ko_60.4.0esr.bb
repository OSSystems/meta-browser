# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c8d00d0ff0a22dde0ab9f9e2eb1b61b3"
SRC_URI[sha256sum] = "ec0444e78fa7651873ed5576f052117b02baa6e24228bed4baf820307919988f"
