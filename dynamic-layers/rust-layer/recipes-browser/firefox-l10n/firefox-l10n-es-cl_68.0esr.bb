# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2d2ce3aa4fe9685ce6f7b15a3caa57b8"
SRC_URI[sha256sum] = "ae77930063db8fb2d34bfbaa84a12a0d99627ca6e30d9f21b01203f7a31613a9"
