# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "467740195852d0505d323cf601711f28"
SRC_URI[sha256sum] = "1820a61cf1b7ee92eb6efbf2cb98997630514a37940e858761d8a6c1141ed538"
