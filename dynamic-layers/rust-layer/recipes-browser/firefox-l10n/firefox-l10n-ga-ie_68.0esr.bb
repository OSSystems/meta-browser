# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "302bb0dc46be5e172b76ce4499eae38c"
SRC_URI[sha256sum] = "0159684eee89be1120b9dcdf99bbf18737c9ba62a99f1d144bbff833069a08c6"
