# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e72f83e8f278d1fd664b80686fdcc8a4"
SRC_URI[sha256sum] = "8fab16ee835fb6cc57a0db7c8bb1c49a030145cce22eff549eaaea0cdb33ed6c"
