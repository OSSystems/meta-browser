# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fd53c01a3c3ea1f3969a22ed4b052ee8"
SRC_URI[sha256sum] = "ccb412aef1f753adf3d8d0f00064ceb577e1a93ef81219fd80e378edbf116900"
