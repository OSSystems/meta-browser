# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c229bed969c5a26a54428afc164b4f75"
SRC_URI[sha256sum] = "cbdd0ea6b1e0b092244c7b5cddcf55ac6827831b1f9c9a84c362b19e5f25f005"
