# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "01982332f34c22faeffa5bc0ffb8c825"
SRC_URI[sha256sum] = "a13bf710ead4a685977b3559ae2143f12d6bc2e1e07b9bc76f326fc46b56d8fd"
