# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9010a82566a24f4c67c71f11405e3fe2"
SRC_URI[sha256sum] = "0b1379ffb321a35b6daaf5b0bf18f1d6ab93bd52262ddae62a6e80ff044c11d9"
