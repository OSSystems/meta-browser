# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "876ca9eab011b86b73c846f391046779"
SRC_URI[sha256sum] = "b0ce541e8df6d0ae98851576dc1d5bc028f54da596da7f5ebab0aee69a114708"
