# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f79a796c6a66fd6da50ab3c17aa8f81a"
SRC_URI[sha256sum] = "6c6ed8626308c2b8581daba62790a20c2fa883c213a7f756a5c33cc3e436e79e"
