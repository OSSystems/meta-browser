# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0ad9a1654e94bbfab441d341433524e8"
SRC_URI[sha256sum] = "b5eb53199a87816870961b3d1dcfdda19c475c7d1c6157af42c4d649a7ad97a8"
