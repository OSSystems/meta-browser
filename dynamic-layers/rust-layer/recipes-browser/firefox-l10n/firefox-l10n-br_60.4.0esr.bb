# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "126b0c156ffa7a1a2deaef2e0ca707eb"
SRC_URI[sha256sum] = "509881c785d1a9f55cf7fa9e30de444ac9af5886748dca4a2cd45df60d9df257"
