# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1b1bbfc079e7fd0256b702d8bc2834d5"
SRC_URI[sha256sum] = "0d539f76f2b28b2c913b7a5fa2e2336ea054b69d30ffddcfd9ad55f07c9e0ca3"
