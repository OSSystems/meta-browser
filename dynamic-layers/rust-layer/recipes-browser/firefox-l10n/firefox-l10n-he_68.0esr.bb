# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "79938ae2c9618fd245b31c969f318b6a"
SRC_URI[sha256sum] = "4bd1979686bed44d4ba1e40bf89835644405fc4271271a2714513230d60de34b"
