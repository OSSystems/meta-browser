# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c303fa2330d12320ca694d69cd7eac20"
SRC_URI[sha256sum] = "b0c12e9b9e0d26154fd12b269ce1d74f188d08cc3f3a93661597ec862536e826"
