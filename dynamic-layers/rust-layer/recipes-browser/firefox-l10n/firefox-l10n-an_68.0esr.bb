# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "777cfa36db9ba6d06f53afffe11f5d71"
SRC_URI[sha256sum] = "6edfd8cba9ccd9c0ea2205202d209b4fee7641e85f8fe6dcd1b4459983d58acc"
