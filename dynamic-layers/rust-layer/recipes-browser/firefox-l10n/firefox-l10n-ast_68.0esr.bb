# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "992274070504bdc2c42d6988dff20dbe"
SRC_URI[sha256sum] = "fe9eb2e95ac7501fae5190b02d793a5c4e68f8aa435ea398dd1d603d0c8ac6b1"
