# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "be3277246283b082321383e37c7d283b"
SRC_URI[sha256sum] = "3c1f3cd50941b18297b008c032f1014493e4bfa63ee6e59733115ce5a781ff14"
