# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "94cc7411de7956700b719d30c73099dc"
SRC_URI[sha256sum] = "b93070ce533d706d81aa23d8c86d40f7b4ab12530a61eab1db16f044616156dc"
