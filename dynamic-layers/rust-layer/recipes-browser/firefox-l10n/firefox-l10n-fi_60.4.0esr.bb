# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "16b33e68e391c3512e359553491bf791"
SRC_URI[sha256sum] = "ce639812fd26d480cbb132400a114a1dbfd83a9c97da6a68f633dbec638a74da"
