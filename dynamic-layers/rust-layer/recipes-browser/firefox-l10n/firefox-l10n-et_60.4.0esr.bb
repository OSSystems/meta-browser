# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "963b4c59e96ded67a76355579e07434f"
SRC_URI[sha256sum] = "6ce4afd678cd214b76671b2a8aa63d58cbe85d32692c27c221ee13f6bd8095a9"
