# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6f3a04b44302331c8bd2a87456a792bc"
SRC_URI[sha256sum] = "aea44af29929a9623c2eec09841c1886d6f5ca28cc5850cbbf4bfc6f9629ae40"
