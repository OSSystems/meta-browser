# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7c050c9f0dc1ff4704a4d8f78337aa67"
SRC_URI[sha256sum] = "5fa399baa1ebe7839a100602cfc224e826f5eb19af071a52cd820cc7970ca230"
