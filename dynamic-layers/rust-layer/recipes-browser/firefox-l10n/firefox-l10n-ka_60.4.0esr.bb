# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d48119ecf5307f0c9fc75887665e37dc"
SRC_URI[sha256sum] = "96591b99c9516c93bde22783bbec58a5cbcffc272e5688229b51a1adc10f82e8"
