# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a2dd9db4632a63ae39ba39b123b35692"
SRC_URI[sha256sum] = "6bc1e816f6218149b40a951d7dafb52ee0f3c6507ca0198f6ba3e10db3a9a615"
