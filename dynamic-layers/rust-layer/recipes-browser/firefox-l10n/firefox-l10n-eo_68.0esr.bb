# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a45afd97bdd7bb9f844e765343e4c0be"
SRC_URI[sha256sum] = "b22ee8febea7f50516a5588977f76212020b8725f2d92891872202da8f619c98"
