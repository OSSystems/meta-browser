# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "50495c15e2a87e9df60208d042bfad43"
SRC_URI[sha256sum] = "4effde2a5c6694281a81a6d47e3a4422655db06329721923e5a13a2e0757ebef"
