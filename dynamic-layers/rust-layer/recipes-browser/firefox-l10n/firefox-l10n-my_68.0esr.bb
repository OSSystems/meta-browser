# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3ec22a352c96b9486a6baaa872dba2b6"
SRC_URI[sha256sum] = "8df017ab8ec31fd50208d15d2ff0803a827836ea5875048a98b0329176fba55a"
