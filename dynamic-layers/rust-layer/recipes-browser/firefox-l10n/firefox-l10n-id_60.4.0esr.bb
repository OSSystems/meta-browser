# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dbc865d80e4dc80036ecf42329f0cf65"
SRC_URI[sha256sum] = "6d19a040775eed58b3bdbe6ea4b7d471c2a7501936f5e8e9a860cd50302ef0c6"
