# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fe69a3d95ba20ba02703e376e171aca8"
SRC_URI[sha256sum] = "47037f75daba786f81a4789ab84b7c77d9d5fe5f14c1de266715ff12193df3ce"
