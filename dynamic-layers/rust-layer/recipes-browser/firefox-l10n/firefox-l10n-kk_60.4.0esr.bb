# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aeb55eca29ca3144f8348d5ef9eb754b"
SRC_URI[sha256sum] = "ded846cfe2cb80f129d2874648c3dbc714bfce43ec0e56b54977f0a4b62ecc3a"
