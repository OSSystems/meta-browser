# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7e7976f9bb442f603ed433b55d773215"
SRC_URI[sha256sum] = "862ab2b3a506f5f0fd9f08d3c94fd71ee156e10a365dae09bc38bcc7c2a09afc"
