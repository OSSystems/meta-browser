# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e65487b94eb7f31c9674c114e4b7e189"
SRC_URI[sha256sum] = "fec893afe6fa4ef7120991e0dcfa314794e166419eccc327da754aa0c46385e2"
