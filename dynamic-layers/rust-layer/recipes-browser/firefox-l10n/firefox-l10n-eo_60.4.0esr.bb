# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "31ddaf226e371e44c9e12322f9886cee"
SRC_URI[sha256sum] = "449f6581cb43407675aae277b37b974d7785b6526956fb2434cf4bef60d44e60"
