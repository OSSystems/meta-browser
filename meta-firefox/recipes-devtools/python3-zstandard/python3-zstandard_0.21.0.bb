SUMMARY = "Zstandard bindings for Python"
HOMEPAGE = "https://github.com/indygreg/python-zstandard"
AUTHOR = "Gregory Szorc <gregory.szorc@gmail.com>"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=3ae87c50fd64b6f0942823686871e758"

SRC_URI[sha256sum] = "f08e3a10d01a247877e4cb61a82a319ea746c356a3786558bed2481e6c405546"

inherit setuptools3 pypi
