# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a0d7ae8416af84c4dc381c17ec5539ee"
SRC_URI[sha256sum] = "ee6209871ac9dd2829f495af1961616a916287bed0fc5f00cdedd309a5068ff1"
