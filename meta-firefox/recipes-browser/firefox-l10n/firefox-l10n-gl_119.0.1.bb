# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "85cfd41682a324e5b906c17592d1fe06"
SRC_URI[sha256sum] = "762cb05b2e66752e8b9fe7268793f4d946192ff3e0870120cb18b64215a83151"
