# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "38131c87d87a3747e7ffd33e0cea8858"
SRC_URI[sha256sum] = "2fca4070d48ec46272e4613bf8640f5296a812cd5f751ccc1408903ef8d39bc8"
