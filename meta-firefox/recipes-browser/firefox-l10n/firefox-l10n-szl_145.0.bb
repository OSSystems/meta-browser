# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "77d907d132ad630fcf17ef67f44ef1f6"
SRC_URI[sha256sum] = "f56676de2a265c54374771dd3f2e6b385098645f1f09726afb38237218c770bb"
