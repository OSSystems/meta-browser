# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3d1abc220a73219ace1338a20aba82fd"
SRC_URI[sha256sum] = "b164075d5b219eadcc770ac66a73ca00325db484f8f9beb57ac63d48a5125a6b"
