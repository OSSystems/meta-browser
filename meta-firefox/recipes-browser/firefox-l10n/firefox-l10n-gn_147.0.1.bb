# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c51f14755b8da81060dbee482c371c92"
SRC_URI[sha256sum] = "22d529dc10eb7960ccaab710208e454a63b668b8b49b0f9d80b01b3d83cb884b"
