# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bacc5343d98def280066ac3de963c2f1"
SRC_URI[sha256sum] = "2cc7bdcc231e57e4de567ac897ae11fccacbafb2be9e2d126a8bf57ccdcb29d4"
