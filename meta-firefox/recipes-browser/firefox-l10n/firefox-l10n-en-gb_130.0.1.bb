# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2546ebe83d1af5f7288595df16f1407a"
SRC_URI[sha256sum] = "060d1f0492ded65734c9fc9056fee0beb39b8384d6d2c3b05a748cf76faf8792"
