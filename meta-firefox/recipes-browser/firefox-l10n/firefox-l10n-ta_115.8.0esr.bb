# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f5b454c9bed8687d93fadcdfea247e48"
SRC_URI[sha256sum] = "4b99e48144eb10e44eae188daac2ec36d66d2a16f6cd52b886ff11f23a4c69c6"
