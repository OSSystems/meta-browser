# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bcb3a7f6b5ca56d30482cdba8aba8598"
SRC_URI[sha256sum] = "aea6d3b03ca41fc42e08bbd3b7ec446a3385600e7f296317164c02ecfaaaebb2"
