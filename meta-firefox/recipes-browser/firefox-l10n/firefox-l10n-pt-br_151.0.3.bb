# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "5764ecada869d0602bd6dcfc84625f89d23cecb5ee8fdddd37e91472f1b2e344"
