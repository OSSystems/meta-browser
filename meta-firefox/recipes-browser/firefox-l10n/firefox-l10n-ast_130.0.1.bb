# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c04c97a31aa52aaa3b7eb2026f5e9cbe"
SRC_URI[sha256sum] = "2e175c763dd34defe43d1b3d04c3693176e4610ebaf760d7b702a1efcc5fcaf7"
