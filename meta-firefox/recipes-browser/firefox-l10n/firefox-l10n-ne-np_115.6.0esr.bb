# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3d267a679867e72bd82cf3573af8f8ef"
SRC_URI[sha256sum] = "ac94f403587bd6828012658b5ffe4c54533ce4246b989ceb72c222a359f5ae73"
