# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c9fd9cda47740b501b28e4251f04defd"
SRC_URI[sha256sum] = "12195bc3d454af83e94a2547dc389899c0c32bd0daad12909bb156204c82b242"
