# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "389c8ad3bcd67c837e71a5756837ea55"
SRC_URI[sha256sum] = "2205c01c1ef27d9fb8b5c12e60118d0d9a4b8feceb71de9f4f2c557b0298deb1"
