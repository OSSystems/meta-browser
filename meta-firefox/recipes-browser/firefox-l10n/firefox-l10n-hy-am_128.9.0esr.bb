# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f6c4a2e211ccf271d7b8c4cb4476929b"
SRC_URI[sha256sum] = "3880b2e84d9dd75a5db8f16d6566c4a7c8670f6ca906475b5d82df1cc43ca7b5"
