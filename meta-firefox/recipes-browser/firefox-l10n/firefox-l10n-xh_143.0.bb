# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "578214d34ed2c372a2b1fd538ac3db53"
SRC_URI[sha256sum] = "1e457de521524327c243b512df203f89e698a6f7297f345ea6ca4f73d763fd02"
