# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "08a060ac5fb9e8c695c758283344bf6e5411c0aacdeeade582ea95b38d57d525"
