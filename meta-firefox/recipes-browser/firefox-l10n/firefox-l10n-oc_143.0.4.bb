# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "efb5874893b520f39db52010026b1257"
SRC_URI[sha256sum] = "441cd8be8ef50f3fe6c5f06519b5f70ef80543627d60ff231815f69f337a329f"
