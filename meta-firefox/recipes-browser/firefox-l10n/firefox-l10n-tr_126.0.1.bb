# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c86a6a5ddeb79ab0e43485e1f06049ed"
SRC_URI[sha256sum] = "5caf4521b6596d8e0df588ec5628aad02f63186b0b5db738b5efb58272a01561"
