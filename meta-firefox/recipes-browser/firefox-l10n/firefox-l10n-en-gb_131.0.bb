# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "da69700a663b7629fab3ed5444853375"
SRC_URI[sha256sum] = "d36ecf31d092998604c0647c7fb4a64981784091d435af9771b3ab2595d757c1"
