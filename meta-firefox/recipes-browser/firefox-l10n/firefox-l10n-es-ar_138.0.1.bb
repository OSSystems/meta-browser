# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2673b3a91bbc97e61541b58fbac5be66"
SRC_URI[sha256sum] = "15cc7571595a88d47b6f8a86703e9cd85a7ebaac3066c1f5f90fae3070707e7e"
