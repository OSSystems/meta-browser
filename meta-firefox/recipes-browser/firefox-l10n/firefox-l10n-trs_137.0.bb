# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "36137732d6388e02e3078565e9115ed4"
SRC_URI[sha256sum] = "bf373d1d795626c44c9f2c29667e22e377dc1a4d555e255d88fbdcd56cd026c7"
