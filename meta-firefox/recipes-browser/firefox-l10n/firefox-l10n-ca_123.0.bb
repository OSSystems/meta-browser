# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cf460401938b936fbb2328173d043212"
SRC_URI[sha256sum] = "0a4ac9b1860361fb3535b6fc61697ba597656d2c69a326876f4398b5d06e1970"
