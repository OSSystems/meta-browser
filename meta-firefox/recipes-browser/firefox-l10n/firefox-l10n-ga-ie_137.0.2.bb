# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7b6d3dc5f9de06c5aa5894e7daac2da0"
SRC_URI[sha256sum] = "9904ac087eb0e32ecfbfa03450e6e48db96a6d77a415f5d37a118215397a9a97"
