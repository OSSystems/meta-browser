# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "30b3b1a219302f8d3622d90e39001c35"
SRC_URI[sha256sum] = "87f0a91bb1b2d6020fa0f4124a6b88df1e8674eb493eaecf0e800cd4cf6cd9d1"
