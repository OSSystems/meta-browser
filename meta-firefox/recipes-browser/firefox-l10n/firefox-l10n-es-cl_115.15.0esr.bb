# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dd6f6ab7cc9057dc9e7044a990cf6216"
SRC_URI[sha256sum] = "5f84a775305ae7e92d12bce2aac3335a4b5eac714fb9aba3d8bef6dfc5b3298b"
