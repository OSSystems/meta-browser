# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0402724bc3096df5ac08e4459cba9dd6"
SRC_URI[sha256sum] = "ad6817c75333fd20bc491ca478d1f91c4066dc2acc820a3b3d6f04392b97e5d3"
