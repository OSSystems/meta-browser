# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8624b0d355a0251d3f1bb8448ff4d55c"
SRC_URI[sha256sum] = "31804b05ce3c31bc8057a995f763a0db85ba17f20ad9ce3b858e92c5178b2769"
