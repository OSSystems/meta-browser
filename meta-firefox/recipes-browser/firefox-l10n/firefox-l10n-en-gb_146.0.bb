# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3649c0f71fe810904f92f3b2a2156cae"
SRC_URI[sha256sum] = "8f47421bb1fbd2602110728f2c991408c41745d01ef362db8a54584e55247693"
