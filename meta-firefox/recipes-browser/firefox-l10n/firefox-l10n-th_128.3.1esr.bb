# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "07269a9712d14e290cafb5a0ccfcd617"
SRC_URI[sha256sum] = "bc6d503b3c9c51c80bcc56dd1a0336c6fc7d7fd57a2c24395efdb17e33081bbd"
