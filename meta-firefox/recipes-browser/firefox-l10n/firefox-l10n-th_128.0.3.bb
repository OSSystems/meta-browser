# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9e9a254bd930a00f29711d407a24cc91"
SRC_URI[sha256sum] = "a8c2c06479e00cc74c2250a3462ce248f5dea4511f738437270f2a13dbe4b7bb"
