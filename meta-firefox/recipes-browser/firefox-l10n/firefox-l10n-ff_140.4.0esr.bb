# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1868ce00523fa6235576c607afeddb91"
SRC_URI[sha256sum] = "9dd124789ef2ebe57d54352e79b31628aade761d7a9a9f5f11e2a381c1d15a4b"
