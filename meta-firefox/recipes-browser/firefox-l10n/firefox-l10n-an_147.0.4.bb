# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2f77365ddc71d0998633823f8c2a7e83"
SRC_URI[sha256sum] = "f8465a5a0f802c3ada29f2d7787b3bcaa95310396597e7c234d522998ce1b141"
