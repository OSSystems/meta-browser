# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c336b395c079b18688f44047d748b77c"
SRC_URI[sha256sum] = "e262cf6d945777a4336e5b346d546755a9307c2531f0e05e55496b10a9e4bdd4"
