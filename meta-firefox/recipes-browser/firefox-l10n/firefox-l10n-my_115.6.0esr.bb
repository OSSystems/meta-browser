# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fb1fbcf926b34320444b265fb1ef2b93"
SRC_URI[sha256sum] = "47568e563c672a6efa779fd8e40a1dbf11fafacd1de4aafa893b04f22e466b5d"
