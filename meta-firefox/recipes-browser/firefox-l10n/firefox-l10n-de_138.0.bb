# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "99e55d4ea76e5587f22b527373056325"
SRC_URI[sha256sum] = "b6dd8d4d7ac78bb0a6a211bcfe7a0554af020c97c7a155a49abc0eaf1d336a9a"
