# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bfdd5e8be3e90f976dac147521f3431f"
SRC_URI[sha256sum] = "ba958a634b6202f705c443cab825dc410f28061d33c92d0e3ff4e1d58e142dce"
