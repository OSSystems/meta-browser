# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f473e53de9035df0d15cc3627bdb0b54"
SRC_URI[sha256sum] = "1081276ffc6eec591dc26ef360c74e0e44933467691e0489f655aa3c9fe24051"
