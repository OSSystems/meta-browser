# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cd1e2f505946da062a3f91851fba6863"
SRC_URI[sha256sum] = "025f2bd9e75c5abc3c2be825eb879310133d3423c46e13881f7429ecb568953c"
