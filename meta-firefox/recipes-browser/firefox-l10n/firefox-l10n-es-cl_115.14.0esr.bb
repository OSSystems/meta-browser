# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0766909986d8afc6b0ab627e5c590cb0"
SRC_URI[sha256sum] = "68c121ff81642c05f351cd522869b48ccc28edd69d1d0fb0a1ebf70181b9c343"
