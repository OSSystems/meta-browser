# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "241029baf15e3e0a18b218f26bf6020c"
SRC_URI[sha256sum] = "2cc5d600f990f7785150aa017d3abfe85cf93ac27029d9d4715325f52c5add12"
