# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "298572933392df99a877c7040324a2f1825b2c7e0c67cd33d1eb5f36d4fc4cb9"
