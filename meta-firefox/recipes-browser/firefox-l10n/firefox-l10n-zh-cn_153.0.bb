# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "88052744ef4db4c53d8d03b68834c289f5682b33f43516175ecc307c7c5dde07"
