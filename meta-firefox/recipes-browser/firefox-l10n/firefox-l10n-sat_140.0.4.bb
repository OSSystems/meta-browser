# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6d49357c2ddb9db334dc263836eb840f"
SRC_URI[sha256sum] = "2111b154b00dbe4b2965d1e5da241ee99abe0ea7a634a1d9a33be1bd790cca2f"
