# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "90515d913ed4b273d8374c590971dbb6"
SRC_URI[sha256sum] = "571ac699d4261ae11986ed049bad7ea2954b41e4fc69c07553aa8f4a6b72dbc1"
