# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e851418273fb68b74e53d32a7085a4cc"
SRC_URI[sha256sum] = "f06a9e11d04ab6b9df8cc77850812b87f258160320bbbd7802f0f6df17fb70f6"
