# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "931ebe87837b99135e97cfe1c2696efc"
SRC_URI[sha256sum] = "d08868539620ebbd7217502ed1397d460e627667ec0e1fdf742a7db123cae020"
