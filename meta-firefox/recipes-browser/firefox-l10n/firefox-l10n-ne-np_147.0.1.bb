# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e9d61ef869192885a1a3a9ddcea7abb9"
SRC_URI[sha256sum] = "9aa8e4738a2a015f57105ae0725491e20a6fbd8db8afe5eebd6f6e266d531c4c"
