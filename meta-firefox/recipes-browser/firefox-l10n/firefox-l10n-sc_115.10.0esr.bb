# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6600b17594b96eacb9da30081b7efaf3"
SRC_URI[sha256sum] = "11aba624bfb41087935a6fd10be5ff601e7e3d48d6baf8a5321c503709af5fdb"
