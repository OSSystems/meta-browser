# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8905367fc3849666384991767f551597"
SRC_URI[sha256sum] = "9f6da7b5e01159dd6e3adaa95871b7ebde8fa26543599d781f05ad61b79b632d"
