# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1ed04a83e292f719c3ca91229bc2e500"
SRC_URI[sha256sum] = "b6ab4e06d277e24d9b3baed9c3e3f454940c68a2b3fef08565f4bee67bbc8ef7"
