# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2551c512014e7420526ea78fa2e5e1a0d8a09b103059e8135e41cd045e9ee48a"
