# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "bc8a8c56e929932ebbe1da7ece9b0b912de88aa44e37f0dff2d1fa93001e1e31"
