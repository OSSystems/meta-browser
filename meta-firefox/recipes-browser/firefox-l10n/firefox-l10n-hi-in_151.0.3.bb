# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7f2b1dcc52a9e9e11591613e6b99b4689b7c5c7588021f8de25188b38d9e4106"
