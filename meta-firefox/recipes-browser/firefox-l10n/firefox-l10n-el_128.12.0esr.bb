# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "27c4d893d3431c93e163e2b9186f2630"
SRC_URI[sha256sum] = "f9b996f8eab3563e09feb55ff55b87f9ab7d091e913fbc389384fa01a7466869"
