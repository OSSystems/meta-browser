# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "77cc0e50eb7881f27179da3cf7459bc7"
SRC_URI[sha256sum] = "c3c43808b24352c0b15f0da19b649d47b398ef5c687051499cca475ada22fcfe"
