# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "569b71dea99ead4490796da43211df22"
SRC_URI[sha256sum] = "fbe0b1c7a7332407dd355cb0b09f8c9ff97d218412f5f42c932f32dd7f4335bc"
