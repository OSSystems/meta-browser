# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5471904855c4210931bbd7fef5cd6014"
SRC_URI[sha256sum] = "b812896f925c5e0e5c84d503a9da3355aca34222be20fff7a8b7f81155178fd6"
