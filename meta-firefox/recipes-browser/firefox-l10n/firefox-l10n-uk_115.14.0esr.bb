# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c8cbe4fc80138675c664eede667ba244"
SRC_URI[sha256sum] = "8ab340a9b16b5e94fffbe0b0e4ab622b1e3a1dc189535c171d363c078a3a66e8"
