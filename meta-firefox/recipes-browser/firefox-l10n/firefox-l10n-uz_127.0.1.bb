# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9982c4cfe3a569d816b751f34219cc0e"
SRC_URI[sha256sum] = "b44e6a00bd09b9a2aa93f82cda288de5d17bf59c880267ca65a52f0fcd340fdd"
