# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2582d69b195193eecbdb34234b018b9f"
SRC_URI[sha256sum] = "72903a64fc856f5665994917ba3379d7e092861d493f00589db9eb903f789454"
