# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "42ca73421fab07cbd6573446975d1200"
SRC_URI[sha256sum] = "2eb82451a3ff4079981a397d7691fb65b61b5bab3d9a54c30686fa8d2744b331"
