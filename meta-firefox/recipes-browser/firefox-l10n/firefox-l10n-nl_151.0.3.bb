# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "01db6dc4b62c16a55d8a244686ad1517f651942686c7229dc304e51acfb22380"
