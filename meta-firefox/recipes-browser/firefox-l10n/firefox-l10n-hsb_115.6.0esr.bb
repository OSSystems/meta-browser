# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a3d109f786f959dee472a73dec9cfcf6"
SRC_URI[sha256sum] = "7dd3b1b5cc3f091791713256c7f686f4e8a786ab019f3fa2fe6fb010d9405d4a"
