# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d6a594e751a8af16f0aef67baa69b039"
SRC_URI[sha256sum] = "197d45e5aa05c0d9e6c4724e0f727206c937bdb01e3582369b08531de1d96563"
