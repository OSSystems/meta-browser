# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0b19d0964cfd6f1c75f12ab5ea3aa963"
SRC_URI[sha256sum] = "c5c0f86227b958b295a77960751e89330f1989004c525568cd12cbe0d355abd6"
