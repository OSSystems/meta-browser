# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2878201be5ee779917a1cf9eee289b99"
SRC_URI[sha256sum] = "28080e9fafe8748d4c766a8c5584810691a3a96884c4e4f7536e779928c54927"
