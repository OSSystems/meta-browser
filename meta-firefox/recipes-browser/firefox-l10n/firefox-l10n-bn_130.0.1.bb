# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eb3da8125fb78a72d98b2500002711de"
SRC_URI[sha256sum] = "33dc9f7b248c839eeb5bd5e4165b0c4eaf66333422a5756e4c264f370d633416"
