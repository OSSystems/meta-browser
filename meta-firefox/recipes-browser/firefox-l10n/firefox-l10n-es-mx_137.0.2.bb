# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "96ec41c1687f705243970d7a8ab24e7f"
SRC_URI[sha256sum] = "19449cb841b9e95fb86b9e84c1050cb043ad68be5f6323dd1eab61795029717d"
