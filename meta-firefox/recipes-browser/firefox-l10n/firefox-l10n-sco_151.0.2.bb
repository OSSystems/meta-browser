# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c0939a370c92be6e9054762d11893317b3adf9a95392545bb09d0a18309ee54c"
