# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "41e08faafa5ebf592173a9061a14e106"
SRC_URI[sha256sum] = "aa3daa638061d45ce76f1948807a2d17250f58045a6fdc55d760ca04d548681f"
