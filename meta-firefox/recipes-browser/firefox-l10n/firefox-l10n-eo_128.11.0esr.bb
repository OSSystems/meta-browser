# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e8d17c01f65acd11cf87f533802d408e"
SRC_URI[sha256sum] = "5059d8f8173c59469cfbf70b0ab3117a2d0a79ae64789c2f83e6ac73416faeed"
