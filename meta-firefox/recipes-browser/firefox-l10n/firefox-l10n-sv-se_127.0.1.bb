# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6c9dbe2350ea93c75ecac91198b456b4"
SRC_URI[sha256sum] = "e1fbab3b21627dbf1b10e1f5c160157f6c00c81ef4a84e1f82b1348e7bfce2e7"
