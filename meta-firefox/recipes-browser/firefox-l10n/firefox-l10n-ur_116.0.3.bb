# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eabc1837a6d96ba8d7e69ed3b9d55d59"
SRC_URI[sha256sum] = "7dde4a2914e8c80c0ddb39513c5e3c9d02906f1ca4a824b623ad550dd73ccb55"
