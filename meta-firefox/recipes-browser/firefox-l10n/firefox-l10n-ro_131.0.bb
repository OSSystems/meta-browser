# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c2bce8f01a2857b574dd7e97b17c1869"
SRC_URI[sha256sum] = "b250023f63d87aed528530af1ee5b25a7088d0c730f4b77ec036ecc090125ea0"
