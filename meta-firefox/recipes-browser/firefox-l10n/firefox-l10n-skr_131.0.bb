# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1edff28ac60f8a75faff81be85dce8e0"
SRC_URI[sha256sum] = "6dd95b4fcf52af161548a333dc5fbfcb7565900daa93898942d9780d7c0c5951"
