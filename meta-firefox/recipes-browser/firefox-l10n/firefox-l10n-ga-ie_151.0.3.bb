# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "aea150ba2aaa557d7d7fa133c97a45e13ce1e3281e35d323cdfbdb578a5abc42"
