# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6c98b54d545dd21ae5cb1524055a88eb"
SRC_URI[sha256sum] = "5f48e07394831ae7fa0cef980f8ba1467932f588cb0b3708775b06dfa4303484"
