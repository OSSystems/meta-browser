# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "66463af74fb448c504092f1b79d269fd9f1b64542a1e04d0f3ceb6815baf3553"
