# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1f4824571ad8f20418495e8bba140c33"
SRC_URI[sha256sum] = "530b55fd449a486dd1b606c12cab678697f1c49b796a8641a382169bee4bc7c2"
