# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c740c9b2d4d687666c860b48f24fe79d"
SRC_URI[sha256sum] = "3862047f0b26ae138f79e8d89c6129f46e9267574bedc94dd53e397047c2caeb"
