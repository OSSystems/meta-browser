# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1aac61d0b2422e694c04a4e03d597368"
SRC_URI[sha256sum] = "08e7876c137bf0cd3209885710e83bf623c792b305ac5e2066a7956aedaf0948"
