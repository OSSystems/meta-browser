# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a5bfd279a483e3c694877918300204a4"
SRC_URI[sha256sum] = "beccb760b44ce216043f4bd0823b72e9b79cd627625dd1b8998c434e2ac31fea"
