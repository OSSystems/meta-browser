# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7c914171eef220173a15c9d3ac8bc558"
SRC_URI[sha256sum] = "0b4e8d4029b6340f6bf22a45d66ef72a7867ab272ed28522411ee7895dc6e490"
