# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "23ecb5c15e7ab4a8ebb0ff0a9219d7fa"
SRC_URI[sha256sum] = "db08a4ce5f1396b816562828524a11fca68ea5bd615c1fcda326da2b82fda0fa"
