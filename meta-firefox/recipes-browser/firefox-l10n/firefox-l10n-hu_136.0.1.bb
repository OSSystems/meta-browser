# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d174d3428aa0ded8924a809963d0d2fb"
SRC_URI[sha256sum] = "9387fac832982e816a51ed6899b2d54a67540c47563ca708a43730dc12605c1f"
