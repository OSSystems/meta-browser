# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "05abe64744cc3d89f9060a21888397b4"
SRC_URI[sha256sum] = "4a4f7e3d4b0f3c2637e8cf3d1522c61fe81d5940f24bd8edd4cc3bacf16e32da"
