# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dcc963843af03c903d4eada7901bc659"
SRC_URI[sha256sum] = "04cc9f596aef9034808b808cba561ef5e9012d9b27cca0f2b1c4d33774eb1cc5"
