# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1a7677977561162d363e68b873844586"
SRC_URI[sha256sum] = "3506f5e96fc88f52b1a8d41bd374d395364c70a36827a336cddd1e9cbd74f506"
