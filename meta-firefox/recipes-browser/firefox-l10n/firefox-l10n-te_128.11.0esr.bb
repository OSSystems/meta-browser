# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ac13ec532f0a49fb41881255d894d8af"
SRC_URI[sha256sum] = "25707af8d02c794f57c0fa84ef32eeb25980743a91af5801f0989751322ef2f4"
