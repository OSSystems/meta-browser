# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6afbf3565b3315cce2affa5f7e67db9a"
SRC_URI[sha256sum] = "2991214d5f176873b6be340aa276f74ef277f30aa4a3bc845ad0ec4c03f69e26"
