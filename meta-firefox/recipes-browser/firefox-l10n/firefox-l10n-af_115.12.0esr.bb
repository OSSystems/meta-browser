# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d9aad047da17f20af17ff3c2a800b6cf"
SRC_URI[sha256sum] = "64548380d430bd565d81cbe96e3b509ff4cc11365958a78c19541e6afe4c8002"
