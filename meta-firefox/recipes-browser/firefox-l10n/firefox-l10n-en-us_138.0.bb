# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3142ea15fe4c081d8e746572c816a6eb"
SRC_URI[sha256sum] = "ead83497682d8af2a91d21c48b90ad9325bb3d756c13ac91cd5f6ad85e8f1638"
