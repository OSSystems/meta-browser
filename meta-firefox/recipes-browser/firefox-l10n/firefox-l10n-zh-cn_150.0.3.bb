# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "5cc7a90c62e6e25b8b048c50f0b78511d95fbb0c7fee79d4bd987c7d121b78f4"
