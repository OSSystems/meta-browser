# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fb34f3db7f57664f551e5e2e51d4fe76"
SRC_URI[sha256sum] = "3bb3b4109c3b0a336a29f7703de65cf49b0dc49504e0a9e289e58a4288e7da42"
