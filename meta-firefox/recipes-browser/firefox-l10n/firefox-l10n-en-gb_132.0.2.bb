# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1caefcd6f68156b862ccaf6490b9a6e3"
SRC_URI[sha256sum] = "9ef9ed08f55efa8edbda4c0c2b247019ca86cdbcf8b50cb6471ddf604b242102"
