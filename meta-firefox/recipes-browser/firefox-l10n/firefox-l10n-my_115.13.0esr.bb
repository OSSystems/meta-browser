# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "04c87a6912415b25fd9e6b244b959e01"
SRC_URI[sha256sum] = "c295548d4ed37130ab9f810ec63abcc6b89fafab743a59301110b2c92917c5c0"
