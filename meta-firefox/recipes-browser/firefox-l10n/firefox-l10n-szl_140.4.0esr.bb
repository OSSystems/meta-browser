# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f888d4cbb38f61974c2b9e9aef891781"
SRC_URI[sha256sum] = "e2645ee915229cfcdb1d80114e1a0eb129b3677b04b473ee9f6f81e388eb5e29"
