# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a58576908b7feafd733d4cdb35960a3a"
SRC_URI[sha256sum] = "c81abcd312a585ef01b3e93c0c775bb0fc164e32c36bd5b728a0eec1bea896a0"
