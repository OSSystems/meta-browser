# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3b696dad9df01e42f218bc070b7fc213"
SRC_URI[sha256sum] = "87c949eeb726d369de48e18b05fd4521bc74b05e453c608030e84c4e90d2a849"
