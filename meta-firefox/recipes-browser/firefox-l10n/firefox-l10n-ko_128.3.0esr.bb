# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a1c7d9a22d9b41aa5f6faf3115519060"
SRC_URI[sha256sum] = "948ace50ba05bcee6256618545354596627281faa625a8da72fc6160eeed6fe7"
