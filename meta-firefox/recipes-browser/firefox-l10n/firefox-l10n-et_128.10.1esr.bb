# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9e310a8650bf92d04517bcafae4b4759"
SRC_URI[sha256sum] = "650dc831e4095b906d456aa8799c5d37849559b47343490b5108ae98f01c3b5b"
