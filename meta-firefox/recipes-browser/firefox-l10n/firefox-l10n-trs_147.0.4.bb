# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8344275a74bdd23d9ef4738dd78faf3e"
SRC_URI[sha256sum] = "f4f57bbca78a1ba7b02ae89d8d157b3feaae7a52247bc0d8be19d21068b494b0"
