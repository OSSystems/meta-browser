# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "25efa0aff2dc280c85c16858093bbdce"
SRC_URI[sha256sum] = "37d788be18e90704ee9658751f3cedb87f898614a7d64f235755342f64cdc30b"
