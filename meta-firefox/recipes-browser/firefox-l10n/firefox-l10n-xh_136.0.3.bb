# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "68902e842016318e5707b101dc816359"
SRC_URI[sha256sum] = "ca5be2ce4b302ac9bf6cd073ccb176b9f94debef7ea34b055bdbafb465ca3ce1"
