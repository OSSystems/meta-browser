# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6155c33746a4430c3b5a35b5ce606aea"
SRC_URI[sha256sum] = "8474b318d06b681db5758304c2363cc875cd960f7da0fae8bbaa28a16574d2d4"
