# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c22873fa6ee3928b2bf07553d599e983"
SRC_URI[sha256sum] = "7c20e111d5392b5498f570c62b6577b5f799b13b75e090f4ca1163181d3e88c7"
