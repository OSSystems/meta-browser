# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1854a8ede3d4f9e6de9ad1fb2ba5649f"
SRC_URI[sha256sum] = "914082fd9b535d8af95fc78c55f13d21f3dc18ad8203d9c256edfdf7b667304e"
