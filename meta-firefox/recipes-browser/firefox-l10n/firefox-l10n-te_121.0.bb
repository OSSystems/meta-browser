# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "91449fb882e256e766aaee26d65afa08"
SRC_URI[sha256sum] = "ccfe7c19ed45fabc7776b15c3e6198fc5356e772864e4643b185728a723bccef"
