# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5a410c57162218c4878abd6ce276b594"
SRC_URI[sha256sum] = "1331371a9f68d26c6fd71a17c3161fc4fdf159f18e211c140f5dfe3a3ec72630"
