# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "b51b2a6bea6edcba5635800e6f1c228e87cd78d615084a6f90397ba36b443fe6"
