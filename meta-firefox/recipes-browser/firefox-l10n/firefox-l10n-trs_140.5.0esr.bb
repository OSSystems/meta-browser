# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2e3a41d755e95ea52167c995a743d84c"
SRC_URI[sha256sum] = "49db439dbece5fd02e1574071f564cbc0fc48161a34a8cbfc4367f497e6923a6"
