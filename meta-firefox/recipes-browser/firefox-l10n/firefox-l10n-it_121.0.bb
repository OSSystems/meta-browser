# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "71b0d3c8aacd87ade6ac1567b4a6290e"
SRC_URI[sha256sum] = "1d467543f9c4e625832e5866d760dfea7d27b430fc58976117d9fa98fec3b185"
