# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "aaa7a9c2104c99ded50e4f53de5b7c280d746b0b14eccbe15dc4e961e0788dbc"
