# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b781c9fc07253b33fcca724ee71f13bc"
SRC_URI[sha256sum] = "f09cf4dc5d99e708ec1bcde95fbadc204cd1e2437637a9ea974f5ed6560d7a0a"
