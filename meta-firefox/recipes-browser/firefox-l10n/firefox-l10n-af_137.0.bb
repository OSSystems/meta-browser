# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4da3f6a37c37c08abdfbfbe47fbc4c3e"
SRC_URI[sha256sum] = "8a3ba7b8c18d972ab4719ac16c3011ff06d4130efc6732f550defd424d630de4"
