# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3ecbf94232db6ef957c6432a8c06d539"
SRC_URI[sha256sum] = "a5286cdcfce6625a496990ce60c01de0206ef6f3a36230d06578fbec626e08ed"
