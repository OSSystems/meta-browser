# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1e7d2c5122bfa7fc4104c9b469f17251"
SRC_URI[sha256sum] = "6222db44a1aa34a0bd3ad9da60a05469ab6f689cd8bc9f1640df8d6f1754b774"
