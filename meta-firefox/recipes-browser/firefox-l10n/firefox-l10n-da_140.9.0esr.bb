# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "95321367beefb30bd53d190ae4eaf5aa"
SRC_URI[sha256sum] = "4e92a23654ab7b3d00a5f391807f0309e7ad1ead2bbb74cbb2166b81278eb73b"
