# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "926509564f594786faa64f17523a271c"
SRC_URI[sha256sum] = "c6cf4982093d05d57b779e85755fd107b45ff315c5b3b439801c76031c5a0767"
