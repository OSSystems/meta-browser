# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "217103a3f9522121f9996b6ed89f3792"
SRC_URI[sha256sum] = "fed4fb66d39f65d1c3704143c7dd1792ca5e8dc0e2e78858932826ebe363dee9"
