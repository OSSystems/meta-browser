# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bb05e9c9618bb45cff075cf619c7a497"
SRC_URI[sha256sum] = "15952ea30fe764bc6c98cb96199b9bcb04dbe287c0f31186036f692fcd64afa1"
