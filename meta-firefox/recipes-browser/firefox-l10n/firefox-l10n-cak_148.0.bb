# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c774637c3c3613b88554468cc50e7060"
SRC_URI[sha256sum] = "703cec83c554d2677b933d1777f5604633854b69d9a0c5d36f2726953f3ab922"
