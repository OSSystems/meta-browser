# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b1645953bb20b68b469451b0b524e70d"
SRC_URI[sha256sum] = "f0fc22a6bcb366cd6a84daa78ee6bc51a1cb71f0f025667cceb5b457a843e06c"
