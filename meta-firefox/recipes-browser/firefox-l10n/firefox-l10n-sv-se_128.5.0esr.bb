# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "25cafdb1297decae59a11aa3ee0d4df1"
SRC_URI[sha256sum] = "13c73a8602e86fcdb6fccf7146ca30dfbf6eff121ddd274202e1fcb9817a22d1"
