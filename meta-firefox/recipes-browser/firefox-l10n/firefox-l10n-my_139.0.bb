# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ea62b718462754c9537bec6f6add8d3e"
SRC_URI[sha256sum] = "6daf352a6f5b56dcce5ab32314056d30a2757d8d1b9aed93246f4dbf08e2abad"
