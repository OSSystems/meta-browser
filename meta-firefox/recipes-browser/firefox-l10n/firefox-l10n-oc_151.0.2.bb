# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3f078574ef0fdeb95c04f1fd90131cc2c9b654cb3278ad5a8781d3109e20fe21"
