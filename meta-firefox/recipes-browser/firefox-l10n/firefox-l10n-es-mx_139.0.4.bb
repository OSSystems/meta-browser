# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6b74c26ab8b04fced94cfb39595e1b48"
SRC_URI[sha256sum] = "1fddc0476d63d6ba4125f0a13ec8b288d8b6557e04d9f988f82d1fc06f850987"
