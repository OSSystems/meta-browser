# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1cbc8232ba92da7d9c5258f5fc15b746"
SRC_URI[sha256sum] = "a29a43275edf625146fd792ea0a0e5b1322b23dff4bc227a3a0d559cb81388b1"
