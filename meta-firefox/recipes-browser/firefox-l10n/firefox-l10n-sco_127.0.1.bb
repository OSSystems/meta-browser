# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5501507f0e12191c3d1d1be99f9af2c9"
SRC_URI[sha256sum] = "0417075aefa0a034b5d381935ae394f7a53e37666cefe3c99e5701a06d4cf917"
