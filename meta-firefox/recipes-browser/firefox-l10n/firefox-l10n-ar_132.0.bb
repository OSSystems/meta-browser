# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "03e49a56341b2006e4b1356e6060c4ef"
SRC_URI[sha256sum] = "bd4631147eb89f0c01f786d86ba0ed7250b0616ba6c1d993bab492b22800c20c"
