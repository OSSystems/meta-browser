# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eb56bb271f4d3e2593c93281f57520ce"
SRC_URI[sha256sum] = "7721e17a57ac67704cf4373d134198114844afd573ce363229222917cea46250"
