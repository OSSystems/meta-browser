# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9010ea6eef88c410d21fdb51a563c26c"
SRC_URI[sha256sum] = "d64a890a68e8ea0012be514e2dff37ba123695acfd712f4a4ffc022bb406997c"
