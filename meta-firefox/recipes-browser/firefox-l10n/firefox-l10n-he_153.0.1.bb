# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "0e2380cb98447775e5d21a7f48f44b2d83afaaa79df42dabbf2b0c8fd185f88b"
