# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "18b7c18030411c4218db9a4e16e0149b"
SRC_URI[sha256sum] = "1d9ff4dcea1e03f18969af6ad7d4d16a0781b8cbcc5d626a4c0cf2e14c9813c8"
