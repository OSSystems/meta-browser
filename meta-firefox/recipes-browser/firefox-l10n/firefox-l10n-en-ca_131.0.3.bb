# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c669ca9691623d2906668356221c2873"
SRC_URI[sha256sum] = "678b28dbb8567d0d5b6f8eb96600c4164d3471230860231a179065b1d41ca898"
