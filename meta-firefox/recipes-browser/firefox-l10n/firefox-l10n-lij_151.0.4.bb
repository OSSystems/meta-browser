# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "86bc0654764405c88ba73b715cc5bf16f91a166594416a632f15aafde56ca9a1"
