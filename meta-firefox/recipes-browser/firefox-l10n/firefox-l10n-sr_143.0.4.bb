# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "17df7d9da60caa257846efd57046faf2"
SRC_URI[sha256sum] = "63a6130312b84686a99f4e461dc3d5fe40c654d7197757bc219241fa76074248"
