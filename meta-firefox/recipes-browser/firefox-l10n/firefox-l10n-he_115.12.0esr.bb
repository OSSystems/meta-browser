# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1519a8edcedfb400dd961b4664da3e09"
SRC_URI[sha256sum] = "de08d4d7d4403d3a4f7ea7aabb9b46a43f49cb5b2676a1bcd429653001b14c82"
