# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d274acf58111573a93261b411222430f"
SRC_URI[sha256sum] = "b67bd758ff03d37fbce82e7a168fbdaff8c5ea39dc4f6ddc717dd189c19d95ac"
