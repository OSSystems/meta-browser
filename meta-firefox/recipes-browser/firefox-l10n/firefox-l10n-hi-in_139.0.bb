# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3a8ad9d1c774370e27cae4ae0cb982dd"
SRC_URI[sha256sum] = "4785b2aaf54820f1098f44df214cb5d30a6835d6b20c0ca76cb7cd4a6e58e1dd"
