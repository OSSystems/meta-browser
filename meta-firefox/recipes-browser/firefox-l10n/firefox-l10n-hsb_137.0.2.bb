# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db9b66630315efe511de4a3e68a1052b"
SRC_URI[sha256sum] = "305f91602b12cab1f4feacefe2bac65c2067b2f62461d69f6263a47e114e766d"
