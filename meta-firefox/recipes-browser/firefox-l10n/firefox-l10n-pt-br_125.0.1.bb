# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1eead392eab6fae6112704a8b998be2d"
SRC_URI[sha256sum] = "abfaf52209f35217a25110090fcea00ce7f63a5f6d9dce5464920a5f9ef97cee"
