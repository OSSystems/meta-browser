# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c1abb44158e06d23d20521e75f362203"
SRC_URI[sha256sum] = "e77a27afcfad4d7d0ec9ccda6fbb364116fc60d3611102552a68666f034a1e72"
