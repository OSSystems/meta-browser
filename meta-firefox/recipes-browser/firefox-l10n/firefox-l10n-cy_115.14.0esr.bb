# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "09e46fef4e072c9e45047d71b51c2ad6"
SRC_URI[sha256sum] = "dd44e8cfc4c8f5189b431291b979c718f2a7359e6ef1c87800609754130a07f2"
