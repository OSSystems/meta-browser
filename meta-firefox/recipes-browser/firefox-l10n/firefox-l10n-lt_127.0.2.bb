# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4959d719f8ea4986b4827f2dab6ee211"
SRC_URI[sha256sum] = "e134ddc920db235d79c823ccd6ad2ed697ded8cd9a4033b5fb5b3947f34cae42"
