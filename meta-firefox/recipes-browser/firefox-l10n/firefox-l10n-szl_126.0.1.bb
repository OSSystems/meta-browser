# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7b2910a87df035451ffa8391ca8a10bb"
SRC_URI[sha256sum] = "8e5559f3ab85162e457b203881023ce1612af58e75994783f84f72b985ab6163"
