# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c83779417a04796244e9d419dcdfc79"
SRC_URI[sha256sum] = "c3447825e90455483abea7e984a74b6c95ecc1b823273985a10d444110024926"
