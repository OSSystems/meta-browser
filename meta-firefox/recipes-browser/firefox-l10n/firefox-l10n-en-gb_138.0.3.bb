# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1a4b6b537d6767821ecd4857cb51be6e"
SRC_URI[sha256sum] = "45964509b0a0dcf653c24efcf5b74e46c9331229fcb7e1d333af1ca7fc15ae10"
