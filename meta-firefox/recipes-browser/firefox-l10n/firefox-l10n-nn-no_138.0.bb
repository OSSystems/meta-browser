# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bc78f9fc3d7d69cf31ee956ece2dd77d"
SRC_URI[sha256sum] = "01eb48125805e55c0a446124347c95b06de05be563db67505ebc98ba6288bf5b"
