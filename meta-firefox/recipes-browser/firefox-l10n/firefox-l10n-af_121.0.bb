# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1d241cde535a3435a181f93401ecd5e9"
SRC_URI[sha256sum] = "b92278850a2b533354c4808d3d1366835c7c0455605ac5fc8ea1b9db39aa029b"
