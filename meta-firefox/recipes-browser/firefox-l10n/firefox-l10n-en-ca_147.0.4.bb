# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c08c122a0c18760c88be080c3eab4ca8"
SRC_URI[sha256sum] = "c6722088aae801a458287ccd647d61655a1bbc29f7aec4fcd7b2181ff0c59f98"
