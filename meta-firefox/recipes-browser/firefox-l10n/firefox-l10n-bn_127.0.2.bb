# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3241fcb8892e87564a9d7c711b14ca7b"
SRC_URI[sha256sum] = "dadd22f2ffd38992bc103df39c923070309e293c94eb1ade78eaf3413d3201d4"
