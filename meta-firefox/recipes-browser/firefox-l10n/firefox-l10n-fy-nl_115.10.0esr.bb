# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "11e9c76ee8e58834cb5525f93dd32c36"
SRC_URI[sha256sum] = "eb90b53c8ca07a6b705bf5a83faa08bf3e55b52a9700afe0b4e42fb74e8ed7c7"
