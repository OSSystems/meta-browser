# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2a635e31d8fac3a546a94be656c211c9"
SRC_URI[sha256sum] = "c9f2b5b4d27949686a48407f96ef1c98d48dd17a285ddecaea8c544a0033e2a1"
