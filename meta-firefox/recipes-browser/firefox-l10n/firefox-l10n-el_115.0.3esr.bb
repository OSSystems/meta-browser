# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dfbf465ea16a0d1194e0c6eef8d1f463"
SRC_URI[sha256sum] = "37985b2123bc634a356433c3db81d4c97f400c95408679a4b7df4b44da8dc85c"
