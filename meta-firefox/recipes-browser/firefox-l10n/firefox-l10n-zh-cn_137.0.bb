# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2dd148eb854b2af398270ffd9eeee6c8"
SRC_URI[sha256sum] = "351bc149c4ef457649f37899702670dc5a2cfa433e1bff1bf33118783396b843"
