# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b57790eaa18a086c86309cc94e559bae"
SRC_URI[sha256sum] = "701dedbff1eb89494270405be43eff100e63e1102de28b10146b8b46f21101df"
