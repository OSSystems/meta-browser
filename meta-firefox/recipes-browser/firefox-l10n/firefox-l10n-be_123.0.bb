# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "90752bc2ad3a49b2aaed696492b40542"
SRC_URI[sha256sum] = "fdb156eea137104113bb1bb3f7cf2eddae6e914a83a8157ea5e7731783fba173"
