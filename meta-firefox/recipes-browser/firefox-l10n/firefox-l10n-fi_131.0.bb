# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f424bb161db5ce1b7062f79f5b451dba"
SRC_URI[sha256sum] = "74b6a3171bd1016fb84830e3f635972af79d37b0908cc8b879106503313ea7c8"
