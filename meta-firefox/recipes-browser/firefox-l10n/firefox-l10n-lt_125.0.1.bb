# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9c6094c30224c866629d66cc053d538f"
SRC_URI[sha256sum] = "6847dc85e9785a468dd2d574dc18bd5a8f5ff4c804b2b09973deb5a49861a928"
