# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "40e20fdb419a42062d448a4be45ca300"
SRC_URI[sha256sum] = "d6917a59280d7e35847d5fd05d0fe3b4ecf857b97a20c3cad94e6377f557ab05"
