# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "255bf2ac6f5adf4707169e4b51f633a7"
SRC_URI[sha256sum] = "c8f404ae6496a6d1868007f87625864346b4178e1d0003e7d98eae4dfb14327a"
