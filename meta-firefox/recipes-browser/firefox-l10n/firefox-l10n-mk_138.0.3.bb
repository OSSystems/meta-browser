# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "03cce89b20e1532923864d940cc198b7"
SRC_URI[sha256sum] = "47d72adaef181e478f73c8bbcaf2f943319518a024b9326f376f79cf85c60851"
