# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cb4fa12b211460b9abff584a782256b9"
SRC_URI[sha256sum] = "1b9df0fa5b5248be40398d2900abec33ca30e1df96ce871fac0fe61187186e86"
