# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "502527035da6cb48b6686cfb81b9fb8875e8fc03e96529d756148b158e451233"
