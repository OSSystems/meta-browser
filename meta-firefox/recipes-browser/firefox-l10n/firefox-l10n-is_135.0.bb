# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "24b6c134c096048e1bc75da596793110"
SRC_URI[sha256sum] = "c5ded9f79e0c9bd529e173f6d1fb10194150e1a60628ea2b073ebf04f51a6ff0"
