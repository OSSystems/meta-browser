# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9b5d4ad4d943652150be7d635fbbc3ef"
SRC_URI[sha256sum] = "03cb71f7470540b9a9766eed090df3e7e5bc9d50ddcc7cadc93969fd3048f5a4"
