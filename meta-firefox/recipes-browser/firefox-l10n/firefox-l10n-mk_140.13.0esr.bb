# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ae525e2c1eb0b0fe15e9bbba6a73300412cb12833a3e323aa04a44f4125f46a5"
