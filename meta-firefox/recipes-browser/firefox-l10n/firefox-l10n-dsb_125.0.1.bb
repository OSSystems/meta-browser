# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9b4e1e07b5dfc6a2bbe4a40b428ebf0d"
SRC_URI[sha256sum] = "3a5e96559ff7464100b05803620fc915696c2465c04cc5e0dd7b3ffe358cc7fb"
