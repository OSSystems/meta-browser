# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "56432c130def623f9ce821ec93a7ae26"
SRC_URI[sha256sum] = "df3f7ccf56e20fbc52781bf12e09fd77724f088d10538bbd8b5e2d74505cd35f"
