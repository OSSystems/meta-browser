# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b8d4011faf7ced63137b5ddd7fec3695"
SRC_URI[sha256sum] = "be97d993279e192da23de6385bfd2b1c887f26680c91cb24aca43fff2fc6fa7f"
