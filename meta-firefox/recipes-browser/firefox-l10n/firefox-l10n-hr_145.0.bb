# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bdf4f15c7d64725bbe7f218af345905f"
SRC_URI[sha256sum] = "cf6e90264c7bf8fb3c31cefd79d129fa2a5efe028d107fa02f723c5fae90e5fa"
