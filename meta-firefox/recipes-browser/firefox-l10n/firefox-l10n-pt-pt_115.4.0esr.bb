# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f791e57ecc3f42e1d4a0fa67a6f959d9"
SRC_URI[sha256sum] = "01b53b59d9006bc8fa0f8a7d7dbdf70d052cdde1554ce8aa8b0e99da7fe19d3a"
