# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1bd9f08e397955dbafe962c83d7f1152"
SRC_URI[sha256sum] = "8ffea447ee5f7ca4671adb8a750f9fde7579751454fb82cb581c3b1bf2951540"
