# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6d10cee43e3344ea728f132b2a415843"
SRC_URI[sha256sum] = "fc9735fc30a747b7528ea2156956564cb53aa5a8460cdcd0120d4082994cd68a"
