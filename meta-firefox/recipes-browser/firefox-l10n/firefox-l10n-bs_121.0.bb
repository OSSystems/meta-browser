# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8e41cfcfeca14cddbaef1ebd8107bc81"
SRC_URI[sha256sum] = "713fede677979e3155d44dd011d6f227bd789d9ba89953562443735fc4c3dac8"
