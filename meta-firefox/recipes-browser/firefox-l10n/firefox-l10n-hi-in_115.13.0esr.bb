# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a8dec82a1b38ab258f74a8a2e9d8026c"
SRC_URI[sha256sum] = "fc092cdc05745ba18eb38e6c0999dcc015ec7a09df21e6de4e90d39433a75cbb"
