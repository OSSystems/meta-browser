# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4012ced32c0af5b3a0f0f67fb49aa618"
SRC_URI[sha256sum] = "319c3c608b6f0ce5bbcf63ab578050a526cea83d2a5f14db54cd02c778435a10"
