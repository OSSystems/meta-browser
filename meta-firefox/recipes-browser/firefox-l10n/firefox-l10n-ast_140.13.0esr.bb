# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ccef355b1c3be5f0fd15ee685ff7a2b2919d168c1aa4d4e33d8351d8b4ebbbfd"
