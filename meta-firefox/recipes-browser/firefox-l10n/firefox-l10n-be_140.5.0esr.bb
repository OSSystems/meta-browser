# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "54a2b914d6b9fd0146fcfdbcdeb5acc6"
SRC_URI[sha256sum] = "79fee3f28f50fae56158e9ecee5191cbadf8675cf5103f46e13163e0f367aeb1"
