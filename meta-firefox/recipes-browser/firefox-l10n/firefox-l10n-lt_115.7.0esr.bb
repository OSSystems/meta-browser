# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8d2e3aa396bc82767bf803c4e7c44717"
SRC_URI[sha256sum] = "deb1742917658acdc990939e59905a0f55a6d7088b5e05739f47cd6dae570580"
