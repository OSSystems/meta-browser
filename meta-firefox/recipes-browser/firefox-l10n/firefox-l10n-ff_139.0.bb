# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e46c1e2b3daafff3acf06071f5338bb3"
SRC_URI[sha256sum] = "5b20bc38a4b3a8c63fb7654b978bcd03843584d15c456c9c62ae0518dda6216c"
