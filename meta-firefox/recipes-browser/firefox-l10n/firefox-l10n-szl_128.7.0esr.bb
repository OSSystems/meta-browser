# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "119c0c70326fc6ae61fd1e0d463e40a3"
SRC_URI[sha256sum] = "3b170a0234d8ca63bf7ab9e4407eb404c0b7991d4d091b70612a286050b4d692"
