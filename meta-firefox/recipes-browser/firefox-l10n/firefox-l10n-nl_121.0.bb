# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e27afd14aace87c7f5b4dda892f0fc71"
SRC_URI[sha256sum] = "672832137500a0a0f18f1895f9dba9dc2588bd4f8411d4a5b79d3131de779f34"
