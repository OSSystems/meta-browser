# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "74d9490aeabfcda837044ce1abd836c2"
SRC_URI[sha256sum] = "ac04c3001b2a7d495b2e7ae9c6932e7189d4ba7054a8f4147ee765fbd3479ebd"
