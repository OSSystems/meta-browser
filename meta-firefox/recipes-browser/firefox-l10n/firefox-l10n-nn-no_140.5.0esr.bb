# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cf0124a85deeedf1c1e3ee3df8e0f321"
SRC_URI[sha256sum] = "797317a279a8ff4adda3a9329a3db9cd33d70223e9c3de824494a868f9766470"
