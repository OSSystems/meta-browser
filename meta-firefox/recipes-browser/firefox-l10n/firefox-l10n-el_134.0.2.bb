# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8824534c08a087e2ddd40b6c6f8877b4"
SRC_URI[sha256sum] = "8177dbe9aa489d678fcc4c40acdad1d88b4b23189b1fba7189a2b90cbd0db496"
