# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "33d3e3fa058426cefe8941d8f1f0cddc"
SRC_URI[sha256sum] = "69db5260985e5017be5d58d3cdaabaea1d5a0cffeb225f0ab002a921d9f1a9a3"
