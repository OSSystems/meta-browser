# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a8b64bfee08dbd2f9797a7e6aa52e481"
SRC_URI[sha256sum] = "d6fa9713239c802551769a5deff6159dce8b0e8980a4fbb5a80b76f7ffb215dc"
