# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5cf91d8f7f44a3cb1de64968497bd334"
SRC_URI[sha256sum] = "bd34b9acbeadad8b7b741f35f627eaa00511632aebc97a5564be8fea1eb4e49e"
