# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cdb486d31f6e4453c96b75fc1827ed74"
SRC_URI[sha256sum] = "4b56eda2c67f4365be86670226ad63543ae1cce67ad0f42f0d39b5aff6860ff6"
