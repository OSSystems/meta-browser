# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "b178f0c6abb8040c59ef777fade063170f28edcc3637d33712d2c04fdacd9f0a"
