# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "31ddd71d30ca823dc06fa8352453549e"
SRC_URI[sha256sum] = "b03b94133a0a9f398f139446a3f7c0ffbe47cdf371fcae5069e0903ef96c960e"
