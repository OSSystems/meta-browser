# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0d9e07ebd05d1563453803020d48fa85"
SRC_URI[sha256sum] = "62fe836f6d4768ecada21cce9eb4433a1fb198e2b263388bac53eebebcdc61d5"
