# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ada4b6d83a4a9799c71a3f57b3a637a"
SRC_URI[sha256sum] = "c3e8adfabe079a23dec78fe6723be5d07688b3b5b06f16e8770df37ed6bd4fa5"
