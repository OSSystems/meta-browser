# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f29da1c80eaf4f96007288a7919a5859"
SRC_URI[sha256sum] = "ab6a8772c832c909624e6ed3afbe1a889162ca0ebf396147690a3420eb70efd3"
