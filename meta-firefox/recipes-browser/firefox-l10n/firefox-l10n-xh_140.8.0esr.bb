# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "28b5c93669407a344040f0d74cc90ee5"
SRC_URI[sha256sum] = "735db0d120eb9301d03a04e1c52ba3e12a16e0984dd0dc59075926f668b4c332"
