# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2e3133f4aec37a7ab61bebf4e557175a"
SRC_URI[sha256sum] = "5843c2ef965115f9cd6a7116259c8260a16acba79939fd592b062daee20a46fb"
