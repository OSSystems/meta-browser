# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6d92b1f90db90b5b0e7fa22af43f8163"
SRC_URI[sha256sum] = "c5c39c8dfdbeb5f376119978e4392e589df3a3e96fc00a1cfff9485f45ea870d"
