# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9e73a165ec5384d2ca61abd3c6f207b3"
SRC_URI[sha256sum] = "779b9db9cd00ae7907faa00f7108cce0208f16fb6ca530901a76bf1eee89d17b"
