# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1cc1cb8f2945bfe42edf11fbb919d1d3"
SRC_URI[sha256sum] = "bcaa76d10341b09f0d0856368fa819fa6b9e141007ba0b8232280f0e9e89bc05"
