# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4015024a1f00245d5e4ef64590a664b8"
SRC_URI[sha256sum] = "5ba20682ce4d9d3205133627896b6b1ca5366a9a290f953e602a23c9b91301e3"
