# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e72ba10aa9258fffb5b8af2c4c0fca91"
SRC_URI[sha256sum] = "e4cdfee0d7d76a4c656412f7ae7f53d8fc989ae82d50308b019169cffffcb273"
