# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "37e680a2fe6993b7aedd80b21ecef0f1c2aac195fc0664075aec86c981c5776c"
