# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a8dd98e39bd35c100d6f82816e8c09ce"
SRC_URI[sha256sum] = "dcb2dcddb3b1f8eee2f439298aa2465a4e14b73b4442de28927cd749e80d9361"
