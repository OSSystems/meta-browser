# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a4cbf02d5c9fa34ab1a825e0e1414afe"
SRC_URI[sha256sum] = "36556836c1aece87a9e1f620057378f59d1a27216417a7f320d772a24d12c922"
