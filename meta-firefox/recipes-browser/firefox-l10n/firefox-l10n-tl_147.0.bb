# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f4f2e3f6fd898875f23aa12bc05e8a3b"
SRC_URI[sha256sum] = "319798d8a538d3c8016afe2302de2c48c8d9298d4087631bbd566e560febd18e"
