# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "631bc223fc9350b09eac4e7a757c7c0e1c74b6835d4ba509ed1791c119d8ad96"
