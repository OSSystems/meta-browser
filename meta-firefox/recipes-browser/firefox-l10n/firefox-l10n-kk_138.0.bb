# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "019107b31fc7583251e22f4ecefd16c2"
SRC_URI[sha256sum] = "b9d8b9ba71b11a1b7db2ceea539123e3631f9f4756d57981e406c24c4d472b03"
