# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8bd70a33fcd724db1889169543c065c7"
SRC_URI[sha256sum] = "78dadd22bf912834ca2ec9ca4e145c90e9ceded97c964320e1e54c17498c6e21"
