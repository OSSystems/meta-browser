# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a45da4f105e620bcb36d4dba9081ed08"
SRC_URI[sha256sum] = "0ad61cd75466a9de70a01a19e37b9bb1e3257c50b4301a88af9683c3fcf10ed4"
