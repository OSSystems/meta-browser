# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f53623ed315ca169c49b87a4c595cf38"
SRC_URI[sha256sum] = "676673b7293340d252f12f11d15736554f12d16858a6bf343e28fd9adf7b1bab"
