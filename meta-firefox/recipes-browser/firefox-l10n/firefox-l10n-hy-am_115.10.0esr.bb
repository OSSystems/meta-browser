# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "22eb76b4383f8c136fefec2f612bf286"
SRC_URI[sha256sum] = "89bf9e72be700750b247ac7a544d3eb9610811a9da51fffcc0b730dfbb030dc0"
