# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "447e3bc1f1eee2b5f7fc4549e5d298c7"
SRC_URI[sha256sum] = "4e414f79a534af4c4099179148578653555f639363623c1e0d52ecab929d3d32"
