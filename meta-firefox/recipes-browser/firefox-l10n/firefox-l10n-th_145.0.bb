# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c7ff076024b85841b98c4b3cdbe2918b"
SRC_URI[sha256sum] = "9197573989203e33ad4467372ca358e998f60ad68a6afeaa9567b8d74ac6641c"
