# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e343cae058f600b2fb2acd691b310f64"
SRC_URI[sha256sum] = "6d9cc1e8588d2d6256631c80ac53541bdeda6fb64f8ee6a38a9b2dc7240e5974"
