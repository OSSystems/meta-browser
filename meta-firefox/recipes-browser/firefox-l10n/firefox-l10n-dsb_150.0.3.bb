# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "268ffb252c9f47e59fe01c0d1b9ef4060cf1b78ef3fbb29dc8e892e1910b1aec"
