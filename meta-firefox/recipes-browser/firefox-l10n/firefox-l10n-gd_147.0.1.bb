# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d26f70fc30c7d118165c6bc6dcffaf65"
SRC_URI[sha256sum] = "54a2aeae4a3a347f10407a69d25e5d98a0bba84f3d7a9cb5d05ba18a447b8974"
