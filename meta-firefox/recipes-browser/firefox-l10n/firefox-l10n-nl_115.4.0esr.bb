# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5ec5067b69d3f1b08e676aa710e76f04"
SRC_URI[sha256sum] = "3b961663a03b9817ed24249be5344fb572906c4dbc1c79c621b186848db552ab"
