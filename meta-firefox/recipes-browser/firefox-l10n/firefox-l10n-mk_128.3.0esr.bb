# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "93e9649a6b5777d53faefa289b324050"
SRC_URI[sha256sum] = "8c46e12a4304227eb04057562b2fa0844160f8946b4b908c237accc3ba52b323"
