# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "42ce26ceb9d11f25de924a0939192ea0"
SRC_URI[sha256sum] = "81e3f66519be477789a3c29e9e483fe829ca2ccaa97095b875b4f9f8bd3caadf"
