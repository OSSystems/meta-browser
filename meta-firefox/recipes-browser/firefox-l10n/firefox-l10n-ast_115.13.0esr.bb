# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "14936ff54059730f87d3441a0f254486"
SRC_URI[sha256sum] = "b5d1d1253218495b74ead0689168e9b0806ca042ef8076f106488abe6f84752c"
