# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "58842ffd1808414399bde5c8c00cdaa3"
SRC_URI[sha256sum] = "82def07dbc8ec3a60e4cd211056c24826cd85673581763e6b48b64e78d2c4f3e"
