# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "5aac31d14fe797c1f8ab50490cc8ec8f8975d9942e880c919b019994e34f5e83"
