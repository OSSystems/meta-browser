# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "bc3d9e11a6826408bbb93cfe19105044872a5041dd0cda51c1d788f4e312523a"
