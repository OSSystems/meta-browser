# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "825c62ce9f4ea43d6e8540330734aa2c"
SRC_URI[sha256sum] = "3806c04edce8c855898dd36f0bb946a1e80a8b3623a65e132d3ad9210f3c40b1"
