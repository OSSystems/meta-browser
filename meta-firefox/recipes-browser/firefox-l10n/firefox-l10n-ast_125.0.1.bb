# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "322fe9086411cb081cbace493822918f"
SRC_URI[sha256sum] = "63a092fef151e89c3e839ac2abc0956a5d6f2bbddd8640e048a6504030f53b50"
