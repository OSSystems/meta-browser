# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3f3044d8a362bfb77b2231d61833adfb"
SRC_URI[sha256sum] = "d9a9de249d3e0aa69ebc35e73e096731bdc1e001173025f110828b68177d21eb"
