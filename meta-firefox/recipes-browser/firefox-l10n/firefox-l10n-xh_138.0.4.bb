# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3c0c611b3ec7a24b1896d3ed8d3d56e2"
SRC_URI[sha256sum] = "73567c275c6b7a53aa2bb47a994c3f165b6dd5f1ae2dcb1c8b8f3d5fb784bcb7"
