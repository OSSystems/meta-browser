# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cbeb944f06f3fdb468a34246a17219f2"
SRC_URI[sha256sum] = "6d8ce74d7ad235d8b797c5196eb50804b9228bd0a3be78ae1e3b7fc03537bfba"
