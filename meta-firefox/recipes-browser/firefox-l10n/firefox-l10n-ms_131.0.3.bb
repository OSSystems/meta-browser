# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "753d49a6b341ba21bc6821731d7564c1"
SRC_URI[sha256sum] = "4800480f951512d76afdbd1a35c297c884214de136cde107d5c562474a711c49"
