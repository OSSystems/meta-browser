# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cb060958bf62fa15c4fdc3db2586d74e"
SRC_URI[sha256sum] = "0f88beab583a26bb4b5f0c8ef489bcb7909c6d64c4db6ab81a3431e0d18a853d"
