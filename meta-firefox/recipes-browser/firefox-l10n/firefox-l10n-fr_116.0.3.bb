# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "583b3c9e5db3b190b5a161134acad5bf"
SRC_URI[sha256sum] = "449fe1ac23a646a8d861444f2f8e9ff822d91c28e5391246757762b87b962e16"
