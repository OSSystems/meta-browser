# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5620ceaa57ace4746e486d509b619e3b"
SRC_URI[sha256sum] = "6a02fb6bb5b2d804f6c76e77bc53b5b2bb98077dd6c9a60eb58668d3690c2877"
