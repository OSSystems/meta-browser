# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "18bfcdc1495aab18a5fef1d73bb51e5f"
SRC_URI[sha256sum] = "075fac6b7961e11dc94244b672d90a7e1be03771103a4fd764a3cde5e585af61"
