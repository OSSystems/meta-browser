# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5077c78c8e1891442ad6c8daee911f48"
SRC_URI[sha256sum] = "23faefeac0e5596bccbc5379af68e4d60e39c64539c05460c44fad4f334c555d"
