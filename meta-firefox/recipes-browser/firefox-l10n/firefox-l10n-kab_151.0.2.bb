# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c2d9fef31c7aa1224ab161b1509d6c573dd2cbda8fd7cacc29513e64c14b736c"
