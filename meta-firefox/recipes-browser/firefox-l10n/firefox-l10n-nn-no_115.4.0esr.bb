# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e47888e2a66cbcd3193eff72fabd5ac4"
SRC_URI[sha256sum] = "3651ce0facd5b2179c635844feeda0a6b1ae55a7147f2e3ff8f3df9311fa6bb7"
