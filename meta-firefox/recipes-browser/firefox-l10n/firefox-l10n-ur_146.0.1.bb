# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d0318ca08f4ab1d0ed230830b107ea13"
SRC_URI[sha256sum] = "c4426bec62c9cc62a9c75cc090b0a6368011221b88385355bba2a9fe5a723f75"
