# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f14deb928d980f6908ec865b1849c503"
SRC_URI[sha256sum] = "4c4eb7d61c24281cf6b3842f4d1e5f981b711b9c85d10cf243f45a71eae66054"
