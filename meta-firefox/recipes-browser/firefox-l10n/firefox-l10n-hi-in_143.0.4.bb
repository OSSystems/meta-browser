# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f217934c5e2c49c5a5909c322c96eb4d"
SRC_URI[sha256sum] = "8d7eb495c3e142635e7d3e5d16476bc839791b145b51bf3f0984aa1cf73d686a"
