# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "8c7d687c75f5e1c344932394b968def586f9a401d269a43e56890f7e19d86e56"
