# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "06c0957fc46572ea8e07894873fafebd"
SRC_URI[sha256sum] = "15e9c5e4281d1bb985ff9e06eb4a8f9e9d539dc04e80c807edf29d4a2150cfa0"
