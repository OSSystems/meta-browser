# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fdcc6075cc8a43292a49dc772f0e1a70"
SRC_URI[sha256sum] = "9724879488b453a9ab0cb0892b97de902d1196e412f62c7c4ee47e195cf0c62e"
