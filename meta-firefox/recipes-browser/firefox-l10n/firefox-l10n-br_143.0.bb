# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "822a4a7f1ccf7925d38457b2796b37a5"
SRC_URI[sha256sum] = "2fa50224b43219d91991451d8315ec9cbbea657297ababd17ed894f84e7b497a"
