# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ce2138bac564e670c38cf233a4ea3ac6"
SRC_URI[sha256sum] = "daa5bb3d7343346cd7cc2995e15f021a42f8854d5ff614b8edb298ef5484a2ae"
