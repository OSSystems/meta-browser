# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9372f6c63a7e6e773f89bdf251198eb1"
SRC_URI[sha256sum] = "c848cd411dbf5c194d91c1f26181089de366993ecab4cb00897f5c4b80308635"
