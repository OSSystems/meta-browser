# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cc40695b807a6ae21fe3f6554a0114ab"
SRC_URI[sha256sum] = "51f45a1814a439dc9cb5a9a89aaa39ce93ba0b4318530c5f0c3832b74f3d6a9c"
