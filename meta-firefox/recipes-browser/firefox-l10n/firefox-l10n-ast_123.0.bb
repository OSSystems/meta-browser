# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e0d06cf99cc8717498d71b6b8740e4cf"
SRC_URI[sha256sum] = "2e842a0bad784802190ff1f3cb093a494840a4968599e2d57e5e4a13e01ea59d"
