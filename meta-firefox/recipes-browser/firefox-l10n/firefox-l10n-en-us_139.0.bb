# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1b040bf0045c3beaf3583969fb385487"
SRC_URI[sha256sum] = "9b27b0ec80c7fa30eddc1de28d542b7652c5a45c4f9f39c6b119da1174e4bd63"
