# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3dd389868bd70387ae61af2374d7b3c0"
SRC_URI[sha256sum] = "2c66b4c712bb2379e09657cc3e571a2f2cf9dbd028381a562858978613cdd5cf"
