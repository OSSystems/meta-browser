# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c4759dc81ac8d20d51469af1c1b98044704b2ae6a7c71939fc3a9bf1d171e801"
