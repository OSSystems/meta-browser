# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a5ee61c4573e6b61db5febf4cf87737a"
SRC_URI[sha256sum] = "0fd253209d26c4f47d383a4e5614a519b65ff4f54b5b8f1fe2fa47561edc1545"
