# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9c32434b00b99d79fb5869d12ee700d1"
SRC_URI[sha256sum] = "2ca51b21c40fb741219eeda21bc10bdb308fa14d1602ccb3ce3a1e16d570b6bb"
