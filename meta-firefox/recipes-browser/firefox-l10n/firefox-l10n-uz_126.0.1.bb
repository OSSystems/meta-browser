# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "896513ea8ac9653356a9d8983fd4de72"
SRC_URI[sha256sum] = "0974c147d0d679902d8dd3353fe152880e920fce81ba3687909fc56a69de915a"
