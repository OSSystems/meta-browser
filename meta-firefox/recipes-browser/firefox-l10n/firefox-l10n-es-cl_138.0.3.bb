# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ef5d90309b7d79c2b543a117148637e5"
SRC_URI[sha256sum] = "29aaf4cebc2c3bcfae354e36c275faad987e67b588876ce8a604a9ec943ca0db"
