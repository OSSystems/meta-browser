# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b1b18780ea0d44b8b2cc13611fd1228e"
SRC_URI[sha256sum] = "2f824aa0beed61b0dacef953c450759df135bbbd3dcd4b4414700aacf0c4f7ea"
