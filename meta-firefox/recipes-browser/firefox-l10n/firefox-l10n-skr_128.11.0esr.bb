# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e459e0129723c28317695a803d15d1de"
SRC_URI[sha256sum] = "f58fabaa429836449cc72efff9dd71637c59b1d8a7e015a1e728339941c1430b"
