# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b6ba2e5e7e7c00e87f06477030474b88"
SRC_URI[sha256sum] = "45cf4798d2c862a1301b6c72bdad6265cc7eeafed046aade7da3e4d061b88d42"
