# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "201ea5925eff7599d9e135c389666891"
SRC_URI[sha256sum] = "c6e6602f2a3d4b6574348675458c1b4f42d97d921bce16d15d2ca43d19c965f9"
