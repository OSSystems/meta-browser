# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b1711772756348aaa492a68c739b8848"
SRC_URI[sha256sum] = "aa7f173dd50d5c72f8bcb93cabae89a710a883efac8ba1bed241df5e63d75138"
