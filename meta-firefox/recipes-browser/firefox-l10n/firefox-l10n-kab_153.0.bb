# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "9edafd2ea84de4ccf480ddd11a63157ecbb5208359971759ca595a151eb4fb34"
