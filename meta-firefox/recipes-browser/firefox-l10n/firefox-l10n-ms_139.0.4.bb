# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0e9763cb124382e9aa29879a2bf18305"
SRC_URI[sha256sum] = "7c03385b4cf9a002e8dc187bd51d898e55f7cf958a272faa4fbcc4129aa7b271"
