# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "92e493a331bb5cf245608ea338dd212a"
SRC_URI[sha256sum] = "7bb25595078d9e06b316215f35f197e2d639821a45fbaf9e37880e2b41bac913"
