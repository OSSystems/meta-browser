# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c8f57a200f1d8af27bab882177ec49a5"
SRC_URI[sha256sum] = "b600a31b0fc3e07cd420965347bbff63e479951b81a9151f9e1ce4f4d90b7350"
