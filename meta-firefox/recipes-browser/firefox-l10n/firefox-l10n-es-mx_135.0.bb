# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8a9cc5330d774dac900c764c175c141e"
SRC_URI[sha256sum] = "3521feaad6417594d33b42bfe32943b96583658758169be97321682913d16960"
