# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9f99984a9fa638c2325be146d1f28324"
SRC_URI[sha256sum] = "162503671c5dc1d5970c4d16ed1b855153e75ca863d748ef60b7082aa5db3b7d"
