# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "14ffe2d36849a814511eeb1d11e6e94a"
SRC_URI[sha256sum] = "249540d896f11ae57a0e87cdf8f34ffd8acef7e894e63bb527c8b962faa2cd41"
