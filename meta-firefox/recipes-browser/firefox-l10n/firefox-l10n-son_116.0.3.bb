# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eb9f562024452e38a819f4c7fd47fd6c"
SRC_URI[sha256sum] = "c02e71877369152712a48292a1b394373d0c7e011599d75b5679e131fd4bbbb7"
