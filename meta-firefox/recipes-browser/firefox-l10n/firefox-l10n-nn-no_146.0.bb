# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "33bc87c3384fd2c7b66962584a7dc9c5"
SRC_URI[sha256sum] = "ff1186024a781ef0b62de985a28491e4e2b51886cc1801a3a27296d8d43a1f0b"
