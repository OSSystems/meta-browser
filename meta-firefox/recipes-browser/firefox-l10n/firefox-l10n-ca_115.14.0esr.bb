# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2a67220e1096685332bb18ba38fb5f10"
SRC_URI[sha256sum] = "c1c2ed88bf4b7d9131357357b9a99da55a2684a310e169eaa8b6ff2090c82c7a"
