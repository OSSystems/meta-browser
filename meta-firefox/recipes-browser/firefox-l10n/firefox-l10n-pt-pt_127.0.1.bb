# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d7acb455cb9d4e812e78e026c2a5d324"
SRC_URI[sha256sum] = "e9c6d7b39dbb3c5ca91b6d91ed89fe4d9b5aa0da78842ecf825555aa25297c8f"
