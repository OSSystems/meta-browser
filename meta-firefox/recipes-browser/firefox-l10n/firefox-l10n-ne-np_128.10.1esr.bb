# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f8c40379d37de4fd494a6ce944bc9562"
SRC_URI[sha256sum] = "f88778f67dd70c3667c7bd461afa9557a7a0e94c68767d68192b3e3caff2248a"
