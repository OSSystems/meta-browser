# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "660cfd12405a5649804eea7cd4163b9c"
SRC_URI[sha256sum] = "8d3371d3d3ba17be9a70dc35aa0b03b1a4dcc7082f5546a2ad09de96401dbeec"
