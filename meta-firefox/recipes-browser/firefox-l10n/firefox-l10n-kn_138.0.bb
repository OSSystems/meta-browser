# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c37b8263fb542b8084acccf01141667"
SRC_URI[sha256sum] = "45d543a11b6c21f8ba022695b4be7a23d28f3b90dd7ca4ac9ddb57936dfc1711"
