# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "accc712d71ee0a0b5c8134e5ec8928cd"
SRC_URI[sha256sum] = "6620bd13fb4b44cd790c2686b0110533fdbc87e8d5dce151e7faa736f13c44fa"
