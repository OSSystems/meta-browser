# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "79bd8a9c9654e1ec8a81818dc66bdf23d469d709ed0eadbed8268d3fd3d522e7"
