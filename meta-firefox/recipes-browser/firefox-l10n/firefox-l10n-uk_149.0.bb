# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c5d71439e54bf244c3eadba58a83b504"
SRC_URI[sha256sum] = "d163c6998ec3721d39ad9be25860e86895436a02423e2ae6471ec063074f7617"
