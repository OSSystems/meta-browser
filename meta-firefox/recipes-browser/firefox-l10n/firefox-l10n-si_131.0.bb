# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ea202277f7d8f0c064d8a573cc2440d0"
SRC_URI[sha256sum] = "877bb5d06b20d303965354e67ac874638d3ad53bd4a94a1e9ec70f272e9658da"
