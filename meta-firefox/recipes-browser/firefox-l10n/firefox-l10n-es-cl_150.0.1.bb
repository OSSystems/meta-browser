# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "6d2d466b17d858fb3e8d326043e27c56bb11084fe25788882943c0139d2c0234"
