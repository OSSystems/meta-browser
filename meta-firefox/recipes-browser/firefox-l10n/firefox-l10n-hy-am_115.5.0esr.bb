# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5655e7ea5fedff43b71b42138c14cde9"
SRC_URI[sha256sum] = "b51a6b8be8cee62ca5e956481e66bd1f13c3e14d3ab32d07ee55ed7d77050d8c"
