# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "33cc9e18d9a0d30e8e2f90e893c2f1ac"
SRC_URI[sha256sum] = "29ef6846ea40d5783e8ec950f081cadf1b81f07d09c9e44319524abdce8f16fc"
