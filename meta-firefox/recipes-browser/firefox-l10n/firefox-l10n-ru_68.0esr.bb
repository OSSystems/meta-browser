# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b032a72f06c8aa6d4316cfaf7969be83"
SRC_URI[sha256sum] = "23f5cb43f2373e5a35e4fd0e890db0c74a62ec23ec63a3576b133827173cf26a"
