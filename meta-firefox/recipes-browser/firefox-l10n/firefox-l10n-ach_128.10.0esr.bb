# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1ec9c8cc11ee9b13f0516f1919305355"
SRC_URI[sha256sum] = "0298fdbc8579ec47d88a3de20fa2acf3249b9058ab98a1532c6dabf3bbdbda2c"
