# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cfbb215d801be7c5170eb556c09d267e"
SRC_URI[sha256sum] = "020d12d9889c2dda035a6272cc7639656c7c58f2b04dd8ee6c1a452e2a35ca85"
