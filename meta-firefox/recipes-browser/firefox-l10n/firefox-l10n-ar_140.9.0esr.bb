# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "194840b1f05cb8918ceb681ca69b9b63"
SRC_URI[sha256sum] = "9f82f5a5caeaa09481d7b3eae23f1f6ca1019cad7ddb0eb464a91958f28b5191"
