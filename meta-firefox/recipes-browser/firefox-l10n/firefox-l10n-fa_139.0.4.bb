# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "45b723941dfe5a91bba40d34edfcc288"
SRC_URI[sha256sum] = "e7c69957ed8c470d3767f8577cad0b84ac56264657530c59a76a876e31db146b"
