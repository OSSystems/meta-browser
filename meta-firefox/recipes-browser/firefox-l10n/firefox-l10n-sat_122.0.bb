# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a2c240bc3a324657bc57cd72e6d0ad20"
SRC_URI[sha256sum] = "aefd9422be83ac34b5d460005a1bad659f5c971e83d03e24f4862c6ceb0ee94d"
