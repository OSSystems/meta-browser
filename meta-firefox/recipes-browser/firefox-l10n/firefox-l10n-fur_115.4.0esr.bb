# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3c624a19c1dc4113d66a1adb60af50e3"
SRC_URI[sha256sum] = "58930dda07c91858b1d8817ad03dbba6a4bb0107c01e8b327b1626f14545bcf7"
