# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e7729bebc03968ddb095f227369ae203"
SRC_URI[sha256sum] = "587048f453b007bade836893ecd15f63fbaee54d47c8692f83a33917b888f4eb"
