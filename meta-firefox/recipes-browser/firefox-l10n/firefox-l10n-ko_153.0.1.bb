# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "1614a57ed59d1102389e69ad920d2c48001d2d3bb91752c2a4ec1c26269cb930"
