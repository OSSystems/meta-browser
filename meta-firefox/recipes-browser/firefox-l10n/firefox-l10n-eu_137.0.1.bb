# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a4ffb83f3e07d70aa52d50e65775a600"
SRC_URI[sha256sum] = "e8164ab43edeb8319e42f3b7e9e99e31c32a6c0694dd69873839ed785831ce0a"
