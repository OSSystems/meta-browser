# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ce603f00cde38176e76ec23550b4e8b8"
SRC_URI[sha256sum] = "5df240495fa991c32d8738d6837e8d977c1952dc9fb81b7cb2e79ed27ea47786"
