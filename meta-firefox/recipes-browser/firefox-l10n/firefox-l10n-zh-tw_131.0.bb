# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cd4c998a1bcadaea49a4b419db0d23c7"
SRC_URI[sha256sum] = "0058098822763915214707c64ca7f17e9242d4b5005bd53bf6a3909dc869d7a4"
