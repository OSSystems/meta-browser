# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e462052eb682cdee111a7ee897301a32"
SRC_URI[sha256sum] = "603d01d8e16d460731802db7c912360c32b233d9fdef62fe905bd8e816d098fb"
