# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "978035d4d6de84954313ded68b8e1650"
SRC_URI[sha256sum] = "6bdee92990c131315adf3e43788580d3e1f07936ef01b9734011a11472ae0bf3"
