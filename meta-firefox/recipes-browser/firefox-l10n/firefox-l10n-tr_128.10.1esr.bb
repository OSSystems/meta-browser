# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4aac5d15a2b0881670cfc03429e534df"
SRC_URI[sha256sum] = "645077d9cf1a406883f3a2f2d5c80f850aeb5a5c5ebf2ba4239aa1b4319f9800"
