# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1fcbf18082dde68695990d8cff521cf9"
SRC_URI[sha256sum] = "ace7a68838f00a498ad2d1127278c98cedf2dc8c9252a02a315f3f925a618fef"
