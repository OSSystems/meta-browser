# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "bd7a845d9fafffb1860a444b712c18939b5d97686dfc895a749ac80df0cff8cc"
