# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ea1fce02b123fbd16e6c99e8aed8acae"
SRC_URI[sha256sum] = "eeef4bf899f2781a76752f96d27d6a4d6d485b2793f791ea976d7bd38868328c"
