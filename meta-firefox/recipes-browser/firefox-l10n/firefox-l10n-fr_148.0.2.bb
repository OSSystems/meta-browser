# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "10d5bbc95d2b35db5ef5e3a1dd8b669c"
SRC_URI[sha256sum] = "d2ad9cdc05506cc36178c133de2d80a353680274c2404ccf462b4e86afc0818f"
