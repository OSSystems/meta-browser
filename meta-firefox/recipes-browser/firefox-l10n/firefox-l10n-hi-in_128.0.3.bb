# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c8dc5de74c8b4457797b41e2b314d5ac"
SRC_URI[sha256sum] = "85b4d760bee55cfc2ff70f9a4db22f7e6870f6f4374a6fd3a35979c6cfc47113"
