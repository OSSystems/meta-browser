# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9650d793661f259bf72f2c7ced32fdb0"
SRC_URI[sha256sum] = "66600a7657ab77c6f3f4a41d079d7ffa25efa878a6d3a6b417c3c8ec0c9fb9b7"
