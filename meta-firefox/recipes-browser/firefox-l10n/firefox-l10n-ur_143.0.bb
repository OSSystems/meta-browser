# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f3cb7645cd40ee936d7710461daf339b"
SRC_URI[sha256sum] = "b55dfa345206adabb7fd6ecd623d22dae7a8a2f1ca87793afd510480493d0d6f"
