# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1c3cab65213f69567b23cf134de6d880"
SRC_URI[sha256sum] = "a139d23ebcff9c6f3e222d7bd6330e56555675e8411b3a3c41c31c70943de71f"
