# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "45683e741f9d8b9d8f9ff2d78615b690"
SRC_URI[sha256sum] = "3b8e4c06ef3ac9e6c0eb946611f455959eddac892f6e0b469ff0b0dda92926a5"
