# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f764749b23a00a57edb6594dbf4fed83"
SRC_URI[sha256sum] = "73d09d949ccb49dbb3c5dfa57fa467d7ac4aea06b441db6e4d74f0e2e8fda64d"
