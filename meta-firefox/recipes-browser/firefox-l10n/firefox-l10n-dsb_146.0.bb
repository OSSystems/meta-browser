# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ca16a16865c1b634696024071eda73f0"
SRC_URI[sha256sum] = "37e7de9198ccc8b950c85f9f1e464b9727d9a69144d5dd7c466415dd9f8c8219"
