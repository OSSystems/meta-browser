# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5d54629a8200cacf0d4a026ee80a59b1"
SRC_URI[sha256sum] = "0c991b9a1ad612650f76739b31bffe158213541bf490a061f92a731994da9806"
