# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ecbf3d45f3822f4321bf5701026d8f08"
SRC_URI[sha256sum] = "179b4fadd30d0c2a8609f3a1507d3d28010480aaaf9057fcd1d49ad5382f8326"
