# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2994a5345466ec70c8e73e24e5c82feb"
SRC_URI[sha256sum] = "31dffaced8ba2a7f23fa695a2acc0cfb73b16ce6ce8ee47bdd60a20df43ebbea"
