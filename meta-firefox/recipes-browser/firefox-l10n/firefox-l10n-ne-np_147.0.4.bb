# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6a81f2466a0c71a2ca7079ac4933fb9d"
SRC_URI[sha256sum] = "5dacfb32b817b699be1cadfb897b9743412ebe06a010ab3ec2fa3c9860e722c0"
