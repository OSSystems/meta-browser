# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7f01f06df16986ab6b4d679fdf4cbff4"
SRC_URI[sha256sum] = "a89f632652da8b2f234c9ca4ee5164b7eee551544bd390e566ebd5f399b1cdac"
