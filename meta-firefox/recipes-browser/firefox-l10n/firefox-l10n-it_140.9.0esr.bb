# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aac13ee27f6688b6a3fb6fe27190bd82"
SRC_URI[sha256sum] = "f7e7af42734181dd4c1d6a9225c7ba76dde307a8dde62ce975bb4e1091956715"
