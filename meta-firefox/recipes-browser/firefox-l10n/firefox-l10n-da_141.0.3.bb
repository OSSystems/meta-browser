# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "073fe22088a680b1d78087d60e72c2e8"
SRC_URI[sha256sum] = "0a9b9d05681047364d0877ed869ca040618fa7298c91f3e82dace30050559b68"
