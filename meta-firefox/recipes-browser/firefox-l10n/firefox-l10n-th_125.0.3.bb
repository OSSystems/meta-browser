# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a8ad96871e7a1c186fe5292f9dde4dc1"
SRC_URI[sha256sum] = "e04f0e8fe3943975f03987ba02019a3c6699afa5f136a168b2b34e6ae47345de"
