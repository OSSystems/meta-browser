# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "718ecd307d444af6c91ff38e3d9000a1"
SRC_URI[sha256sum] = "24eb1d3e0123eac563d3f69321e424a4d57651eea8a7843d5e124628f8e8be86"
