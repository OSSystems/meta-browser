# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3082ca9b68a45087564cec2364642002"
SRC_URI[sha256sum] = "c923e81bc688cfc7e342adad4af2d5b1e6564e8b5198078f0ecd237070fbd0cf"
