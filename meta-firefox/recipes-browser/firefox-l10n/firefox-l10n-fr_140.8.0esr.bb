# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e1c4cbab9d737f301b2d248544a35da5"
SRC_URI[sha256sum] = "f3168f45954e905f42610bfc419088b4074bf8961dccb9ad796db5aae7c31136"
