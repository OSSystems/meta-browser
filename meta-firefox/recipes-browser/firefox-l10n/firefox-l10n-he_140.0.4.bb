# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cfe745a439e582669bbec827703429a4"
SRC_URI[sha256sum] = "7ced70a07bfe1ab3db35177f8ce1880b21d4beb1f02ed69211dcaf2d004db919"
