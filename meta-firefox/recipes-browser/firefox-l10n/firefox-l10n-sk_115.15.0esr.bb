# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "76edf49cd580fcdb0cfc72adf83da24d"
SRC_URI[sha256sum] = "471569c7280cfaabfb52f118d8729fd62dbf2db7378fa04905d07ef06f0b8dcd"
