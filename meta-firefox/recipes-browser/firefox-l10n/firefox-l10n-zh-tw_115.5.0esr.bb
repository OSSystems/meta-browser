# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "58f2ab609b0ccf6de952d858d85bc08c"
SRC_URI[sha256sum] = "5e958d1f5f108586f57ed21c996757fcf4ba3aa0194dbf6086a8c5666d23d782"
