# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eb2fdf419ad4028c998f5c0be34c32ab"
SRC_URI[sha256sum] = "5e0157e94d17d79bd12b0ac8f3a7e6411702a209e2cac244bfd8d9485eb7d148"
