# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a50839327b95259dbe7dbd0c00b75841"
SRC_URI[sha256sum] = "6f3bb3f78fdfe739c9024d1c248a6df42de75562ee3670ae03adcf24de9dcfbc"
