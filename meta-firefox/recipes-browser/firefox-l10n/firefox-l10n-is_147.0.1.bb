# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0e6cd3da2d94c7c47ed1e06d36dade24"
SRC_URI[sha256sum] = "2a5888ecb72555157960568941751f1011d46b85e4ee8b97d2df7fc3fed40066"
