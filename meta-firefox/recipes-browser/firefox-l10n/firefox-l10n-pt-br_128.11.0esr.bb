# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3aff13038c93cbd46cd86afc9d7d4dfa"
SRC_URI[sha256sum] = "4da94f434c0a93cebd6254209101f3607280b30d5627d775a7544ac2a16c4a74"
