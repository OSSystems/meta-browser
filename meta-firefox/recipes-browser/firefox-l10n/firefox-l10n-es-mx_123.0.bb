# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aa33c0c007b67f1bad71d222d6663e44"
SRC_URI[sha256sum] = "bf9968dc0fdff891f1890760597b05f127ce20fcab0c6b5829239cf6d81e63ef"
