# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4692f6d441638a1d0576f675b52115d5"
SRC_URI[sha256sum] = "f048267ffc3e62cfcbff25f44986a6e073645b129c5873d41f9f3a7fd246db07"
