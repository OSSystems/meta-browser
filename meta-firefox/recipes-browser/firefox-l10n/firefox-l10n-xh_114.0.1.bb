# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e92b652e575293c25d50547a1e1c14d1"
SRC_URI[sha256sum] = "ddf4ea86a3ad7ba5ca6cee6d68c7cba7cf0d52f7fc8ec02da95a525123905a55"
