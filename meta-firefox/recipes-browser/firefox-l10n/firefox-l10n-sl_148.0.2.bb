# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ac192b8d2904fad31a6f6bce91cbdbca"
SRC_URI[sha256sum] = "635de6452961dc9cee9344614c33b3ab33fecd57a4d468caf5ff92368e199890"
