# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "099f3f1358f0d68f6ee1e901a29d1b9d"
SRC_URI[sha256sum] = "4444d51e2a8c07b9c1bc1f1f75f0250ba90d0220d7061df60f7ad2e6dc971b75"
