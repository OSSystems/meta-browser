# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fb909e1157a4d6f63232653292e288d0"
SRC_URI[sha256sum] = "95940f49fc3f6ddd580f2c472807c495785cfff41b5c7c0b42f80d0aef5fb4d7"
