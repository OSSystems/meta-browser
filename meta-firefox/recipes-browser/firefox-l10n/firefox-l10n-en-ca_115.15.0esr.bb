# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fcfbe24e12a25b0236bdf4ba03e6a119"
SRC_URI[sha256sum] = "bd255f6a23be54ea6b3e22c3bf1e1d36c231b2db439dbcc7f3543eeea055a9b5"
