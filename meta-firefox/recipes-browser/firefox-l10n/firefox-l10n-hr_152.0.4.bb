# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "aec5f90ac5c7b250e2ea6c564eb6997bd362f94a23cdbaa487d311803b3a6242"
