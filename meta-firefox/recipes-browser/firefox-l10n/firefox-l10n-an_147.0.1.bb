# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d48b40d6992de5655fc61d134e7a0e37"
SRC_URI[sha256sum] = "b447a5d31237ce786b335ad51cc0a0e9f49e36ecf5d0db194f48bd579eda9817"
