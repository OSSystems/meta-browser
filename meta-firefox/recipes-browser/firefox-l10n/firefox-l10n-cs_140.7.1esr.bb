# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a9c4e08521c216d2f7d352033e0a77b6"
SRC_URI[sha256sum] = "975dc7fc14730ff6529f0412a8b538ed56197c032c95859a3251c7a436a5e98e"
