# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "79ad910e5282a103a58d106ee28c2df4"
SRC_URI[sha256sum] = "13482ec77ea8f2a3e7ec9565cfc443d341f0a300ae937334854abca35fa61f77"
