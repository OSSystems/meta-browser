# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "27abe2f798d6f35db1f8bbe03ec16bf2"
SRC_URI[sha256sum] = "a7756f27c136997a2ec545b8fa80cbb82f5e29fbf59ea170556c3ec96a4d4c4c"
