# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3da41af7ad8fd92749da7c13aac19d7fe1052f268e758939bb3e59fda4e19158"
