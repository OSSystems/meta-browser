# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "345460d30dab6eefdb9f19bf176b0d55"
SRC_URI[sha256sum] = "5d3596a9228ebd52d56aa3666f4fdcf5b096ea7cabe1cf3cc4e3e62b9cc89fcd"
