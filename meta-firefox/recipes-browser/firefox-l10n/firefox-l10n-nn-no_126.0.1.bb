# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "374a265255204610dcec4521fda3dd52"
SRC_URI[sha256sum] = "c24c4f408037e5bfb412c453959cd05c24dff4fe7b2332f0ed1c737851f9a1f7"
