# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "dc32b8f48c6eb64ffacd988ad7bc59a52feb2468573153756a9697d999bbb3ff"
