# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7ee96f5fd095a895708ac1c3f0287690"
SRC_URI[sha256sum] = "33cccc5fdf62cb746522bbeda86fa7a44d87033db8be494aa6654b1c4b609cb3"
