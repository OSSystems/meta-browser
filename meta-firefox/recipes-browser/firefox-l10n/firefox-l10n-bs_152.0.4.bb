# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "f919cc8fb2b5c90b6e450ecad0ab6619021d5f6df5f04b29bc0c4349d8b3fdea"
