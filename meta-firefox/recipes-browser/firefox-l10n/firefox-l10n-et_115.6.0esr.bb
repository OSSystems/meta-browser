# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8b7f1cbf216038177485750ae0a07b0b"
SRC_URI[sha256sum] = "5aa0c6d99b7e4b0fb6a768216163fbf5d61a684043b8e7a474598cc19b773f22"
