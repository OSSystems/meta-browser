# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dff8eec5f842fc3ebdc5ad06f7d8aac4"
SRC_URI[sha256sum] = "b4642569ebede903de882fb36b3c612b9695a7a2a48985fd989b5e503a70e242"
