# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "59b854fa5ea02e10c3b5c979b4742290"
SRC_URI[sha256sum] = "36d31f81924d69ccb5bf38bebcfdd1928b152a9b446869c7ffb0dae73f69d629"
