# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4f843aafa001159647b02a56e22fc4ad"
SRC_URI[sha256sum] = "f6fe5cb7af3554a8adc37cd6b1d7bb39db5bac8c419bbf4eac0f7f31d28ce941"
