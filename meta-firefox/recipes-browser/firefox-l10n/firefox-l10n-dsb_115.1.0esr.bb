# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b6fa4ba57dccb47aae13de1fa02ccf36"
SRC_URI[sha256sum] = "af451f6155c23b0ba8e04533760a1b3303d4f6437a74d8bddd9525ba3334478d"
