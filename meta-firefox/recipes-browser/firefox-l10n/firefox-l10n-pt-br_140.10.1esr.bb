# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "abde601f55be4aac4ccdd32ee442fc8e8e62a54cd0b4ae6f929ef1fd784270d9"
