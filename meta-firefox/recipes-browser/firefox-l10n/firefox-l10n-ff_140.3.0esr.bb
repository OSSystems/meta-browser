# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "37c626a8d371bfa772a351d4e6818181"
SRC_URI[sha256sum] = "d0dde0686718ffff82a0bac7b84de87d223399aa76ee18954063958cb30774f9"
