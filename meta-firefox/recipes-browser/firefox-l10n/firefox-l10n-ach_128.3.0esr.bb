# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "450603ea82c48d7973cff6e0bbf0c8f5"
SRC_URI[sha256sum] = "444bb2a1fcc1e888ad58fff7649e8581962006e7af5c18137aaaed0b6e8927e1"
