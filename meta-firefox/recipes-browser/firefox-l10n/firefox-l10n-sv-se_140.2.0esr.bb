# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a8f211f6a99aca4c5df85bc2b6d2f6d1"
SRC_URI[sha256sum] = "02ab299017fe1b550af9c91a5150c8cb60d23c3c0d191ecd2c5400a95da20891"
