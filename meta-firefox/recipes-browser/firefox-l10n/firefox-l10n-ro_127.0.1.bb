# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ef4b180c7da9301881c5b542cde15344"
SRC_URI[sha256sum] = "e264328c804d8085a1bb0efb42af76e7dab897a9f22b514e6c6a80ac8406f4e4"
