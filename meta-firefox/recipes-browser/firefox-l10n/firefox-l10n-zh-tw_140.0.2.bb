# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "25f85a2db5abb60758199ac875171f82"
SRC_URI[sha256sum] = "0a1effb62c70f45b4ffcd870db585b0c4461379c238dec23a5a3b985e955498a"
