# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d72d832aa87d5a2733918afdd15ee224"
SRC_URI[sha256sum] = "60d741f99f6a1d8dbd4bff90ec977daaaedc238fbab45f6ddc5df9cab2cc5854"
