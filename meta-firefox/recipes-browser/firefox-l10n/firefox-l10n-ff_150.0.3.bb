# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "79eeb1474d17a79d7cd3fc5b476b534f919152551375e045c4a830944e73d2d3"
