# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "08b280779d8e763b0c280877cef1ec79"
SRC_URI[sha256sum] = "07736cd3482529048fbcc98f9e400abb8869752558677bfaec9adaf87645f0f9"
