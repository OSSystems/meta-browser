# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "03a03f82f57adff6b4c1516828c1a450"
SRC_URI[sha256sum] = "d0de96679e4f6cb29aa8177e73adbdd917c0fd70b51f887aa6cdd563088cf263"
