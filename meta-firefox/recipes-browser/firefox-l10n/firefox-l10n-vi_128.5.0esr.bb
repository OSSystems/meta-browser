# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1917749b71195e9fb1f5fdd5b1281775"
SRC_URI[sha256sum] = "f62ec877904fdbc60480ae6a983caec74733a9dea601f95bf50a26bcff7c4240"
