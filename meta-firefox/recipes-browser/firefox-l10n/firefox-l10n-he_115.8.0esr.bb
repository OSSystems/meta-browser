# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a6ca35c8c4330cde225351dfb43c1e8c"
SRC_URI[sha256sum] = "593200f50ffd93b23f53220e670182dbbcb4f1038d5da32eead8ecfebc96d5ab"
