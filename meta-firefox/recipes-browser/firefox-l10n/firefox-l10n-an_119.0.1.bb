# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b273d2da6edec7bb88732d37f2924fc7"
SRC_URI[sha256sum] = "42aedb8f342d0efd101f47b91c941b4cbbfd303aff350b37a67a253f7a3a4b97"
