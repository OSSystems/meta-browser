# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "66acfa2de483efa11bb4a915bd03921c"
SRC_URI[sha256sum] = "bee95d4b303d60c7b604b434037661e971f0b5eab3bd089e15585b65ae84bae0"
