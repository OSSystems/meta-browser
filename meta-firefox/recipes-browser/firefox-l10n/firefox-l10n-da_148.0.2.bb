# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "acf7f2494017f99fa3f759c78a5ed648"
SRC_URI[sha256sum] = "13faf57051780c54cc10c3f098e02f5a06e953918f5fae8fc9097cdd6b0023ca"
