# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "29ca68baeae4b3a1122d9d18e9d35b11"
SRC_URI[sha256sum] = "a02b05103214152f13e1d1c817f8a90a2347a508a018eae7e4633c4d28085f64"
