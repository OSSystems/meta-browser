# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ff460bd58abee5ebd024f9caf3eb2c40f514b5cee23b4b8bc30c2a5660880d45"
