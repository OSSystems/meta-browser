# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a75790a4cae2784a8c32670983587cb0"
SRC_URI[sha256sum] = "ba833eaeab80bfab4131e9d59846b2487bab177a199d0ae746ed8debafd1cb1d"
