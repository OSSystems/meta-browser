# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2df0114ea1c06a4a1723dcfa98539fb0"
SRC_URI[sha256sum] = "5fbcf390f2db6a7c09ecd22481b2241c1377853c01f276494e7edfaf5d5ce139"
