# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ac651de8eedcd3128faf3fa099db1de6"
SRC_URI[sha256sum] = "0e150e1e98ffc0af567a9a4bd22e93a116c31b49a3cb2f9c0f5dd218781dc447"
