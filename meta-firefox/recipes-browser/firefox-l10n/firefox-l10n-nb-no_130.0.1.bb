# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "71ca3938a82fd6ecdb1baaddfa5ec670"
SRC_URI[sha256sum] = "0f76d69f543c5400220c9f2f3ef0ff880d83f4a258d751d2a6ec516385825f29"
