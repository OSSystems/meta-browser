# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b99d4c9056926dadfb9f229e60996d8a"
SRC_URI[sha256sum] = "6a94027d53731ab0163276719c7515142d471e5ab863d12a78552a0a5191cdfe"
