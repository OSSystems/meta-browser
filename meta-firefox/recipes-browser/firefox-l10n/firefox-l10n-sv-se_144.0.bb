# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "659649e69cf0a8b8e3839c7eee4d0360"
SRC_URI[sha256sum] = "8f36e392b61965d8e97115ca7805c3b90489ec1d7023e0178b2b649588f50b99"
