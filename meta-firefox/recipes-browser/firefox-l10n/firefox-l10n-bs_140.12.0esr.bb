# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "1c2020ddc988a49f8a61c17bcb0dfce98dc55794333e3d1d338ebc236f6091bf"
