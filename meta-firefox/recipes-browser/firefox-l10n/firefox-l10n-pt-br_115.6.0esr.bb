# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fb5ef12d502c77a67ef6c36343c49b58"
SRC_URI[sha256sum] = "032c90e83e57a7852e32dd1c057745f8b91ccafd4e760af6666519b4b54eb908"
