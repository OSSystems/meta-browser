# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c067bbd0b730feff8f325680b0392a2b"
SRC_URI[sha256sum] = "3e53ec8c4e4743bb610ca5d534052ca0befd2a254f054fe4ee018571713f2fa8"
