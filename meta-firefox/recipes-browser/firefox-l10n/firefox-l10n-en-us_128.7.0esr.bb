# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8d215470a7587af5c989b4b707f9a301"
SRC_URI[sha256sum] = "a15519bdecc76a0363d2283a0e900dc31b56f57934996af87c153b6b4a2e4dc8"
