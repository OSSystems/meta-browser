# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3fc65c793edf12e60434aa2213285548"
SRC_URI[sha256sum] = "c1660a604b09ba160d08808214015be30bb5cb6c3e434f3b9826958c15cf1999"
