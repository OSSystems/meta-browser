# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9832fc1b33fbb6ab4b9b7f6ca75b48de"
SRC_URI[sha256sum] = "5cb8fbd34d044fc5e565b6389e5a1940334e022067554f228a1206a29363f458"
