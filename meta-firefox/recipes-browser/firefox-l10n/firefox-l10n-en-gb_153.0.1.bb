# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "14ef1fb3cdad24e2b60163c425fdcbacf3ed6ffa244a07e3802e3ea740ab8894"
