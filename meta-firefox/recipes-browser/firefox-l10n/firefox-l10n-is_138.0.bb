# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8734933ac116f15e1511f1d9db885c38"
SRC_URI[sha256sum] = "560f9c6368e38013ba0c2221b8a9c81f3d3ef8ac0cb447153847f494defd924f"
