# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ec12e40f8f6bb5fdc698f236c1c2f66a"
SRC_URI[sha256sum] = "7ef0686c9a98a18b11513fbd6ab76ebfc823c025815ab94bea1373898e7c76ee"
