# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "df4fb8370ba771d02d264de2c4954430"
SRC_URI[sha256sum] = "8155b5f06d23c13fc91c4468e0e375adf9c222de9cfb7209d625a08d245fc640"
