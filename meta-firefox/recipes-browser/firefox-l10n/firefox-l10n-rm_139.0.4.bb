# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "07c93df8a8f297edfa7aa898f4dcac5d"
SRC_URI[sha256sum] = "c78cebf4a78c8159682403292593e502802a49a3fae4c92490b0f6d3e3ff9f55"
