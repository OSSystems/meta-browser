# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7d018c636227f2b0c507c87d659ebffc"
SRC_URI[sha256sum] = "fd020af4364be4c9f715d71ccdf7446c0ee185623c246c2341d6fb522fcc4a5b"
