# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "94955fd89ddcd9a4ffe4bbd65b76df5f"
SRC_URI[sha256sum] = "0fc13aa75798e4a00017f84d0776d1e8dd812feffed8676a4918769ace46fa02"
