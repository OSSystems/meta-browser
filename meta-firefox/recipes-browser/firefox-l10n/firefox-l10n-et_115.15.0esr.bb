# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e893c6dc233af6987df4c8e0965de548"
SRC_URI[sha256sum] = "302104708edfc7edd44c8cb2d8f201a2d3f746f217a42969cc12af80a9428caa"
