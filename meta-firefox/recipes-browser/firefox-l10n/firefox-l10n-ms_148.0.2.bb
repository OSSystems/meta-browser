# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8e631ddc42ea7a5a47d8519ce602c20b"
SRC_URI[sha256sum] = "fe08dc1e0b792684a23548d232a4e74e91573c0918569f1cb73603edebc433d2"
