# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6f82c33c8029b1d6d867d8073d157135"
SRC_URI[sha256sum] = "5ebd9068073c20b207bc738e1c81983a3d1ed09b669a46bf30e67a621146353a"
