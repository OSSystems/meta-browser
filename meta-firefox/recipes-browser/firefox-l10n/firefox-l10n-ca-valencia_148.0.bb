# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "312adb453da67ce7c0c4c1e271302925"
SRC_URI[sha256sum] = "1e439ebd80546e238463442d3a99933e79aba5b755ab1454a032b53ad72a091b"
