# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a53b878abe90f49c5935d9e17263d502"
SRC_URI[sha256sum] = "8706795aab0d52294cdf3f2d30051b6ad67f7ad3dcb89d8401b2c695115c17f4"
