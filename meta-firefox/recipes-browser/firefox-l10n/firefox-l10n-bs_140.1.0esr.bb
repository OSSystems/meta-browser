# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "99c582c9096b5b580616c8b982f22394"
SRC_URI[sha256sum] = "3bf049a8adf17353edc29231e969d0c4bd5bb107deeb9f9d2f7b72edca62e11c"
