# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f381384381afb86ecac3e7c496ec64e6"
SRC_URI[sha256sum] = "31af1035e1b664cef8b7a46912c52530d5c09ba8f4c6f0273c2aeb88e4ff7d97"
