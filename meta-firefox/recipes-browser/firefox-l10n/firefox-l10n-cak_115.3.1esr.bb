# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c26fb7c1416a81a1bf2168701ea6ff62"
SRC_URI[sha256sum] = "8b60eab3018c79a350d33766e993eb853c9e7dd41de76539aecab145892d2bab"
