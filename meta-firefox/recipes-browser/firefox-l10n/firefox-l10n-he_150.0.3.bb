# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "6576481b0cbd0e4ae2d7f777eb1603086f5a94a17c64b326897be85fd21c5b0d"
