# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "826e9425323da331e05c212064c5086f"
SRC_URI[sha256sum] = "9cac15649eeced86e37c89986f3d8c65c1e7dbc9c3ce405be711711e44739f0c"
