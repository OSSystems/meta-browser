# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "741358e7bd18ea77342148c0c1688263"
SRC_URI[sha256sum] = "09801f13ec751404639fb0f573010b9adbc88213cda32de2514424765f45589f"
