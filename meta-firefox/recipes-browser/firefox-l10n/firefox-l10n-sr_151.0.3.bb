# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c68203e108dc1cd8765fe214089615cb30e5d7045dc7cce11f0b27449f088254"
