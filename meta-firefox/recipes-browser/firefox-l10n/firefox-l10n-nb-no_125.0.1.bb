# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5ba75279c3ad9afe5a06c30c91fb2438"
SRC_URI[sha256sum] = "e00b64bb5ce1d17edf2dbfdf6ac9576cee2278ee9a6af562fdd6354b00092886"
