# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4dcab15f6309bdedea32d9dcf0a6146b"
SRC_URI[sha256sum] = "1345f55d28cb4bbd0355d3c02597c4668b99c6f6ef939635de17e17a7cb8ff3e"
