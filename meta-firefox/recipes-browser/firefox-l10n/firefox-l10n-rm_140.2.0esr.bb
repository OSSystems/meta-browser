# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "704258eecf178b330e2394402cffa17e"
SRC_URI[sha256sum] = "7efe246478cbcdc1ac7af41c6c0ddfe5a5252ee25ac13afec0ed59e6ef3ecd5b"
