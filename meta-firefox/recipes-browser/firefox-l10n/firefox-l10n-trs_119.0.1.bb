# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c1b5591544911b4804040040ef1f2b41"
SRC_URI[sha256sum] = "1115001609ad9c739bee71d707faa4f77665fc6acb817c60fd58c91eb3601f9a"
