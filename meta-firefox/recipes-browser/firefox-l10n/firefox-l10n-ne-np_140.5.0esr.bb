# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2189c8c6b3721482ad47b16e568ff2d6"
SRC_URI[sha256sum] = "2e710e1a49adbef8301e2358b6908ec20cef80dc5c9cf91b4c275383ba5459e8"
