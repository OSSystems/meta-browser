# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "89e6e7cb8a3c834e510967710cc2cdfa66cca398b7320172b593bdcc6ff3d453"
