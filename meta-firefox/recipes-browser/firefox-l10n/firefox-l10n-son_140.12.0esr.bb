# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "02fc54b5b997fbdc0d35d7ca949315781aceaaa17d6735991f4f4ba246077cd5"
