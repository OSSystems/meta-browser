# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aece603938ad4437630d0647a46e0152"
SRC_URI[sha256sum] = "db6b0a6350203579558e8d880c59437b4c9664a02c91126708fc42f4bb727224"
