# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ccedbe973fa87c8123e1deac5c50319c"
SRC_URI[sha256sum] = "b6b9539f7ec0e83090f46468429726cbcf5ffc3e8eac213c264a5608101cfceb"
