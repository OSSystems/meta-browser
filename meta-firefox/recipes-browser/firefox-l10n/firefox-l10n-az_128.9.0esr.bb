# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "91379cec2010abbf1808ce28a1e8cbc0"
SRC_URI[sha256sum] = "ec194ed8e263f64f291c1e3392d5f9f78367d0c4718898fda881894b1cd91aaf"
