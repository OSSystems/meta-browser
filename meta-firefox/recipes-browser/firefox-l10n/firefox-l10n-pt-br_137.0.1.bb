# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d3fc0ec16efb7cb4f482b5746f202ccc"
SRC_URI[sha256sum] = "f208c01e67cb14fa2e525b1e3e1f23ae2fb227c45f51d47709b921f98ac421eb"
