# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9f0d4724e10629dc29dc0e60be507612"
SRC_URI[sha256sum] = "d224dd3e07f51e7f5cd2bae944562022421e65e0efd8c7639d909f21e06d3e8e"
