# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ff5fddfb60f2b59c7051bd01f439465a"
SRC_URI[sha256sum] = "56d0c2fe940b7e4b9510ffa65daadb782e7298e943e0e13895a5a421592b67ff"
