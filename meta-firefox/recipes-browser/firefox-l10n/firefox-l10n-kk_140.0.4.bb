# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "736b196f2773e00610c7b3e0fa33fb98"
SRC_URI[sha256sum] = "6c91001f6a97ed168652777ac132bf62282f2489e2884c0449023bc1b2435533"
