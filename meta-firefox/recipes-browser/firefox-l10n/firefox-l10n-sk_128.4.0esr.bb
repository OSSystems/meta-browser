# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6993820efc6c6988055b1838f6a0d5ad"
SRC_URI[sha256sum] = "dfb43fc246b5b5199280aa20526b4c2b70c077601d135b3e97e97ff4275a330d"
