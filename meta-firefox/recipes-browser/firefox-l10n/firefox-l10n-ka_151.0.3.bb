# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e3d89a105f072b0962629c5241a3d5f990f17c2b40a62b6207d30cac87b22b2f"
