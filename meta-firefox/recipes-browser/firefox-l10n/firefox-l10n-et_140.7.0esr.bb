# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "40908d306fe5f8022ce74d1139618a26"
SRC_URI[sha256sum] = "5aa09c9d83a84f7a5ede85bc7ef24f54e94eb0cf3b847fcd9f8f2cf10a595e65"
