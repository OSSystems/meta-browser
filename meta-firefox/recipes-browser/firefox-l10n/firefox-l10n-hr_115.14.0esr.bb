# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9b186c03b50be03307df222075bfead8"
SRC_URI[sha256sum] = "ce5efe7e86156aaff52d9aae04a8eb8778e2d56e3c80ccada453dfa03a7593cc"
