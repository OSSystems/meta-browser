# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "deaa6668f9d12e52ced32e857b99c62b"
SRC_URI[sha256sum] = "b70683858c47ff2e4fb33ef8a0052c57df777fa77bac00c73d65f0b647188423"
