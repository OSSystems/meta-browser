# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "945b476bb4ae565250deeca48c057c9f"
SRC_URI[sha256sum] = "c72c2377a03abe57c57c15d48464a47a4fdbedc486c06ec6a8e01463a0427c47"
