# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7b722d4202297eac05f3e79a5538895b"
SRC_URI[sha256sum] = "50ed43614b8db4e0d6c523530c8fb93c778466d6dc0f63aed5eac57bc3465dab"
