# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "479c26bf293bfa90942acc6c5135eef5"
SRC_URI[sha256sum] = "ad12ed10cd01e1c127ef7310829dcc375125ef051318fbbed52e364afde6ab8e"
