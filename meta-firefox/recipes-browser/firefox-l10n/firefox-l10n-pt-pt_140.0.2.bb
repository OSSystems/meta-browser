# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1916299c82d40e6f21c60069e560decc"
SRC_URI[sha256sum] = "c2512745f8023738ecf2d0fd82dc2f431f59e1a67ae0f06fa9b6630606c65e23"
