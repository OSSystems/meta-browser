# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "251857a547a1935d216e15104b5c99ce"
SRC_URI[sha256sum] = "8572853880cd215419ee11d75441fc86f37fd29016959a78fed9c04e70edb065"
