# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3d47b6ddca4eecad8c0e633256ce4adf"
SRC_URI[sha256sum] = "93ddd3b6e327b4888571675a4679aa0b33166ea73fecd82ae2b1c6896709d936"
