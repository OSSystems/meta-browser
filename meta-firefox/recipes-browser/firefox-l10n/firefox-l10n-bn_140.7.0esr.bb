# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aa5c7256b0ef0f114b78cf60a7d4b5ad"
SRC_URI[sha256sum] = "ba4d0b10674b676a633073d986f2c64577801aa5ca9573c734207c99c8c4daac"
