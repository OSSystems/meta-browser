# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "81e74d40556bc4c502d9f1bbe28e1c1b"
SRC_URI[sha256sum] = "48862da086c744042b572fd19f91bef8c89030e050241fec2f03b918173925cb"
