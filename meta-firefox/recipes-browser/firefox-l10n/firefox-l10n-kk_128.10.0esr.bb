# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2e1a9451a5f2650b2f529eddb8c97fd9"
SRC_URI[sha256sum] = "d84c1cd5fa07f5b2b8ae91a6ce89d667a50e3571722960b82b07c8da40d4ad3f"
