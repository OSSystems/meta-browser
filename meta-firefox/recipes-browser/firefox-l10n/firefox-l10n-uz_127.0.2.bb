# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6d96aba5996abf25226913ac22cdbd20"
SRC_URI[sha256sum] = "bd288aa2aeaca9b0f186a9e42da1c1dd5a5e204ec291f8f8835d6ce466c1466e"
