# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4ec93b3d0d1b07964cbf8529fca80b1c"
SRC_URI[sha256sum] = "a0273eee1c429140136cf9171801230ee6a3b169be45554fc1a319c09222789b"
