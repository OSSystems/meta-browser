# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "07f9926ca026d1402480b5c5c4054321"
SRC_URI[sha256sum] = "6c2b610724633c8a693673660ee116023a177a52b31742e7e3501fdc6c14e761"
