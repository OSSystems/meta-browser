# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ed25c3bb321e446f8573703f15cf813d"
SRC_URI[sha256sum] = "722045c38031f5c7a4818ed382178a4bf5d22ee07a695350c74656b9ade89464"
