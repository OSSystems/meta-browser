# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dafd96847578848a05937178ab863036"
SRC_URI[sha256sum] = "086d541aff6f4eeccfeff4a5d71ecb1cb71b5436017c9f01e0b86f1b295a566f"
