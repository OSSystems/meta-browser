# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "28892057a542f7581805844beeaf5c7a"
SRC_URI[sha256sum] = "c07063b3b321f0496c36e49252f965a2e12ad38c2fa5df165c16cc59ab8b0955"
