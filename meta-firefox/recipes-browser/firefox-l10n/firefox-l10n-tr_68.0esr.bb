# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fbc5133433a431780b260d2ff4505bdd"
SRC_URI[sha256sum] = "0b762bedc6aa0fbc6348334e98dcdbbea68de3b961b92109b4b9d405a84d6c31"
