# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8c0a6ef64012a1c327aa37aeae271544"
SRC_URI[sha256sum] = "67a983611d5c746e5ec778531fa665be17b146f75223a9401c84a8d95796b0d7"
