# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c1c60fda0fce6bdaf4bcaba8f09bd59a"
SRC_URI[sha256sum] = "53ffc92027376b948534005e699a12cd21d7992ba989538c4f862517bcad763a"
