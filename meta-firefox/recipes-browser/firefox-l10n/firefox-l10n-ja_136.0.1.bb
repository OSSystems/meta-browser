# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2563af2c4a35faced7de26e1fb039060"
SRC_URI[sha256sum] = "6bec26492084580ce3ceffd036b128f8d1c363a8a455dd4cc71eb07bf91b658e"
