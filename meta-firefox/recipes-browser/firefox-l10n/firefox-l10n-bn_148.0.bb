# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a00478b3ff484d0be725accb5666179f"
SRC_URI[sha256sum] = "48af04b2e58c14710dbaeb682f8e57f941f90fbcc49b96bb126f0b2bf0746217"
