# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1adf008833c4cd059504017d4a4bc0ad"
SRC_URI[sha256sum] = "3436ddedfedaf69e8ff490e7a3ec91984dba06766d72e9ae7219b0720087bf1c"
