# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7b516b31252af151235786187e8599c1"
SRC_URI[sha256sum] = "097a34880d6c9d4b91519b8f2add424d3ea5824ddfe70cf40d5fdbfdebd09f54"
