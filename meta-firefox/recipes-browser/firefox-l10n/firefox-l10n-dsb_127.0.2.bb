# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e3c2f4b8ee8232f94e82f3f836348347"
SRC_URI[sha256sum] = "66681c78df3cdfd61ebe130533a562bffc05d036179c92f2542ffd2ce179d879"
