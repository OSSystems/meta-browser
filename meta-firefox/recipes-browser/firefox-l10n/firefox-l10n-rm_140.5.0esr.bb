# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3fd547365cf1d7c74d8ac8751284782f"
SRC_URI[sha256sum] = "56c6aa7720a20821bc0ad285698808a93ec1d94a079862489be4b0a525c86488"
