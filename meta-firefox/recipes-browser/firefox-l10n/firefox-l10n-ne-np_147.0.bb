# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f137391dadda3dc716edf9d575156457"
SRC_URI[sha256sum] = "0e9b222fc277993a9b64e3108dfd596768a8bf30742757a13067d7fd5012cf17"
