# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "836341d57fb317d8e4a798599859fd57"
SRC_URI[sha256sum] = "39cc9dc754a2caa36989bd51ab21cbc600b7e3cf9ceeb180c717d54882b34ab6"
