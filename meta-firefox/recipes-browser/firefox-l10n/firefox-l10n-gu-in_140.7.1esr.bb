# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5cb012781aeede79d496b9c790a06def"
SRC_URI[sha256sum] = "47ee6e971fafe87049737d603d3346794b22dff215743abd0495a7f1aa04c365"
