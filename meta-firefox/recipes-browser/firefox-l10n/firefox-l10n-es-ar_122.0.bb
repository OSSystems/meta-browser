# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c544a2d3e8e961c0d53a18ece42288c9"
SRC_URI[sha256sum] = "40e6604d033773528d58ee36014cfac563501385a063a2596116c122f13142b5"
