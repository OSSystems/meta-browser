# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "566f3fdb2cbc1fb99c08f8bb8d3dfd22"
SRC_URI[sha256sum] = "3720ecabd94c9ecbd08d0ae81ebe83604a29be765d59618913715d78339c3c62"
