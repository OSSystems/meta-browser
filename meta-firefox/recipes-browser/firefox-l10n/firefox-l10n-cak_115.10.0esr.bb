# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "21699d48e1197c1ed69c4453b284ad0e"
SRC_URI[sha256sum] = "c580d31067e8f120bea9b4b7fc8df1d36aa23dd7b4400f8939327f522d5999c7"
