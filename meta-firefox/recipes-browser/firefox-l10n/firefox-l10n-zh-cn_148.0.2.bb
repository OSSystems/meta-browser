# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "996b468ebd341bb995330da0066dcc1c"
SRC_URI[sha256sum] = "0f1c0d6afda47e620798d87f55cde80f87f8b4631f183df3e756a9ac5063b442"
