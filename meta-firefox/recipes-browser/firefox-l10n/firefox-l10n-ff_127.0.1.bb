# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9414107c25ba24006e296dfd0fd79ed4"
SRC_URI[sha256sum] = "8ffd65ee1d7dc3068d78a84cbed67628c6f36e078a43e857d7677af19fa944b4"
