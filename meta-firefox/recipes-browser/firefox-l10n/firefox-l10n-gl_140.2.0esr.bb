# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e3b0e5ec0d8eb09ecee58d4e419cb6ae"
SRC_URI[sha256sum] = "285aa2ce778e58d979d6ed6462f5453fe66b6e7317e562cc1f192a7c2adab881"
