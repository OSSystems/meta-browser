# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "94092c5552e2c8a85e148174b9280260"
SRC_URI[sha256sum] = "08d84a5551aa217c635647392811641572afbe9a99a7a305d6043e8bfedc450e"
