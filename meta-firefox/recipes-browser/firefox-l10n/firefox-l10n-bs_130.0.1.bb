# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7150692859b4c84fa79acee5a0bf7fe8"
SRC_URI[sha256sum] = "100686988f664d33521e0e7db327bae536d5219cce43e52a6ffb442681ca1371"
