# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3830cae81c499aff8960b3c25fd8d329"
SRC_URI[sha256sum] = "8a9c395e1f6b8a7eba5963d0ca4726e87c27db6761a0959436b896a3e6395db8"
