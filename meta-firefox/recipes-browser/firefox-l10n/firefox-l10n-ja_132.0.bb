# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8e4f47b97b5d5acddc0f3a3f5d9dee6c"
SRC_URI[sha256sum] = "ab0f43f8dd844fd85cd055d4dee2c89ea9432ec24473af986ecd2512b08d2721"
