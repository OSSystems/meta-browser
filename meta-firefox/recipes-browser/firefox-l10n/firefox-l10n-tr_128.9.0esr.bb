# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "30529fbed639302e54a87b58fca5e09c"
SRC_URI[sha256sum] = "ec0ece6f88a48676bf2e3137ed622b2e15252be41cc3fc30d90a6e546511d303"
