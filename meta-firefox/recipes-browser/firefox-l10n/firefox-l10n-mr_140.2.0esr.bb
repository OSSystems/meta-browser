# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5ee0d4a87823bf38e2a359808f2fcbda"
SRC_URI[sha256sum] = "d3650cdea5cb72be33160c9dbbb4e073d0d6865782b23ceedd05520e97fa6a24"
