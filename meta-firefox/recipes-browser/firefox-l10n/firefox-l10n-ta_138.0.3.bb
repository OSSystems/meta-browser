# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "54c524389ff4afc46cef5dee549e293f"
SRC_URI[sha256sum] = "50d7ea46e24c450b768f52a9aa237c43a3e2b90dde522f18b26cb113988d3a6e"
