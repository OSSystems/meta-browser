# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b9308d44291d954dd93702c675701637"
SRC_URI[sha256sum] = "97ef5e5da7f1682d3c7ce1d279dd6d664e959060cf27666c349bc6ca371cc628"
