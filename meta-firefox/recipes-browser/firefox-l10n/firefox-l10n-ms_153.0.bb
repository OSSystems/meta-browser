# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7ace5f5cc8854c17c098682c6158b6ffd6847f47605e654d627697b05eca7fd6"
