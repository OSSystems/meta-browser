# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fe2402f6381b543e2260a9bc6db03564"
SRC_URI[sha256sum] = "147942aebe80cbe48670f915fe21d6658f0b401a79de742035f5bad1af038e70"
