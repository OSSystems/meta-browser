# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "492c462bc26e6ee13074887e64a6fcaa"
SRC_URI[sha256sum] = "c583eab40848849d5da7a1f551de97cf53dfc36bd65d96c86fd5bb9721725075"
