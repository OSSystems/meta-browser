# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1ffa21dfdde72a95453607eb741de099"
SRC_URI[sha256sum] = "9c436bff597d98b4890a27c1989fc5a51f3c85da7aaaa5f065e4cefb5976396a"
