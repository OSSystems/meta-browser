# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1782f1b0a6757eff74c9edb309b34039"
SRC_URI[sha256sum] = "56242044f0d261c794903f97099656fd03f643d88e0a223235c0ec97951b0808"
