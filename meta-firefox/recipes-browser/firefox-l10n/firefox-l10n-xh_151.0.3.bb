# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "05211e4e5a5d5f807dae5a1fc3ff13606aa28e245b1639bbc9d83c7ae6a4a2dd"
