# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dd5a99c102533353f1b1b1f26779544d"
SRC_URI[sha256sum] = "12ffba8b6dc5d74aec98dbe3cb7949a6219e5332beec81557794bc7e70fc6587"
