# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "58da4ed73c28b0098a48498be9e4233a"
SRC_URI[sha256sum] = "49ee72e3f82e8b72761c1230fd757e3582f7d029cbee131f71226ae92552e05a"
