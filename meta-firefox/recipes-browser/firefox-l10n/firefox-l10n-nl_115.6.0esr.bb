# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2d8b64d998d1069a650f5cc2e9347f1c"
SRC_URI[sha256sum] = "d1069b2ae1767e79625213a6a84cb6e68f04eed79fe97bfd19cdf9b2dee18ef5"
