# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "64a2e4e404c6aeadf397a0ddeb5cf239"
SRC_URI[sha256sum] = "3be08407282a9c33689117682a8c56948263acc5d82ce579f5b91894b1bc86d2"
