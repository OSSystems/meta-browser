# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "95a3356b17206c67da1f98b1b60b496f"
SRC_URI[sha256sum] = "47946b152ca44ef3ddc3cd5b71941ac69773a533f332261377e1c3eee73e7023"
