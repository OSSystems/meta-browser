# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c9dace5d04e99fbf7593dc0eb42ba123ee78ace0982e370511569981639d771b"
