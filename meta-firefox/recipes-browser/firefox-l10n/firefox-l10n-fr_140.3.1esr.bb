# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7d72daf9bbaf7010d2c6214be770420f"
SRC_URI[sha256sum] = "2e9a94115d21d02e39e9e54f70dda7092f3b2765bac30b747ba8afd15a816bdc"
