# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2e8a5a7f0aca069debb8797f8dadc2ec"
SRC_URI[sha256sum] = "1830aae61296d2e5c2a8ab61ecf049df0b28136c72c68d7ad118a7c525efc2a7"
