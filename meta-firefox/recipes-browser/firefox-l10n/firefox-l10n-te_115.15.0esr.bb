# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bb925b5efb506d83a84d788ac540d3cb"
SRC_URI[sha256sum] = "11725a9ef31eedc91bfe14631f8dcc027ef06bb3bba01395bab8554461f7870e"
