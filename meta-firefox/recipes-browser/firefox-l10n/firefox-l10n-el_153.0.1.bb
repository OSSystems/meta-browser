# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "bd997aeba7deae6b675a1bcaddf27b550b65e1310bf845125b776ba6f90c9f0f"
