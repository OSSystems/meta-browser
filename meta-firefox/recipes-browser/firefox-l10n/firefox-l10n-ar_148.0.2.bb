# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "289865bca101278fa7e502e3875cbb4e"
SRC_URI[sha256sum] = "3c95f13c111d6ed3f3106a05f9921569b67e028a07518347e67e8b833b728e19"
