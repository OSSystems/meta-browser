# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a87cd55936b4cbece5ec687e581d99cc"
SRC_URI[sha256sum] = "b5f78d813eeb877a034fc392748780cea07e40a0807a967e89ce106637792188"
