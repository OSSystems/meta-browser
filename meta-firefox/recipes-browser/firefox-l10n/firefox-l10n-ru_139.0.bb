# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "361889905a40aadc9d4be14665b1ccae"
SRC_URI[sha256sum] = "c03ddc3a9657d78698eb184fbb9c81c147f5ea2c5f7b3b8e7c9fe7ce9fea4fba"
