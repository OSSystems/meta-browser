# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "05a372fe7d8e163c0458db6233e6076f"
SRC_URI[sha256sum] = "e69b0417ee34c63429d1da5b8ced83a8fe59a9aa9c6a06497d8e54100716d882"
