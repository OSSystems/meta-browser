# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "124e88d94ca4e5cf77c55a178ced42b5"
SRC_URI[sha256sum] = "d8ba324e2ef4881b354d521ce7091be627701e596d6e60e4933f64369ef4ca86"
