# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "721810b98287efa60d404093db3f66d8"
SRC_URI[sha256sum] = "e6dd6a109179bdff2b3a5aadde49c19b741a3e6d41495a912a980e311fd946c4"
