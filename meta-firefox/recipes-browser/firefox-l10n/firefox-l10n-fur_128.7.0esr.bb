# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "812fe4e90cfb7bb2616d1cd923a02c35"
SRC_URI[sha256sum] = "42f8a623a1eaec2703c644b95cc53580d2be282943098200d09c67b516205266"
