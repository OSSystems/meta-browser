# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b7354269590ffc9f67fc2fab93d43602"
SRC_URI[sha256sum] = "daa3e0dc0ee4e71c19dbc557c5a6ff42e8ad417b4bdea644967b3d709ed59f86"
