# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cbfd8e29a9cf7297fb283b83d4d21a28"
SRC_URI[sha256sum] = "1e185f1ce6823b3adaef2370b4da7ac20e8df0c22bbd73aaaecea99a6fd54a5f"
