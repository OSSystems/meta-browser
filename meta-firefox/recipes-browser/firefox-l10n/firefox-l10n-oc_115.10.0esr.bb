# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f1d67e24f64dc414b873490999843569"
SRC_URI[sha256sum] = "6e579b339c2eb1c3f5321ff029b728731b5a9764233bee2b8a206844d4f774f5"
