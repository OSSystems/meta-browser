# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "749277be1c85b3f7c9df6c7340bd06c0"
SRC_URI[sha256sum] = "d7da883e8bb6e2b2a363a73ddfe98b4a1793454d8e80f1f65b7565570f7f3eb7"
