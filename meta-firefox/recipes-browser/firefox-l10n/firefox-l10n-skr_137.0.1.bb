# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "44bf9e6facce92f1c3becd26baaeb778"
SRC_URI[sha256sum] = "6cc157e2216296b762fb5f0ecc7e0b84c91a73891ba3f1c0789ad38149bacdc6"
