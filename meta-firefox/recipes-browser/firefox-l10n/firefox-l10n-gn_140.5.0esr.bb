# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "62aad9dee1fa5feb8dfd0797d9d4f959"
SRC_URI[sha256sum] = "a2d5b799462de5b474d34558f7b575ada3127309ac13b4cdf4a8edeee8350657"
