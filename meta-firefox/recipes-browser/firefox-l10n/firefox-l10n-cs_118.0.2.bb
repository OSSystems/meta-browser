# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ae6095db92a100eb6a2731eb10dcfbd2"
SRC_URI[sha256sum] = "a532a9b46c926277cf0514080afedc00a24649580417051502600a90f7363b73"
