# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "95f98964c48838070603ba8ac1c44cbf"
SRC_URI[sha256sum] = "7d86069ba792343a8a68cb7d60f2d9affb3ddfe5e152dbbe3bb68133d54593cd"
