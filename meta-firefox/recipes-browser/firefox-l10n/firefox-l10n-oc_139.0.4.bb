# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "76d833ee4a63e77f05ed599af82a7927"
SRC_URI[sha256sum] = "4ea2dfdac7819969690c571a37270969b866278e78bcb0f379a886c466256a21"
