# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "958fb0bb6c49766ab09be86b44c5f944"
SRC_URI[sha256sum] = "e842022d841de0c34219e9904cd19f8487fbdecfcc29ed550303e343f9bdf8d3"
