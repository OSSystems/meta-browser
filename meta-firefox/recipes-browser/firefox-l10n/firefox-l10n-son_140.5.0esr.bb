# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "37300b666052185e2c8b8fafd1a12319"
SRC_URI[sha256sum] = "5f8383e2b55db92a6933e1c7f52763ce2c81779a821bc20e216de574bdf47127"
