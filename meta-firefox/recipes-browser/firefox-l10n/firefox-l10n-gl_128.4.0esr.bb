# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "56e225f1c0e0d096d69a44ca50325842"
SRC_URI[sha256sum] = "c460f1f077b478bfea8a57c59abbc47cc219fd5f260b3eed91e1abf1f3321467"
