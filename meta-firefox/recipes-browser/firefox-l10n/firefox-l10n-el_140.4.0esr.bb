# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cab7d8b9cdccf90f6344acceac4e7420"
SRC_URI[sha256sum] = "53faced486141968f47d80c4754a21e663cad695356f0918b91ede84a50c58f6"
