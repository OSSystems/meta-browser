# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cd15b62a1b8e8d70c9794b64673b5846"
SRC_URI[sha256sum] = "827bb7710b1ddebac9a7fa11864f1166699a84f3747a638b788a6b906dfb29e1"
