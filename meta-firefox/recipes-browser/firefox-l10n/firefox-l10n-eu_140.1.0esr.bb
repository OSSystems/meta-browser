# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "61d4c43f6d0f91d57d61c1470744e9ea"
SRC_URI[sha256sum] = "29198adf7faae2427a534325bb2ebf5b8d7c41af91783541c5161f9122f7929f"
