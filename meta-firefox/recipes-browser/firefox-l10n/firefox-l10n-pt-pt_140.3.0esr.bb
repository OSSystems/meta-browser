# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "95d3b3a84faabe7175c79c72ff0cc52e"
SRC_URI[sha256sum] = "b9385d23c0a214798ce4ef35a8676f5c392d69669fa900975f2d131c3a29e53d"
