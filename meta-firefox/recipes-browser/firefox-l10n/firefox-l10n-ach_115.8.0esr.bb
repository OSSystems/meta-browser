# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "61a363808b29f57899fbc836ae45c222"
SRC_URI[sha256sum] = "d4b33402269d742165d5fb402a5a4eb522204aedf49262c48b1a4d4ba77b4404"
