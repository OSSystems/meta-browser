# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f85ef4f13cbdf5bbac29cdec108e837b"
SRC_URI[sha256sum] = "a64cfa864128ec82c58de8f5755afdf6dcd94e4ac5716bb6360441885b5557bd"
