# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c879dd67e15be9a97092c9ddeb0d5b80"
SRC_URI[sha256sum] = "b2dced573bfad4a23ac94a70d1c411972fa84c1409858ad39f1a236e27c3fa04"
