# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "29c5d0553005233df60add80b7211d19"
SRC_URI[sha256sum] = "f10c9a1de6beaa12fae3979f60a625a518a784901e907b3c71d86c45204efb01"
