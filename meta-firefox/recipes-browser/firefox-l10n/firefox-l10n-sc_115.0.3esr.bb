# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "740de84dd4b8f7892346282d6a43ac8e"
SRC_URI[sha256sum] = "6749dc13328c5c4852e72c639583d83029739f08a956488998afe55df6ab5a5e"
