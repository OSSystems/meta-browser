# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0e30c0ab599661ab41399250f7384391"
SRC_URI[sha256sum] = "b4b812585cc8cb09664f45945976c701ae40e325070a24a7e1c968ba2ce9b4e4"
