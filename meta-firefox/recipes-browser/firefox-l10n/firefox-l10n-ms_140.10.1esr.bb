# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "a357c6c6e5b59ac2d415d34212df788eef2852bae35ab1e759b381f919076165"
