# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5a3f61a686af7a2628902ec1c2b7d771"
SRC_URI[sha256sum] = "7d59536c9783e49078d2dd60635238a7223277319540539a48eb0387e12e30be"
