# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b9cadce0aa24b237b34193cd5d82010b"
SRC_URI[sha256sum] = "98b97e7c820ee2093dcfd95f52d77adc8751226e8bb0e96d6ed78b7ef05804d8"
