# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "78ad66e3465b5aa8f3400fb162d7514f3d74e13e24869576cf8d7dd14dc23a2a"
