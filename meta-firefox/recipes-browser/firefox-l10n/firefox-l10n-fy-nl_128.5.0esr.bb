# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0443334920eca566b2f25360df29b01f"
SRC_URI[sha256sum] = "f5ec0c25d189d885af66617e65abd06425c6e253f9035996aa604daf745d8f48"
