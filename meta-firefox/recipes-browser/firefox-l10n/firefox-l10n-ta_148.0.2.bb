# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e15503b90b54999a81405cfb45b1499b"
SRC_URI[sha256sum] = "89d3f20046f38cebc9756cc76cacf83a103d131efd95b18d873876bcc7e098cf"
