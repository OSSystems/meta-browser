# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b82886e5bd5b59b154f51604b7ade502"
SRC_URI[sha256sum] = "35142047f1f8668795b022aef3c5a7bfa5202ac5d33c051f157114070788519d"
