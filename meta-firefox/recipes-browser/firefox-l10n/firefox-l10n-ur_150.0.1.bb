# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "58bd44f1d134ec73b5ce17ce691d6534847f044e6331c6e4433d590ac6da3f0a"
