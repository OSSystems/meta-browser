# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "4868e0d8a5df6472fa66177c15cd882d13de88a9216571fd2db6c7181adb74c0"
