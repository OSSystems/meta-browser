# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "922967dd95317aff6cda92a2c70d5cbb"
SRC_URI[sha256sum] = "17e56bb692ee1525a0eb56dcffd32129c4be221a8f6393f19f6938a329f2519e"
