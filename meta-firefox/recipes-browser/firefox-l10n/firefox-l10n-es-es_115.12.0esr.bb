# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "99854fa19652aba9c1f94c1bf8a0fb07"
SRC_URI[sha256sum] = "eb8f93584df9a972747a09af4b6135051c1f2870753838bbbe1b2137e7bc83c5"
