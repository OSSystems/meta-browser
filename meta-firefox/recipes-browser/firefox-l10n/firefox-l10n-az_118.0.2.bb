# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8a534306d620b1e2252565ffd19d953a"
SRC_URI[sha256sum] = "8adeb6eeccd70d5508e56a0c1ec1ec838cbeb1c3291fe8bcc82c44ee1dd8c977"
