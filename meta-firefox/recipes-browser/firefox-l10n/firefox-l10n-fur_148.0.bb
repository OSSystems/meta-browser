# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d927a6cae67bbb3b5de4c56d2d1fdf58"
SRC_URI[sha256sum] = "78c41783f7b97c90c88fdc9fe0ede926c91afff46784883072498e3d5e420e07"
