# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bcf22567d0f9e5c38e10ecfb537632ae"
SRC_URI[sha256sum] = "e54ea91726a9e5145f6453e2fb0fdd8eae4b4a2f33b7e0030918ad4e9e4b5e5a"
