# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9aa8e11966886af36fcfb6d634a5537b"
SRC_URI[sha256sum] = "b2779590711386ba9b03303765474ae7f4c99b91522ebf771f46190519401076"
