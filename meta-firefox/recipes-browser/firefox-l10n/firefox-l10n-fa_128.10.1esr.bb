# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "382859901c7b9afabd6fd10915d1869f"
SRC_URI[sha256sum] = "4cb4f2efc8ba8d88a5c4e2519450491bcc4acb75bba7b3360740583bdb656b4b"
