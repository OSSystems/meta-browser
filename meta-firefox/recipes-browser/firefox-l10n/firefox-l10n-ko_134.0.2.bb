# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5258bada26bae13a2bac31642845aa31"
SRC_URI[sha256sum] = "8749ea618008a32013f0209fce5e2a780624e3e473f44b313f8b29b42d68b1be"
