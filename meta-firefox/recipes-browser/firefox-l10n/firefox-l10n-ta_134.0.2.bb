# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "98cbdd4679e627b03965a40441365ee9"
SRC_URI[sha256sum] = "77dd2397af7f9d01fada82ffb6ce5068414c481c36bfe45aaffc12efd16e0fc9"
