# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e9bb964a523dbafb86153b54f7588c05"
SRC_URI[sha256sum] = "9086b97140e6f87d448e6b6908dab3286f3bc558e937057f876c859096de3132"
