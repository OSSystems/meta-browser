# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dc455b83e4665aba7910f3441639f980"
SRC_URI[sha256sum] = "5b3975c3ca7afa4f0048115b1490c9545f66657f971829a22f79219ad94bf4bb"
