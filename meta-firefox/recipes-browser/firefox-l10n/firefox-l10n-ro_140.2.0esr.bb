# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f316bb022904881968ba53122669a2fb"
SRC_URI[sha256sum] = "a2c19e18e82a713a322d8050852e7225180e6f8802247be544a13243f3c2b56e"
