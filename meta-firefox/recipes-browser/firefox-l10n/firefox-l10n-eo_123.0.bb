# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aed621461e00ca6f85a5f0965d0cfb75"
SRC_URI[sha256sum] = "076f057bedec5b161c98b5a25a05488663e6cb03414219546ea1431d1074eb13"
