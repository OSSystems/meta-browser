# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "28b9aa91813fdc2e4b4ab3f2c2f8c643"
SRC_URI[sha256sum] = "7977e0e00d589bce3ec4b150d91699768074353e1d172c72c46182e466c1f378"
