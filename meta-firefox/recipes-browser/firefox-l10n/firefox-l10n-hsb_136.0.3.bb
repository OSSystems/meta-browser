# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3aa5dab2d82e69e921de611cf38f2bc2"
SRC_URI[sha256sum] = "32f7ea0858d0486fc51b1154d0d485904b3e1a1f8b561c6ca802c4ec40ca142c"
