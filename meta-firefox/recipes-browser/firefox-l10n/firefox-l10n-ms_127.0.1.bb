# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9fff7beb94749a6d4616e8a278966bdb"
SRC_URI[sha256sum] = "e1f2f2de7fbc7aa28d4af8b23ec9825c0c23511c79d10a11ded14301280b5ebd"
