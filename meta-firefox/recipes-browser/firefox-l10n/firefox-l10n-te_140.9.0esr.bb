# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "df287bcb6e15abf22d444faa752039e7"
SRC_URI[sha256sum] = "9d27abc608bb409c01ce76a1bdbd2835643cbcdf1bd95550e512aab1a2372a2f"
