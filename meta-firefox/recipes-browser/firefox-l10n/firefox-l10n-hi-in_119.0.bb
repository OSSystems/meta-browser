# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d3298b06e5439b40851257a84c81778c"
SRC_URI[sha256sum] = "d745023b7f9954104f92671b67d03cca855c143497f6d19efdb9341def8ef03b"
