# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "38e78e8dd3d1c97975ade2e3ed814b0b"
SRC_URI[sha256sum] = "de2547f4fc1599d76565e8afb70d5ba8adb70a797a43ab38efcd0f732636358f"
