# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4357c874888fa2e02dd413633216f648"
SRC_URI[sha256sum] = "ad0bdfd246e118a8284011e2747a54595751fd5dabc42f17fc751b3d9a201e49"
