# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db04e0372b1b47a00f174564ad5f9b24"
SRC_URI[sha256sum] = "bdca4884de3a304d819bf6363c28777e85db5dfe4863dd06bc80e82d4f7b5c53"
