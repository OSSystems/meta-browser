# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ae2b4296f4f3372171ed31b898de9b67"
SRC_URI[sha256sum] = "cdf297f797ba80ec52f150f64bf1e02a7008bc8aaa52d046f90ade0523fabc1f"
