# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c16f83353b5b1f21b5da90e0b9b0f68b"
SRC_URI[sha256sum] = "119a5b95290b9ef7887673a4fc98f2d15a12677337585c538fdd316bde0147bc"
