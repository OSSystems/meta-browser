# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "af9e9dc4fd167bf707007f07a08699f8"
SRC_URI[sha256sum] = "a1bbff5434254cd58be348b121c9fbffd77be7bcb79fabc417efd8a0ad730427"
