# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c740459741e69b1a1cfa3bb2a7ff4241"
SRC_URI[sha256sum] = "dd80165636130dffa57b51a9385158d2700c554b4d8931261001782d7c0d6a48"
