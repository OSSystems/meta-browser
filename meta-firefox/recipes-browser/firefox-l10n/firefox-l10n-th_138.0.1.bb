# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "20a5e0022d22a2557b05f6dbdeb79317"
SRC_URI[sha256sum] = "9e15ad8e95e795f94aa6682c04c0de3039b654df65b26826601aaf09de651579"
