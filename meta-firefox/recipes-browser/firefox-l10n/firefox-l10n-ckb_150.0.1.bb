# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "1c5a9f7e822709fa1e891b08496e3f04f881bb4c5cc1a01734c464962756e463"
