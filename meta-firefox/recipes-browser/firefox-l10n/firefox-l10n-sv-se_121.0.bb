# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "84206935c9707fa1c27b4c917f4bbc7e"
SRC_URI[sha256sum] = "68598e9f4b8d242ea65c9ac8e2b1c6e34e91793294997d133749e04243798cbe"
