# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "a4cfad6c3fcb9f6832f8ae75f63fb1d5bba6bb15ef171c7cb54c82b5830a2f50"
