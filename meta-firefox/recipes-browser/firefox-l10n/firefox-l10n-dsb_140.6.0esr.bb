# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a3b28b0dee598b86e2ed2f8eafb7ace2"
SRC_URI[sha256sum] = "a25644df4743728cfefacb93acfe62cb9971049c8341b9267d7da9811f68fd72"
