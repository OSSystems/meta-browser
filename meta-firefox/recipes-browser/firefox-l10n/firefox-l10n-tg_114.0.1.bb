# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7af4209a9e65d4e0831837c5ff357bb5"
SRC_URI[sha256sum] = "9205edbddae91e10693285ab3398c767af6e40cbd3c88efb38629ebba7875622"
