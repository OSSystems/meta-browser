# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5ad66a9c2a29c46170ace65cdf4f83dd"
SRC_URI[sha256sum] = "737b767be7493ed5784c4136588bc7496100bf74ff9684c4f3555434d4bb5b3a"
