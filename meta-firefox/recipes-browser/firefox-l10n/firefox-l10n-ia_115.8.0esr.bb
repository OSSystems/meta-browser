# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b6d540e7bc09824fab39dc889fe14d97"
SRC_URI[sha256sum] = "1fa8e4ce8ce0950dbf760c3266d162399a618aed0fa97b5011b4dead109b133f"
