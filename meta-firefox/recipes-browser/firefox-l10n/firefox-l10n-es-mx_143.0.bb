# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1d580f9ed854c576e0700b282d5c181f"
SRC_URI[sha256sum] = "72a60c85ee295f10602e4510371d44be860701f591d4ee0d20930b130e05d3bb"
