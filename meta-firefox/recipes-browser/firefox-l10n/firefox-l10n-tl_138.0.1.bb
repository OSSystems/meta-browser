# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8752d04d2754435c837e0786105d4726"
SRC_URI[sha256sum] = "1935a1f52ec0afb570a6fa2c2f911c679b3c0d03554ea7574a1517e6f4febde4"
