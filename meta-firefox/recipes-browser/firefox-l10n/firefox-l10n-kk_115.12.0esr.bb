# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a83aaec7e2c7a86a50a357544f5755a2"
SRC_URI[sha256sum] = "7c7d1dbf92b0bce0a57e4388c0b703c29cfaab0bfd4a6951ba7f650a18a7bf9c"
