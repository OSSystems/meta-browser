# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e9145531c6f28a7cda1b8aa360781e5a"
SRC_URI[sha256sum] = "fee71629dd08b48bf4115658c3ef7ed6960fe605b3029bee6916e28a414d5534"
