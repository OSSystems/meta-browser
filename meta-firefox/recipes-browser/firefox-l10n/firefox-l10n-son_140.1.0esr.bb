# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2bf9924be6203061a96cd6dea6f5d3c6"
SRC_URI[sha256sum] = "0267f170e0c249ffdcfd13ace6364dd8bed7605c263dd147da80b8b6a6813512"
