# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cc19f61e81289a6259b4a878e34f4a99"
SRC_URI[sha256sum] = "fd67207077d3a35e2b96d7e0de265423927e5c81ba9d8a8c3ffcac6b904dfaa6"
