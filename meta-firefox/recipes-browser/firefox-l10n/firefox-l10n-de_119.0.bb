# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8de628781cf79730a5dbe75d39eb9675"
SRC_URI[sha256sum] = "8424cd3be6cf7c863cca77f6f9d062ae94cd3c00407d3b962792f88e3b4edd04"
