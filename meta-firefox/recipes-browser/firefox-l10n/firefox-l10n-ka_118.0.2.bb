# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fdb07f260b78a7756f000016a7730c44"
SRC_URI[sha256sum] = "d4f7a62441cbb2640c6dd324edcfb2843745c3dc8b447c2f82cff26c82fb6e8d"
