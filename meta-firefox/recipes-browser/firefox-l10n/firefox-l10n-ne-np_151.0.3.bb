# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "29a00203d97238eab075212541ca904f009ca694efa0a8c6b81721424c2b2ff9"
