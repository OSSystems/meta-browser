# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4e4f21eea186817787ed87e085e066de"
SRC_URI[sha256sum] = "dce4397189e9943fa948efeb375e2863db7158ebed3417cecf9cf05984c3415f"
