# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "be4993a696b582c6334ad265fabcf3f1"
SRC_URI[sha256sum] = "01e55fbe6ee756133e92b0765d2496e2fd5e64647a68088695380be65223a2de"
