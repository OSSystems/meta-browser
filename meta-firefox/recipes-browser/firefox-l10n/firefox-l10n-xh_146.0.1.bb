# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e279ef843f9f370c1f19ac8d1db2b595"
SRC_URI[sha256sum] = "37a1023f148a9cb813b1da6bbfd99072e2aa6736e18fb7aff17a4225bf648acf"
