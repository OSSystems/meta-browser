# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d86f8930a4c6cb1b0e37a9f06639b1c9"
SRC_URI[sha256sum] = "c4a4236c50efb1af87f690456562248b314e0497040311f096867e253c9e8524"
