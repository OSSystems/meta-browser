# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "58591b0ce1f7de942633ab9182419da4"
SRC_URI[sha256sum] = "07ecff1040b245a4a396691c67bcf442335c5f14f7ef28a190e32ef6c4a057fd"
