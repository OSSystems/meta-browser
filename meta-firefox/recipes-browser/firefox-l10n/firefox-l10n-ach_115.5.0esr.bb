# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "78e1a6def0d98a1a98b5510589829af2"
SRC_URI[sha256sum] = "03fcdc3ae0dee274066237f1e538d6c7f175c22eb2a770b30877c24a4d0b2125"
