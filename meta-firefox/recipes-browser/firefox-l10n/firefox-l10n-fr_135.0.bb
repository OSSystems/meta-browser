# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e76f5945231fdbd7d593b5a0d8a3d5db"
SRC_URI[sha256sum] = "a963f95832050b693c9e09b045732412e6a057bc3ed2609c970e0948065dd32a"
