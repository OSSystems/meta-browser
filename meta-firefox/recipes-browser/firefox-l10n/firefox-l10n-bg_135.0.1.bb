# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6952496bdaf34ed470d557bacb8fa580"
SRC_URI[sha256sum] = "a2055b448d3ee5da975d1bd877a07048e57b7c2cbd1f82921428aff9b4980c8d"
