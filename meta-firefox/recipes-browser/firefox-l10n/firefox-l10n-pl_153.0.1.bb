# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "6ab1789aca791edfabfb8be8d800d91c1853bb2f632c76c69a1ef1364a9cd6e0"
