# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6762b5356ec91bdde916ceabc17aaecf"
SRC_URI[sha256sum] = "78f5743d5c224612be840ba8224c5b090d36a13bad5cadce79af3001f877823c"
