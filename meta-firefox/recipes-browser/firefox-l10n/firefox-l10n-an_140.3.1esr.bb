# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c042e53661aae2e771496ee76d7666b7"
SRC_URI[sha256sum] = "93c6ae32027d2c9f9ec5923c2dbca0eefb36f83515be8a0681db5e8b5694bd41"
