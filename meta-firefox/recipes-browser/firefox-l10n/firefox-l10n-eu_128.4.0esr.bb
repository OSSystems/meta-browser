# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "daad271f9af9f3f8bcaff24fc98b31c5"
SRC_URI[sha256sum] = "409f51d73c197bf79549bd7850194a3ecb0d37a77cfee3deb9203081901ef35d"
