# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "fe484c11e23fcdb2e96f2629e8a58afd115945d292668f0448ad9fbf0e89c587"
