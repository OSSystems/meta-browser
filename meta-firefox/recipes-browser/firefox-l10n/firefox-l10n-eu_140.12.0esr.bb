# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "70d592b1bffae8e748277cb6ac215dc2bd8a8e3efbc4dedcb3c892bca4b31fc8"
