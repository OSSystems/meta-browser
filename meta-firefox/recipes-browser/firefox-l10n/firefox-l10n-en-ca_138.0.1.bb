# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6709425165414c9da4fca9692494e91b"
SRC_URI[sha256sum] = "b3239fa8e03c73caef32a350a907bf1d99635978e963fac0e0836d03851c95bb"
