# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0210623246d745a785ab577cab95df6b"
SRC_URI[sha256sum] = "ce27b3edda02c217394b03da7c3ceeb04f7567ac981a167e72b84d7daa378756"
