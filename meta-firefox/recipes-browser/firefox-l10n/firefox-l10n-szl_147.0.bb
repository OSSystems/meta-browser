# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d6dcd1be8ac31435c41f1c230bd3d97c"
SRC_URI[sha256sum] = "7a2daa345b543cb2bca7ea97f735601967de41ffb3b7c9221c9d518892b16c20"
