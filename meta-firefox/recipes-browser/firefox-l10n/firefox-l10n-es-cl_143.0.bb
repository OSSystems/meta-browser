# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4fe8e39f13ebc25f36fb9f3ed7599dbb"
SRC_URI[sha256sum] = "b7b2007288c22adeda73c8e45407f69988497a3590dac88eb3c78a597b12a9d7"
