# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "14d815cd0e4c6e33a4fb00dea7ce5e48"
SRC_URI[sha256sum] = "6dddec1da18ded51d5bece21e493cc02b61a4f99ccde25789b8da61a3551e664"
