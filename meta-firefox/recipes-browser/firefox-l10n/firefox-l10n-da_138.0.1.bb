# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7db78cf01c7a05a43a6868156790e850"
SRC_URI[sha256sum] = "f8af6c1b2e125a6d7a7ba94d4a985a1da3fedcbfb5901071745de65be9fea07f"
