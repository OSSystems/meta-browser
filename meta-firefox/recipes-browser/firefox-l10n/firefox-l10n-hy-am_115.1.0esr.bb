# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f5bdf809931a68c5f88ae02afbc9938e"
SRC_URI[sha256sum] = "77ac4027a329879c439749b6299c15e80f5277529ab73a11e742c3a3794e61da"
