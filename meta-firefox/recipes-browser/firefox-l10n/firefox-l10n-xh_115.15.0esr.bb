# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3bd2c452c9098ccdec9de7b4a408c502"
SRC_URI[sha256sum] = "c2c9bd36efca1ea0179f98b4bf70f252a9a7f011375d4d5f0e211a5fd2ebc482"
