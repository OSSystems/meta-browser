# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0140637e096198e4729541143209e95f"
SRC_URI[sha256sum] = "a55d26d8ce2f23563480022342208371a4a07e4dad493f3a365676773a82e88a"
