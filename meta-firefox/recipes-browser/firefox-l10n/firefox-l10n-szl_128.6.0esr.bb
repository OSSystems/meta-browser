# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2e448775be3b599a09254d7a0424f90a"
SRC_URI[sha256sum] = "2272925c4a4bd609bbfb3f31ba8ccaba97a0c07838d3a58d904a762d9e66e4e8"
