# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2c431e73aedccc1f143387b9faca64a0"
SRC_URI[sha256sum] = "8ae8598cea40538feb306d453b9c478416a69f4d13b479a44142b8e1b7f684bb"
