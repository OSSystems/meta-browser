# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "88163e4f4d750270d847474587b1a667"
SRC_URI[sha256sum] = "10247264fd75f4a0fb8a53786d7c6e8bb1e8c76b0ccdb8f5cb55b34543e691de"
