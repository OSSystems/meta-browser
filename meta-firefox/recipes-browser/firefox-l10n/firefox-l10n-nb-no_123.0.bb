# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1e0aae88f4ecd9ed714902b8886ffa06"
SRC_URI[sha256sum] = "5cd3d4f69938454ee7714dabcdc5b0a36631d47563b35de4c361da8ccead6a5f"
