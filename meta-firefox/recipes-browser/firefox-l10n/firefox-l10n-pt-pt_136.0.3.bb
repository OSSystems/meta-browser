# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f358266028bfd09dc8b395f395822d1b"
SRC_URI[sha256sum] = "0ec754e9a372b874156527221285b2c04ef07129c14c983de792633279ac1b18"
