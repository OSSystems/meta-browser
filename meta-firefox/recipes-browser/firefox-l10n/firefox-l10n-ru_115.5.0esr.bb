# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1aa4a54f288f5bea392cdbb76de23b3a"
SRC_URI[sha256sum] = "fb232c2e858275e5d03024ca4a66f398b1db657a9c72c5266b6e41b1219daf7b"
