# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9cf33bb486bb07d04a3f647343ed8130"
SRC_URI[sha256sum] = "fc55814011459c6561d1b2e7fbe4b64691fadce177986bcb4f75d1d9c6c2eed4"
