# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a553d91be98279955dfc4f4688414d12"
SRC_URI[sha256sum] = "9dfddad9323d46e565c3b3ebc5a448f6fa71860566f7b13495737b263b9fd1ff"
