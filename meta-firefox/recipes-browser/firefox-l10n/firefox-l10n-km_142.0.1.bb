# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "576ef22dd6be5b55c381e26be5be960b"
SRC_URI[sha256sum] = "0570438ec90f21f98698df0e89b443f5a5946640bd928afb759c303cd5a37274"
