# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "86f28cf6476b978174c9eca7c30c276c"
SRC_URI[sha256sum] = "3ca3a1e2c1003bb2f5bc67f15f3ef07e3ae9f3abe8a56e2cdd444c9d9ab43d8d"
