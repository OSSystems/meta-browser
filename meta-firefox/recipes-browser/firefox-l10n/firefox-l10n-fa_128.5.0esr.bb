# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c5765520fad1449b3b2a69b2f79e1d51"
SRC_URI[sha256sum] = "4467615fefa293deddf04ed3984d7f85fa085bf5a61da85b7eb42f5ab701c19b"
