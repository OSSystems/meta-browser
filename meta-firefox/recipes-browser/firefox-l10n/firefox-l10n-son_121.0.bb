# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a642e7c689a18ec421393ec360b8bb04"
SRC_URI[sha256sum] = "725451cc773a40f3648e3f4523b7a39cb6eeac35ac901745cbcb28afd72e30cf"
