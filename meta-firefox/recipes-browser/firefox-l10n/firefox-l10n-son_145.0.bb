# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8c58dfa3dd62b4e36c685fcf2d767ab8"
SRC_URI[sha256sum] = "d532317e1de9a12383ef967e81a7895e30099dd03e5840e10dc0bad8c25ee7d9"
