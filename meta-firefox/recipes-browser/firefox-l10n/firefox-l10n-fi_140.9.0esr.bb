# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "23610abbbe56754c2c7aa870a89ed00d"
SRC_URI[sha256sum] = "f01928a0bfaf5de671df1495b582097470ee8c6a15323a5ca08d96886c6f30d9"
