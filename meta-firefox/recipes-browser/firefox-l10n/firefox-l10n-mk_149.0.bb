# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "09841ce143f70cf14036737de6c89ce1"
SRC_URI[sha256sum] = "8a3010fbd36023506116c6f64195827c641ce53aa48dc25f1dcf7e3b40a0299c"
