# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "736771968f374d230864122c64a3dbdc"
SRC_URI[sha256sum] = "a4a90049ed203bed3ff9e89881c97cc85dbb7e7aa11b345f889eda69d0be28e7"
