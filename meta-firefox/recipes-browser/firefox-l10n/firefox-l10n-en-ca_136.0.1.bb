# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "06622c14bf915e06e77f5f68992c8a42"
SRC_URI[sha256sum] = "fb134f3c49044347d655f51d57f25d3e87d8e9ecd4dfb357f11532fb24988a06"
