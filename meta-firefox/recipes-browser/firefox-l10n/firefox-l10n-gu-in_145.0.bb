# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c00f6b6a9fdc92e3f807d20b1cec3c15"
SRC_URI[sha256sum] = "14beab8dd44d0c7a9e1daa4d044e9358ad34a5067cf444cf8b179cbf5c22d539"
