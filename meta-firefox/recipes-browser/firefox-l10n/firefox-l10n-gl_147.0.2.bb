# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c489e162d0e9614ef067ab176268553f"
SRC_URI[sha256sum] = "62ee79d9af43081bde153487356addae54e813a781f6df0e10f92a8827780034"
