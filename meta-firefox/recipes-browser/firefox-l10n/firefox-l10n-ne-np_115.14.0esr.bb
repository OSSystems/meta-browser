# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5ce46772ec0a061990b4beb730ab2209"
SRC_URI[sha256sum] = "e10156fbf2091ecc7efb178be1759ca4532ba87e515533acbef4ea3f37a0a46a"
