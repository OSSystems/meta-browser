# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0567efc5aee5f58a79612686b05c2bc4"
SRC_URI[sha256sum] = "ae47a5fc2171c445ff41d1daab112f95378153ec9f0e92cfa056885e559eb8d1"
