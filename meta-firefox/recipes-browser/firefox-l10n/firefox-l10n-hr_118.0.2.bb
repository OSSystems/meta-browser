# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "36b2a6418cc102a9f4eaa965a4d845f9"
SRC_URI[sha256sum] = "761dcca69a8881c5777abb116ccdc4928fbcd61853ede761a69c9052ed980a26"
