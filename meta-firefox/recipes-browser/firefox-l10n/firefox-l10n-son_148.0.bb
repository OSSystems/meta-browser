# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "13051208b743e30880142063f6232142"
SRC_URI[sha256sum] = "d7bcebe7612e68b6046bbe5f152d5db135727bdbdd6750b8de7bc11cc53e92da"
