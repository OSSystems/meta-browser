# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "180e22e594dac1730869bfda916fc7b1"
SRC_URI[sha256sum] = "78cb1eacdad460ad62fdba599af089cd36b64de3fc90a1cebddea4690d4fc479"
