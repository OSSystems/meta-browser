# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ce8dc5be470d23ea5a4d56ae331d3baf"
SRC_URI[sha256sum] = "0e685c45305d7453d274ac745a8852be72607b0e5a87c41c837b1a00fe9ad9e3"
