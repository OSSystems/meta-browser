# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9292a2c3ef2b566881aa3d81541157dd"
SRC_URI[sha256sum] = "1334baeb8128a2e72b302be0f7c091230bf5a0cbc8c8d5f679b0a1edcb978da4"
