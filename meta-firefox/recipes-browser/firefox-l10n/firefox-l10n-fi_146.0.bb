# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e926f9ef0b17497036f0260c975b80c0"
SRC_URI[sha256sum] = "6e75d4b7aa5c0c529fa756ebc918d706088735ac8c3ce8e359d9fac2be203c38"
