# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8f733bf887121350fdc7d789b2941f7a"
SRC_URI[sha256sum] = "1e4d2f30f7e52e5432c0d6bd6603821de91a04bc7e4d56b84cd77746ccec291d"
