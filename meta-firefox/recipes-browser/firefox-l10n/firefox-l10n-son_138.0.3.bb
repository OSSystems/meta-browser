# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a98a2fe664d3e054e4bca82d0ba68d31"
SRC_URI[sha256sum] = "1711df6477553b9efcf703ecc87fc4d32e06f96d42abad04d0f860c8a855baf0"
