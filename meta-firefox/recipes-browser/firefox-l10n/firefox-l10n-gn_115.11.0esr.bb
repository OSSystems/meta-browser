# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4f5476c361714e4e890f1a759d328c65"
SRC_URI[sha256sum] = "734d6349ece7529ad611038653422cdac2bc17befe2e87c8027aa1afd7c13fed"
