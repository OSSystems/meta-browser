# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9cf7af96bbbc84bf93518db19d760db8"
SRC_URI[sha256sum] = "7ff51a22af049f5a4688824d91f7eb0b058ddc9b0ab57bd6f1aea4efbc479675"
