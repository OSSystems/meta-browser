# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "054f006bc649d83a19ff5072f5bc2e32"
SRC_URI[sha256sum] = "eb112219d0d2b93f744d1b679db37943e1abcfcaee02ea707a690d2881088cf2"
