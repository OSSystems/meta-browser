# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1ed664717a387e169bf1ea4af606041b"
SRC_URI[sha256sum] = "87ada20484223975713a9c83f184b766c5ea4e23bcc9c810d4a019144bfbb443"
