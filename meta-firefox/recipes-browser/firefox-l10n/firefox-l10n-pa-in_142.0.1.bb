# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6caeba72fa05eb8024752de00ff76c14"
SRC_URI[sha256sum] = "02b793f8955ea9eb843f5ba173f3ed66856d3857ff33f104b7f5952028a483bd"
