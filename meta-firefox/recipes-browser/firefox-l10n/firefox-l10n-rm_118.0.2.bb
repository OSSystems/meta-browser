# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dca6e0f10f2342775f70ec108b92c934"
SRC_URI[sha256sum] = "cf00da800a8c762f30d4af97191675bd5381012c125928c2afeac9d9cb5653d9"
