# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d309a438accab6c276b8f689aef700ab"
SRC_URI[sha256sum] = "bf58451a0787b1dba36eb96a2d61db07e94e039714068393df9746fd483164ae"
