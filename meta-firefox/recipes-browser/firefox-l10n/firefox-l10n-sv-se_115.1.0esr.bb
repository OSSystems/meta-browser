# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3745724d96834925119893bf454f5e0e"
SRC_URI[sha256sum] = "0cace1758c27d5f02680be0d8b5cf553f20c1e239fcad784de5606e45e064ac7"
