# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "be62d3b7a26f93965833fb1252f10cd8"
SRC_URI[sha256sum] = "47f51a6ad9e5de36683a183143d26e7e45160fb9135148ca578f838fc1140c44"
