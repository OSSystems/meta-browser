# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "753e319f343629d94798ead37cb0965a"
SRC_URI[sha256sum] = "ccc5577ae8f87c0530e3a1df415fad5388c67edbff45486436241d8498020b79"
