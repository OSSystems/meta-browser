# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4cb1f59fa18a6e78db5451346fc7f16e"
SRC_URI[sha256sum] = "5baa9d520735e4def403bbc5765b92e128d697fc3535d4d3c40c4ec12f369dbf"
