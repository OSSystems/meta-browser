# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "42f9f0880f2005f506fadfe6e5bf9060"
SRC_URI[sha256sum] = "60f8b3601d27364e7fc456b64535c4eb0bce5ed9e0dd7009d68e146eb74b3dc2"
