# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1c55192f40db185b1417f28cfd5ebf20"
SRC_URI[sha256sum] = "ecd977c458bc67b38540c7164c2eca7b3a644716447d5459bbf961c05f73c5cc"
