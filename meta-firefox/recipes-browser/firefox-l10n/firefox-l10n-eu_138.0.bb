# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dcae041f27eb20e517b4db1147680d82"
SRC_URI[sha256sum] = "891b3c42ee9bc4b6542461d2bfd569e8fb19093b087dc6155a563c67fe20c857"
