# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "64f015be43a5d8c5eb467c1d7b182ccb"
SRC_URI[sha256sum] = "6adfeb205675133ef567050232c2cc4b329e7170e7c4291c1330493f7b9a98f4"
