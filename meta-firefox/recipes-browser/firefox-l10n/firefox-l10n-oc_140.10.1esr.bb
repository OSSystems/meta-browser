# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "a5ff404015f8c6ebaa0bb4ce01b2e969af4d103a82d3fb5c1102f37c505e2068"
