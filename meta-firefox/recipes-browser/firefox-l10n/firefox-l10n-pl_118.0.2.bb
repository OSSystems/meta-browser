# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f1191fc0979e4362753ee7e07047e399"
SRC_URI[sha256sum] = "c41ac594541ae70d0176ba38d32f8522e93ac9d683bfe62d7460372eb0c3ccab"
