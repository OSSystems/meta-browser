# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "07349fe0ae7727671ded3fb0182c48ec"
SRC_URI[sha256sum] = "004997aa4c51993fb1cec09a5235d893cb1d86878b837e8ea54b64b24d4539e8"
