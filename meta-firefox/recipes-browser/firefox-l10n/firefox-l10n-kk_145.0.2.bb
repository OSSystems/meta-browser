# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f0aba4c04ebad425e687771eb9242762"
SRC_URI[sha256sum] = "2c73bcc2b94b0a8c913fe3d9b000604a179c6b14d2fba7ecb428375fb66095a4"
