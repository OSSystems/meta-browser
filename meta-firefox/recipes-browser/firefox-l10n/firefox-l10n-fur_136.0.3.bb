# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f4c677e09801e61faefa1b0cadfd4ce9"
SRC_URI[sha256sum] = "65371adae2a50773769d1798d5a97f59dbee4d8166a07688fdc6960577a9bf0e"
