# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d5febc337afab841e877efcef3eae8cc"
SRC_URI[sha256sum] = "2d70b154ebb9145ced55bbddc012fb9bf66fb1546db83c82620d633643af44e2"
