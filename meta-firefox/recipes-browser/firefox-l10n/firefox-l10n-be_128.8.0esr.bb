# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f05859b1f69a0907db37712658cbefb1"
SRC_URI[sha256sum] = "952330316aaaaa7eb3707a79d48d335706afd0ad75e50175d921e6dd0758e086"
