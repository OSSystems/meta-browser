# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "da867efe85a37db68c73e41ec632476b"
SRC_URI[sha256sum] = "b9c28bf15b549e2c9485978cd9fb7d8be2a21f5c1aa272ea8d440a8112c7705d"
