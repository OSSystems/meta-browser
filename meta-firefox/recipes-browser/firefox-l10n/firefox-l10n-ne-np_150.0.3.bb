# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "115dd466956b46e799e255d223544bca4556fb0289860605259ddc6dafff9ee7"
