# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "615e96e801e189225197d55715a6ff4bc832fbc351d42fb2917abbb996b6e264"
