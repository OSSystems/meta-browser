# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "70f343c9b0d44de4f25ab42ddf2abc64"
SRC_URI[sha256sum] = "36ec94e1b4b48d528e43cc38da94e0f18b35782bdcd233640b51143b3fd36c93"
