# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dd8476071b2f093c1e084f0c5c59fab9"
SRC_URI[sha256sum] = "40dd0555c9e22c8a3ee9b80daf6714e6c22b4cf9e1ad1850b922fef0fafb605c"
