# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "804c669be0324c858c23252b98f5a045"
SRC_URI[sha256sum] = "c105c95fb2254613b03f6f11a273f9309ef34d51d1a3addaeff3797b0b7009d4"
