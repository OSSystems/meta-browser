# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "88cce3ec7cc777082989bdba03f77ca0"
SRC_URI[sha256sum] = "c2506e4a5e7bd5fe58a79e0f1764c3e568fd94eb5f22daa04bd25e538caf6f96"
