# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "20e5e6e3a4d068f80c9d931a737486bf"
SRC_URI[sha256sum] = "809b7961018445e580e856bff056c15d2c31812b5f82bf1da600ef78d1b96708"
