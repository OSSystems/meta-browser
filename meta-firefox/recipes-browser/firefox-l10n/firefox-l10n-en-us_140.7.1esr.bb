# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aedc1acafc2c479fb5161614ec83e862"
SRC_URI[sha256sum] = "95765bae39d3190cbecb58b6ffe5e4c0257063bc766586972f36b2eb34d2b81c"
