# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8f8d0f2726b31758b47edc3da5a41f86"
SRC_URI[sha256sum] = "8604f26f8f471209b215c3dcb60a1886f2f6ed3d6f84aeb8f9b8ead6f8ec24b1"
