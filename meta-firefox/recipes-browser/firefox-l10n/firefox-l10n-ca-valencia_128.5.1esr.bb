# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "16a2b559314b5aabff0ec2996165fc7d"
SRC_URI[sha256sum] = "28693e78c52359916e8a90848afef423791cd6fc4c54bfbfba6ba43863f591ca"
