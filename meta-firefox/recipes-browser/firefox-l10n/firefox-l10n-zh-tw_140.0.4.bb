# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "02ed6c9242b07c93d099012e58f73ac2"
SRC_URI[sha256sum] = "b1d8493d89a78dce5a9ca1d3af0a4d5c9c48e3590baefdec6f69313e474f3048"
