# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "29737ce79cda89aca20bd58ba7ef1172"
SRC_URI[sha256sum] = "439b085543dd848df1cd599b64371450ead8024d4dbbeb2476dcb47a6a61437e"
