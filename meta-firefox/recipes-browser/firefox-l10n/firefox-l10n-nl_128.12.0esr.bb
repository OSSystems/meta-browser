# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f33a3722b64b7385e8825f181c11f0bb"
SRC_URI[sha256sum] = "ea60c4663259efe5c06b915275de8dc5c3a9758453eca4584379984b1c712f77"
