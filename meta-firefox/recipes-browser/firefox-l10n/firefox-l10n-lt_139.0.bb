# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1691f5fef7300f1ca6519360972bf089"
SRC_URI[sha256sum] = "d497c83f3d37f8ed590c8be80781792964c2499afca8aa2ad7a87fbbc5981b5f"
