# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "005c11f68a93ef3cdc99b02d44eb03c7"
SRC_URI[sha256sum] = "aca3e7b286f38818ea0dbf62a5c6d6c1339d795b05e0c693be0d3ad2132c211c"
