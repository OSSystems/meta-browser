# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b8d96a3967dfe0c88fe334a5be4d9ee3"
SRC_URI[sha256sum] = "f9d092d138fad610fb6a999625de2467dbe1239b76b98daa46b65af3d3d2388a"
