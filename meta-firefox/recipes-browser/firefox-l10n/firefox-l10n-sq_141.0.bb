# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d0609886fb48d7e2c409530cea1cb16a"
SRC_URI[sha256sum] = "7ecd25f365682c47016bff2d4bc0e8f94f9e6218320bdc449ec7818f2e9b8c57"
