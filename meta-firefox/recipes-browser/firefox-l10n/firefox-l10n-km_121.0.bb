# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "90c7d38ff02538a8a2a5d49fa125576f"
SRC_URI[sha256sum] = "aba55de083c1161f706d7ddf4b79f798f67cba454fd5e69661dfad362d0173a3"
