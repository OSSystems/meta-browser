# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "67431bb98554972f3c0bca820b9b800a"
SRC_URI[sha256sum] = "530e13e5dc83ac918e1c0c48f3a7f05e2c0778185c769149c3ab86f5841e6dc5"
