# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "853335c718c808184cdec1f7967c9131"
SRC_URI[sha256sum] = "8c4f7d9e97e0abba635e3a65cd4aa2ce53a48b70b9be95b45d5a1e91e830ddc4"
