# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5ee95a7e6c2dbe2ec4997e0c6f4db2e1"
SRC_URI[sha256sum] = "69b9e642cdad772efba6a770cd0ef2bfaa1fdd697252800431be5b2b42a8ac0f"
