# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ccfd97fad44b2f0c1ef2a3b63d51ac5"
SRC_URI[sha256sum] = "dd1ef41ab31f419f96e2e1cbf1ce2b6fef7cf5d144dc3338481177a390bc79bb"
