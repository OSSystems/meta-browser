# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a6244432d5223138052983e895525704"
SRC_URI[sha256sum] = "dbf9d3c24f64387d1ad6925bb96994a78f9798030f965b6835b8555c04d85afd"
