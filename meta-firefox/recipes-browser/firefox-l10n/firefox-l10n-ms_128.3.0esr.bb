# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c5d0d6c20e3c6654a5f0be1283a2870d"
SRC_URI[sha256sum] = "db689f4927029209a0952de37c3ccc47fcf25e7c11319199c3f05865aa01204c"
