# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "8c92152cf4cc894da04c54f13363eb903485e5a91e908a569e0f924031e4cb2e"
