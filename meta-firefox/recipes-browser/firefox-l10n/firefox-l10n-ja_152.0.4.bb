# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7cfe10f807b45a2159df55b6a33091371c140af9066178044efc7f10b58faf12"
