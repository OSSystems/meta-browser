# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1461d4c75878f40a61460828fd458d8e"
SRC_URI[sha256sum] = "9c5c96bc3b5db3c80ec59e7eac52eaf63337befef391a8b691b7907c17e61ea5"
