# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b116dad550b1a65f8830e7536629c70b"
SRC_URI[sha256sum] = "0961e3ddb62766e8c26c26106fcf9ee9e21ed2ba1115bb77ba8f0a2ea66baa26"
