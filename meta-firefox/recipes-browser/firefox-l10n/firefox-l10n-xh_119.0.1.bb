# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2634181a121ff852ef058841f1d54921"
SRC_URI[sha256sum] = "916ddbcf864bf8c1e689842236a14a14fb03c712c4cc9bacd85cb4ce1ac1bbd8"
