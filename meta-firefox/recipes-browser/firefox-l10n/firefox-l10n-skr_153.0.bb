# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c0adf16339727ded21483ff8779ca54698248c8e4b737543d64dfa5930c6ba79"
