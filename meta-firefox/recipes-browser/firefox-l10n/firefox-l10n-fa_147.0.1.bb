# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9c61af517cf279c892ba3117dbfb339f"
SRC_URI[sha256sum] = "c3f5771c1a90ac28214ebbe49447372ead8cf58e4eeb9b14670b546aecb5c44d"
