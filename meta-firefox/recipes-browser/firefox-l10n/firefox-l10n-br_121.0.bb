# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5839d5d959d0f7134f14822a8e257cf5"
SRC_URI[sha256sum] = "c296dc461947ee03b862e67296af0bd374cd95ca986af4f89751fd5374ae3221"
