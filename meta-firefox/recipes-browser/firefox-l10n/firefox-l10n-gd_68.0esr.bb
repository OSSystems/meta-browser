# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "78938713fac2d31b3ad945ec5996f776"
SRC_URI[sha256sum] = "5b59bc5319b09928a3807f9a5887ac9130d488c8642043c541654ecfc3a2a79c"
