# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9edd75692b2e5fc87f4b5ad5e32e1728"
SRC_URI[sha256sum] = "7ac8c13bd0ae57b2d4d8449090af00697a815dc912c709cfc3c883717a709bfe"
