# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "78f69212c949477f0a55edf11c142249"
SRC_URI[sha256sum] = "4df821658f37df6ba39ab4edd9cfc44a4a35d5af3c972bb2e8ea399a8633eb5b"
