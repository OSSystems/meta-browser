# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e7988a9395f3c8ffc3cb72806fabb861"
SRC_URI[sha256sum] = "9fa72fa10c58fe780b5cf9b2583b3d79841942e7d4ef58aa7f688843539bde3e"
