# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5638329634cafb1750c14cd68395a8fa"
SRC_URI[sha256sum] = "3dc634026d6048f43d759a94835619c42271817457e76140165241379179342a"
