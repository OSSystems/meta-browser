# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "88de7788b8ee217056cd6f977e1334fc"
SRC_URI[sha256sum] = "a7ab74a716e590beb73b81c6697e084d1b5ad0e5ef605d5730e0a0cf23d3665c"
