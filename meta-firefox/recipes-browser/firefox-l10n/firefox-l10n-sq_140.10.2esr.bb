# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ab5aeb1462d34f944bddd035bb1802e4a4cef93470bbe6a678fa01c206f0d236"
