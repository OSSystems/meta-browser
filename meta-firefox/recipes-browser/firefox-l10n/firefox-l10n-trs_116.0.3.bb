# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eb18738e42e3d3a6fdd452d7d8d87c78"
SRC_URI[sha256sum] = "9bc4942d6821a309c0b8601d16d2b2e146a9d5e9a6820983204aadb4109a54d3"
