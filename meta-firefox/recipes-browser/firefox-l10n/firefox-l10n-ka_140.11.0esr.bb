# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "90271e57d9baae541c9b73fb1f0f8aeb9c795adb6d568731de7d4ddd304dc38f"
