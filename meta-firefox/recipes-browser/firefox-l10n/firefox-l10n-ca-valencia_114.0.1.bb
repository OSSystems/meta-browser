# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "92df3a9c1fa97182617393444d8a7cae"
SRC_URI[sha256sum] = "5231a4c263fde263688f5382d696ddb0c6e7477229cbfb08a893ecb917866332"
