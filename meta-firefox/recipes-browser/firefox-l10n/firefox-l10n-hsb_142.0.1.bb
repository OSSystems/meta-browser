# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5539f7521f9d30f58ccf1b61a8a03ebe"
SRC_URI[sha256sum] = "40a4b192c79ee21f949f4a62a9ebfa474e8e2b416528ecae15d9f2be8502adb1"
