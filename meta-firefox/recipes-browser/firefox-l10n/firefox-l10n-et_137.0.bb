# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4d71435973cadd43610ecd3d518df676"
SRC_URI[sha256sum] = "4bf4b7f4e15edc82fec7f173a5648416fe0cf6576da5647af184f1a1b2aba92a"
