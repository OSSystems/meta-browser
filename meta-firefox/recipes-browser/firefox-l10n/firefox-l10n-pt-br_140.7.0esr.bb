# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1b76f26d5cf231f2c266ecf704441090"
SRC_URI[sha256sum] = "063410ec20b4964df8823c45e7622144edd9fb8cfa2d7d65c40d2a94ef405319"
