# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8a12b62456491f98f40e9c17117c7137"
SRC_URI[sha256sum] = "e22ebc15ed57d02e54ecb11c5d7ee6930c9a491c17ad52926151cb55be083a59"
