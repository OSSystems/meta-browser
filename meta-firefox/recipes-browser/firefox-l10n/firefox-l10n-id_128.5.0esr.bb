# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "30502d63651a569a0abe43a7c694c242"
SRC_URI[sha256sum] = "37d1e5a5c765001d9c93a196046371173bca91087f157cd2e927527b6679f50a"
