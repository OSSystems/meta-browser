# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1ef6f7f90c708f8a17472f13bcb85fb9"
SRC_URI[sha256sum] = "f72fb1a5851cb948ea9183dc430fc6c6530724379c4677e44dedbc1159ef0079"
