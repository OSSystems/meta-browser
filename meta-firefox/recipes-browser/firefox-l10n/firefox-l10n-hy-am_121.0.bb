# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "99d6ed81dcd078a52a462c9c0481861d"
SRC_URI[sha256sum] = "3d24b3ab09307f07767decdfb44ae6af86c9d37145c7c04435edd984bd279aba"
