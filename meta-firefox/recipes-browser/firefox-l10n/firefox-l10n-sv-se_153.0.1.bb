# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "41671a86ac068a2b5d4b2739d2d3ad9c437dfe7af4e1585a637d1ab17385efc0"
