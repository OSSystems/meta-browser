# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e8db75ad741cb4962c5d4f9b61054ee6"
SRC_URI[sha256sum] = "f81cbbe49e803de18af2eeba483e851279c133b77a6f5dfc0b5179512f1bb2e5"
