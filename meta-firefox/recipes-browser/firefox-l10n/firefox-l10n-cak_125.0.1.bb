# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4934965568a4dde0d3c75aad6c8c433c"
SRC_URI[sha256sum] = "83dfb4ed5ad1027110e1e4d5307d701e5dbb10ad0b68da4569b0d226c486aa66"
