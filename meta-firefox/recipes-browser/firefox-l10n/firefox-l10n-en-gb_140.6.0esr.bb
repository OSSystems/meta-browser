# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "66e829f7b90bdebe6f6b188050738ca7"
SRC_URI[sha256sum] = "11eaad528dda3a1e39ca752e8d00ca0a8abdec1343e013ed3d96f6f4874238a0"
