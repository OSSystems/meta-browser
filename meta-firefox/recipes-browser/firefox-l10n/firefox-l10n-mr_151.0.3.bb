# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "1c1df8de2a69fe7214b56641f014a4b6bda621bbb815f400fdbcf954b0fada57"
