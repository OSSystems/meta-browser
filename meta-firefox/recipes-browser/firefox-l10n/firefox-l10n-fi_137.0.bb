# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "af90667c0deebcc7a9d59fefbd11e350"
SRC_URI[sha256sum] = "aa3c0c01cd0ec12802d7d2040fe20b47e840593cf9d2679137eafe96bb9e8011"
