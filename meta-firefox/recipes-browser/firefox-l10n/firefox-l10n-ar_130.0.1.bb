# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "24c27723aa6aa532f55549ee2b2ab4ac"
SRC_URI[sha256sum] = "ae96d896a71ea64799542ffc1cadc396c11ec68e74d2b3e7a73de876984d063d"
