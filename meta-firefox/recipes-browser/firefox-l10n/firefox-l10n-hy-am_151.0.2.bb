# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "568524f2e7f1e5766143325e5c66749926dd10af9aec36d8f0df82ef81723879"
