# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "075dd827511d18e166a869ce59b14aa7"
SRC_URI[sha256sum] = "b4c68ce1bc84e4b875e2b0204321e98e2a24718bd343da0419f6ef78919df20b"
