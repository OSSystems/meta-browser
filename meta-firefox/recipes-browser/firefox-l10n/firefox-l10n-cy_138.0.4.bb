# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ecbd5c1a65040e2c361bfd759d7901ef"
SRC_URI[sha256sum] = "23a131eb7c413bb48bbf46ba94f29041ff19475026bd114e7bcd7a3081d05250"
