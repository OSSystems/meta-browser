# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "58f325c36a91c8b413e5fd2d1f5e1a29"
SRC_URI[sha256sum] = "b81839ceb13f1faa24f75507dfd0825c4e410980195d6c96e46fa56d2735e60a"
