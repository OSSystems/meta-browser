# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0f879f265abb4134d7dc186da85f5d24"
SRC_URI[sha256sum] = "13b4cef4920a7c6a01046b45f90b7297170bac512c8102868329d96b366eece3"
