# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "837bfe5fcac3a087fed843e195cab569"
SRC_URI[sha256sum] = "a7bc53bf17aa96ad3965816e1c47e69811311855c3e6f464de767cee3db2d5e6"
