# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "1f39597dbe1a9c024562d8b895ac7728956771ea4ecc83504e2ce340c3c8da10"
