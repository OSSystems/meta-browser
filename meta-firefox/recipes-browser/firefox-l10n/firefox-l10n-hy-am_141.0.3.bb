# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3b9c047fc99d143513ea7a417aedea06"
SRC_URI[sha256sum] = "ed120293af0a3f8a4ca08f960c68dc04a745d3b6a62580b1fd1bad368554eea3"
