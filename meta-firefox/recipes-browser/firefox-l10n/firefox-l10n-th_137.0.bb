# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cff3224dd57d8262a3392f36b6f58232"
SRC_URI[sha256sum] = "8d62c1fdf78ff66b2830d5630d04ce997b7f0b20d7f4679060abe6e490cda4da"
