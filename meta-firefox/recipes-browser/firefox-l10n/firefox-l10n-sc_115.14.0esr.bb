# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b9d8a7c670eb029e85da6ec644f99977"
SRC_URI[sha256sum] = "a401e301ca9924aa7b91632407c10d2fd1489b07b7fd5fcf9cd2ff842e45ad5f"
