# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f563e916c3eac792ec3c7556e9d9b85d"
SRC_URI[sha256sum] = "e6ee8fb421be5fffee1ccd1d1d28e1fd8f73c2fff58e9fe0c9b0f4054c4b8049"
