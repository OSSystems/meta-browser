# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f284856313afac317251f9edbaef85fc"
SRC_URI[sha256sum] = "16ac0396504453e770c0c033f2c7fba47a154c61c7a0e551bb4e2471e753ee13"
