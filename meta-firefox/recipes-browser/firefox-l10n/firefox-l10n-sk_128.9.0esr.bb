# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "54d07d82b21287c2b9aa70075f0e2f0c"
SRC_URI[sha256sum] = "db9b2014cdca8420e8d4bd2cf2014ef1aca2485935b4964630b751a6983668bf"
