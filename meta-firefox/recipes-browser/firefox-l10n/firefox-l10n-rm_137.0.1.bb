# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "78961efb358a79a218f30d1bd2b9d261"
SRC_URI[sha256sum] = "60d36c234df0d4a715814a740dea8290d1703359dd062197283ff6a0bbdc3f4c"
