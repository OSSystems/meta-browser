# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4b45f86b74498c4c1888f8fd8cde8d26"
SRC_URI[sha256sum] = "605837e6e95890a50352dc88e786e857d36bb6afa5f8c815ebfb56175b544ba2"
