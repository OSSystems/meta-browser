# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f163bc64908f8c285da5ec7f57c9ecf5"
SRC_URI[sha256sum] = "03f613bb80158e6de710661834d5e70439bf250ed3228b35503c873094391291"
