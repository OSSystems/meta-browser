# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1332efe3d23ed4b7501d5c35a233f4f3"
SRC_URI[sha256sum] = "4810484e3330af0b0279aa5cd2febe3e1b5ac25b027bbabbc43f61bca581ae29"
