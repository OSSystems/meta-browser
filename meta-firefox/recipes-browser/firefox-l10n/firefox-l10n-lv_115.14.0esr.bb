# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4a740031ddecdf3e9f87bb22317180d5"
SRC_URI[sha256sum] = "9dc70a46186a5641affb9bc0538f4e5bb0c658869fc6b9f6320abc631e46e0e9"
