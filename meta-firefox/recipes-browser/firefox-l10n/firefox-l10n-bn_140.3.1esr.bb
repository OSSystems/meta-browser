# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5d84e9105d30410629c8d58f4a6756fb"
SRC_URI[sha256sum] = "7d58aca40739f619798c99358100ae72246b2c29baa12e7988c989f0efd3a672"
