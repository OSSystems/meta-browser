# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "997ccff37cfc4dc34c1981b8d9d9eba9"
SRC_URI[sha256sum] = "28121cf2a0007ef41664549e3078318628457843ff95ea6974eef00238d869c8"
