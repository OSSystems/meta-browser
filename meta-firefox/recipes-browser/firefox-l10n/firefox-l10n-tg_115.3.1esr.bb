# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5833acb0518060809463e968d6f58dc3"
SRC_URI[sha256sum] = "30f3f072ca9bc8add9735da9d12c2d4a6609de97ad64175688b5d651547dbb01"
