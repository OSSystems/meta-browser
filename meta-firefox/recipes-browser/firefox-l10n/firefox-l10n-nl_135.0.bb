# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5031c6afee43f8856c62d16a2bf0c021"
SRC_URI[sha256sum] = "131ed6c850a7a033c98f29e3c13c6407aa7d722ba5fedb7f983a7effc2445119"
