# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "55c20f6a46eef8c1565adf3b95bb7f28"
SRC_URI[sha256sum] = "be1ba4cc4c9077630faeff752f7ef01d38388a544aaca52f5005181594482e62"
