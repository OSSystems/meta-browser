# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bdf8ba4d03281e081cc7cc1ec72a55e5"
SRC_URI[sha256sum] = "10884375bd1240b1d3303d98c7fe646557bcac33f428ce3ecd866b3f877bca6a"
