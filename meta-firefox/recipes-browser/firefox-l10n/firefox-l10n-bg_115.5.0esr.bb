# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e0946e553cdb3fa6aa29dec3636c5dad"
SRC_URI[sha256sum] = "7898a040b543c26f8bccf3feddbdd3a66edd9687112e6b8ff706d7be190bd4de"
