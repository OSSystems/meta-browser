# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "58fd06a12bace05ea97fe6d590011a75"
SRC_URI[sha256sum] = "0d2bb35263e922dbe65020929e50328ab35043b0dacf7d68f80e43ed051c67cf"
