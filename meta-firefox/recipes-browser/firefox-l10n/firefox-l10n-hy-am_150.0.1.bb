# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c70be8b2f01247030b31e99a33a5ae19eb836a15cb0c019bcef8e8df33ce9b37"
