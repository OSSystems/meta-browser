# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d056f6d3298714eb7575842676e72df8"
SRC_URI[sha256sum] = "d36f1b0dcb327cfc6fdf61e6969736d194eeffc806993bead68c1680b46008a7"
