# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c9a232c97fc5465aafa314cdbc9c7414"
SRC_URI[sha256sum] = "9b0e5c7e024dde045e527efb3a07f0fa7bbfca2114d7c69687515c36d1b98ed2"
