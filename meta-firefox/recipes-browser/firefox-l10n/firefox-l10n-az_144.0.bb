# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b18519c54dff0f7b7c611ed54349f270"
SRC_URI[sha256sum] = "77752415bfabf6b785fea1f6bec56346b900e07e437ed0f1fdba40d22df876a4"
