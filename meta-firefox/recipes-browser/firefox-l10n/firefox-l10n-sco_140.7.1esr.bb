# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e2347f694dd66322212bcf543e574098"
SRC_URI[sha256sum] = "99b420a7c1767667065076639b20a2a209fe6c1e49558b51363afe1f26960d33"
