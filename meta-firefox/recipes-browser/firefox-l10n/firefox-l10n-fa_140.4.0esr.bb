# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "affd68a485c7a78a8f2f4aa37b1d35e0"
SRC_URI[sha256sum] = "5ed94c8c787304351de80572e2b50c8a46fd0e4eb8c44c23ebc8af5f0a060edd"
