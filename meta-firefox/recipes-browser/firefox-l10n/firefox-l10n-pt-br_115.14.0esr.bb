# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a4808ec3f2c5a38f9bbc198d58c5a5fb"
SRC_URI[sha256sum] = "f6a6c422db7464a5a9e1fc7db980d2e7e7402e74d426855624288a6277c8f940"
