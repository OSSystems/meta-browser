# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e245aec3e15e6d9e45fd111cb9ec64a6"
SRC_URI[sha256sum] = "6054f2beceaf0011ceee963e10d4f13f2484954b5ce66893705ab142e6d9dcfb"
