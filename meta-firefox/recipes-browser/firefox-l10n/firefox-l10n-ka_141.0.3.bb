# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3169f2ce6628e20b02d414a987b3f8d7"
SRC_URI[sha256sum] = "96bc340eb517fbd29b1779d772acf1881f688256938405d6321933e4bab4d7e6"
