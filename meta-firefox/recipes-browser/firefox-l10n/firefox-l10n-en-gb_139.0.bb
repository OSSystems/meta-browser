# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8e6386f204a042acf42f69b860542530"
SRC_URI[sha256sum] = "ac92738eff8f46cee7bdf13ae128c09f4e12a749c18a461dae2e851a905532d0"
