# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "370bc6d2a903eb59a986f18a1ff319c2"
SRC_URI[sha256sum] = "fe25d9327adcf90f8b0d871f7be5c6d4a52ac7be8c2993235b18e70cd06d98f8"
