# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a7811d39084ad060b083b7728ecab75e"
SRC_URI[sha256sum] = "2c07345663b619e22865bc96b65973bcafdc28cefd2f2011e4d7219dacf32944"
