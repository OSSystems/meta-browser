# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5fdedfebdcca32a2a27a1015f814045a"
SRC_URI[sha256sum] = "4c07253d7690e5296fafa3d1c5cdad21cd6c97f6c2a6bc2e131c6af432ccdec1"
