# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e89daa8014f084315496a06da27777bc"
SRC_URI[sha256sum] = "f8dfe8d8a4f8b618450ce1449d19856e90048c0f4bdd1a58b22f6af217b6a9a8"
