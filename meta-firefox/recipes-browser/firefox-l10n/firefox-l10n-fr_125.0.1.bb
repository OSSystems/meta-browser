# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a9e91a1890a57de7f59bf780840e23d5"
SRC_URI[sha256sum] = "5206c6b3351af4c8a02333db2b779d305ad7362f2655e2336f49290778b4864f"
