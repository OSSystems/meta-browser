# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3595c425572b2e36bf59653900b37a005a7102b0c49a8dd9e30ea8518795818f"
