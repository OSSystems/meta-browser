# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f9d5dc1990c91a25d2561811c374fd41"
SRC_URI[sha256sum] = "5790f5c1ca799fc9613f4a4993e5f2b780e404ff211c48ae46e93f161d1ccd68"
