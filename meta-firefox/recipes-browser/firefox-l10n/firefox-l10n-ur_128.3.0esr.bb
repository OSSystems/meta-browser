# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ced699829c57e87a22452a68b26c2535"
SRC_URI[sha256sum] = "593b82afb8e3829296088898df8aeb8919e37b26cb045839e65c08a4b774b182"
