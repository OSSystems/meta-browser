# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "514672a467831f0c5e2b34e15af4a766"
SRC_URI[sha256sum] = "f3bccdcb9ad1515f158d48e0d8fd7b8128b04f877f454af7f382b098502f12c0"
