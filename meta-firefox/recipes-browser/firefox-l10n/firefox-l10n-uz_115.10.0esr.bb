# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "405c00cc4a4e2a1fd18b9635546a28fb"
SRC_URI[sha256sum] = "33113dd19d2e8126331798d292661ba9603fb02567dba347ab39ca9eaaee01da"
