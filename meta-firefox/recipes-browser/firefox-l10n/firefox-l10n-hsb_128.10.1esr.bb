# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d242a9e8709c0d1d1a9a28e01933890a"
SRC_URI[sha256sum] = "0568deaebc7620d8e6538d26e5d308bd8f17ee4d77ec929d01711bc99076a4f8"
