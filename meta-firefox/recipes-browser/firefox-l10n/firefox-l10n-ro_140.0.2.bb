# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9491681b4a7e2f3588193c0611f7d441"
SRC_URI[sha256sum] = "98ca9d4dddb87f9058f71e3b81cfc828a8731ee8c5a362d7d2c6750cacd2fb68"
