# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1d0250410161d8df840f34d3774ba231"
SRC_URI[sha256sum] = "fdf2c36d60cc7f4d969e8d4b7d660c4681bf15ba498df0f36cb49933294922e8"
