# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4cbf02ffebd3ca957b83e3d69f0cdb89"
SRC_URI[sha256sum] = "082681b15f97fad5489cf0cd8ff341395b2eb47b30d84784293a78529b1a50fc"
