# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "886092dcf075b2829021f2fdd91f56517918af41f04240b7475c724784338d1d"
