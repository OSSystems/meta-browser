# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c100f8be94a81bc32ddc700d922158a0"
SRC_URI[sha256sum] = "ae7d0f5f462b8dd5a14e08efadf70e071e85530cf6cf7609e9398add43588eab"
