# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b83cf6d38d8932486fd9e5cd181aec81"
SRC_URI[sha256sum] = "1dd1407286d58e887a9a6b595d5acf30a88e6505348d4b6cc95d99a78fe2668c"
