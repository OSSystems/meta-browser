# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ed4b91d3f567e62879e7724a11fbafa9"
SRC_URI[sha256sum] = "8f142cabe1d96dffd54cd871ae5a3f5ec021b71d1605f99b7888aa32a1e1dcb3"
