# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "a68f76c60ca0d5de1c9c9dd6d0fecea536468a6ca4c35f1cd349f452e920944e"
