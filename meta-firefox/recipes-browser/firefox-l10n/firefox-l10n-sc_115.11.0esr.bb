# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d0841adaacff8133064138794f9d7f1a"
SRC_URI[sha256sum] = "cc2dcd3c638940c4dca3254870fd28a468314daeac7e5ed5dfd42458f13a04d2"
