# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "82456f6acb7d2b2ec96fd88e74255be2"
SRC_URI[sha256sum] = "bdc53435c554f59dfeac63fa6173dd855eef2372a42dfe54f4c366591068737f"
