# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f62a8a8a0d7765639ac9535704ba3c64"
SRC_URI[sha256sum] = "94d8d44033ee7eff9cabe87b8b1ec706969cf2d54e03e8878cf63aa6212c0183"
