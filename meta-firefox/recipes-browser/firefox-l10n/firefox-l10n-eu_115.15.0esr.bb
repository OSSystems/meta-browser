# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ea03ceca618e8535bddcacc01f68af49"
SRC_URI[sha256sum] = "09018f5a18509c9cce6660222188ccb1eff4d7619324f8f3b037bbd43cf3582a"
