# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7d3849712586196f914d3011d7a0a2cc"
SRC_URI[sha256sum] = "77996370af30fbbc4e8e65ffc38593cc0e35f2392be0b065aeedc7e1dac580cc"
