# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "b8b75b184b1fd79bc97fecf7002455359ab1924a8b81d978d979852b148ae04f"
