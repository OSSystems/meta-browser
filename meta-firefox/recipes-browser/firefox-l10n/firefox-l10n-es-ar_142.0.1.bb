# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6789b7db30e5aaeaa21e47c686826878"
SRC_URI[sha256sum] = "3230495017dcd7b82849533e203d84aa0191c6d5632a8a01e4921afa69503c72"
