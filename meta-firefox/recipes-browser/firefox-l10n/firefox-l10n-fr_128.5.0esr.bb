# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "065be08330c60c4dbb2a145a1f51a358"
SRC_URI[sha256sum] = "5f34fac8e8f6c2b0bc3d4c6d36245ad622b88fc559452bd9af8e3fadf89904b4"
