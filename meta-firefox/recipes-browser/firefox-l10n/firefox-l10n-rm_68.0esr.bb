# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1ffa5aa7437e4f214852d6a2bf990f81"
SRC_URI[sha256sum] = "ee75563199d333696e4f4d7f92b2b0d7437c03069b861f2220249d4f88b9546b"
