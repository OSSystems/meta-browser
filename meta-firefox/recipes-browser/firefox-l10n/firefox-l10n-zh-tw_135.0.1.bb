# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ae1fd7ac53c887998577a7a5eab084f6"
SRC_URI[sha256sum] = "fe58133269a591d2cb42bfcbbd42866df2f797490cb0236958f5def1d246a343"
