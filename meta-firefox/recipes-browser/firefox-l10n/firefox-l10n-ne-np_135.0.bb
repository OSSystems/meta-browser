# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "64018825865a1933eb2b4166031ed92e"
SRC_URI[sha256sum] = "cf8f1cc9a681ef9b4845e01e7dc2e45f215081c25fe82bffba19fb268665df49"
