# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dce52aa3029c68042232bf92a7826de9"
SRC_URI[sha256sum] = "f36482ac652bd9276225aff1e207e5cfd2f3d93028bb85fa2638ff7a0483e9e8"
