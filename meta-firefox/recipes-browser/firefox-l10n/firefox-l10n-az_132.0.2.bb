# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1d314f2a4c8ea3e8c9a8aa6f660f0cab"
SRC_URI[sha256sum] = "721e79e0e51feae4400aa7ddf757b38b957e7890e763b690a96c77cd3d927a82"
