# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d96854bde94255927b69daf4e181cdcc"
SRC_URI[sha256sum] = "d987a48fe16f3a6b2125e02cb67dd9563ac0a5a836a51fb2e6c10588af40b497"
