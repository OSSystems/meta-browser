# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "b1c2f539d8ab522cece8a1b460b46f4467c59830a419885103bd1a25d839fd9e"
