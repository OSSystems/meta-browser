# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d314d9a22b145c470b4c8393fdb3b738"
SRC_URI[sha256sum] = "0236ba51db370563b152bb48bcc57f3e1d0c7f6ef1da04fec09a70451bed4161"
