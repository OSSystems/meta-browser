# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "daf69f541d48cdfbe6f5d347c58cf7db"
SRC_URI[sha256sum] = "fd5d87db516c524c53144166465e7b841f8f73c8d2af291d8d02534a9027b180"
