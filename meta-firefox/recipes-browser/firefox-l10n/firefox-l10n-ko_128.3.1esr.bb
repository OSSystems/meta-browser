# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "252abdbfcbc636acc8289db9f84e3032"
SRC_URI[sha256sum] = "bce3999a933be717019969c01245affa95e624c5ec1e677c03035c7d35c3c119"
