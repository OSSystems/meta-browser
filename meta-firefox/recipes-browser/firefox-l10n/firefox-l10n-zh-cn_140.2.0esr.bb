# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "953edd06bdd74ab0b90dfe1dccdd9610"
SRC_URI[sha256sum] = "65a61bc387ed82fea60f5d60d33dcbd9d4a8d8656c9158d6f9a8b67abad33093"
