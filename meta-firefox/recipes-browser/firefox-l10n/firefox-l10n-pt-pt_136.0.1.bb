# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e02cfcaf826cc5f18f51fe1f075ac861"
SRC_URI[sha256sum] = "633c5da24ee6e192c459d8e88b4df8e2e46946f91866ea4b12ddfa6a7fac1ac8"
