# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "44891a12c14d5891560545dd5e28b22e"
SRC_URI[sha256sum] = "e230a22ed6657aa592c720ace143eec6b93dc2ac0493d655f3b7c7f45b1582e6"
