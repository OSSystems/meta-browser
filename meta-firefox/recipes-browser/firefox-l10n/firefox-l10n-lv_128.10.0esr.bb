# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "03bfe74e5f1963690e3cdd7985ae37fd"
SRC_URI[sha256sum] = "1b4971a1c1850919cdd2b8b0e5fcf53ce45ff5e66089cb7e35f0a2a045a2e8d1"
