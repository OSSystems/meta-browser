# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4669e4b8f47961cd2f7b567ab018636f"
SRC_URI[sha256sum] = "f616624cdbb6c8abd65cdbaae4d098eeadda4e42ee8e6c3008dc36be45bcd89b"
