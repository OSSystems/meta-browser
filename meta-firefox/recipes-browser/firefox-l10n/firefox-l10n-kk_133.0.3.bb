# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "13ceb9357536d8d348147cc34b28c38a"
SRC_URI[sha256sum] = "faae7de70ddce7239a64fefaaac484283c9718eda23dddec614f3f2fe6c81d6c"
