# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7abc4a1e45f0f771a8d9f0b02278ec4a"
SRC_URI[sha256sum] = "fd91a1ca530146edf11b0366f1bcd306e17e7af67087a0ba48b840b593bbc793"
