# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4de9f992257b68096e3dd62386a80fa6"
SRC_URI[sha256sum] = "6599850c9b0f7ce7ad0df271fbda4cc822a6142fea132d4c6c33eafd3655d7f8"
