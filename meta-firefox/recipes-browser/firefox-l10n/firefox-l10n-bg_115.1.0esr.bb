# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2981ef4b63013b49852bca0c0a6d279d"
SRC_URI[sha256sum] = "98be1b4b5769eabf4d16b7af6d4e0a6f879564846a8224b69cca538a5505414c"
