# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "f5d302ac353b2c2dd8af80f53d83915300c954315da69d05a58aa8ae91f88ee2"
