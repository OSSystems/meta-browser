# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eb9529887c68135d6ee2b594dd156701"
SRC_URI[sha256sum] = "cc264e5b8fdaa57ad6a94c33880e72ec925dc8680866c73164f498c4de8e2f95"
