# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "14cfda6f5110fd188bc73c53833d3e40"
SRC_URI[sha256sum] = "d46d807c4d92fbbb9d79cb94fdd30326c165224c4dba628c5430762044e55b9c"
