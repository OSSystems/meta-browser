# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ddc3ca98ab0bb319313f23f937d5b9c8"
SRC_URI[sha256sum] = "1aba1ab2a3edf436081fed8a90cb6812a52cb3e680ccc117a5001792949183cd"
