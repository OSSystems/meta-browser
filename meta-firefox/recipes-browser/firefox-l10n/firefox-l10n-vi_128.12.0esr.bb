# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1fa99edbf7a0af77fb7e8b6eab743ce1"
SRC_URI[sha256sum] = "5c55fe280ce35cabe768d83cf27569aecc035dc5b19167a1066039a6d7a63417"
