# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "323b868000a63ebcf4927b0c92adee66"
SRC_URI[sha256sum] = "4b86d882f94a706f8f9ba128070e272d98f5142636d0a3d32bae864c832354bd"
