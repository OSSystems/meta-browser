# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "62798aeb956904bb54172e60dfb16ba5"
SRC_URI[sha256sum] = "03ee4d27ac4c3a17af500fe7bb09e4cb2d658a242f13ec727058195745a9055f"
