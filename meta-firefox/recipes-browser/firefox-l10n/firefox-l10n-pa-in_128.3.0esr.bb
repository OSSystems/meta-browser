# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db444c228debc7467e1bca4a8b70620e"
SRC_URI[sha256sum] = "47d2cf6acc3418e2a854cb474b61f52acf482aebcb2d36e6bf3b155fd036e8da"
