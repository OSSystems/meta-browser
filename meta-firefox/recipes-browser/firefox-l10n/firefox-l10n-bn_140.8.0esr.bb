# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2b854ddb635c40ebd4f408794e947fbf"
SRC_URI[sha256sum] = "0d33b10fb47e83903c7245aef0ee33f2a8d3244d1439373597733871f4ba37e6"
