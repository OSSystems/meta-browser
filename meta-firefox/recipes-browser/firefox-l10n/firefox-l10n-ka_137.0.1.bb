# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ef0603ce0fdd170724814409d48abd49"
SRC_URI[sha256sum] = "768d0e285bac95cfd5765140f87f8e2113f5f6e18ed37df9d3d0984de68af0ae"
