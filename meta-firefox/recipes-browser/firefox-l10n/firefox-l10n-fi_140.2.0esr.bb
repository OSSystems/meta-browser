# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "31938c14f32b9ccd4d54942d5ba6fe7f"
SRC_URI[sha256sum] = "cc7071db165aa4981808c43a98a1d77ed2c8d03886adfe3e7f0e7811bfb03d90"
