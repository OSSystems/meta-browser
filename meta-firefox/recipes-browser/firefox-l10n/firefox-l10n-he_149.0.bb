# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8b4ffc9191d38c62de230be702753202"
SRC_URI[sha256sum] = "92ad1b977eb800840c3bed11767c9de7deabd57c82eb625735db244fb4f4bb0e"
