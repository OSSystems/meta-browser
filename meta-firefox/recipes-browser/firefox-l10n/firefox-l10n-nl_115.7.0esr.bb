# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ce805fa22ab319f39a162a9b165341ad"
SRC_URI[sha256sum] = "55869a863918879065d9cf3b764d775e6c6c3cfb1fcec670613aefacfc23e0b1"
