# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "88abf0ebfeb354fc21df1391317e60315aa56b52e2b3818285c810267ad66545"
