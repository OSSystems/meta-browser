# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "132f03d87031d55fea8670d5cd449860"
SRC_URI[sha256sum] = "3361a6bfe2e05a2fa13644153add914d86f44061074d3d31b8271dd251ce4a82"
