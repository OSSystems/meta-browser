# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "6e73f1631d0c5460c172ad08fcb25391754cca6919e61989a7e062c44365c45b"
