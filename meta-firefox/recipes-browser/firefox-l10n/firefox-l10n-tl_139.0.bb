# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "932fa63a0458a61b2a04c6b43f3f1d28"
SRC_URI[sha256sum] = "7df63567ad58c4d85cb778c2d996d24fc44fd0694747837f35eb33cbd1c3f501"
