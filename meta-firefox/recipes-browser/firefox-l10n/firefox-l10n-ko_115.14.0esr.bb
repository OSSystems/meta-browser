# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "caa03b0c4940042053f5bf7fb88a734a"
SRC_URI[sha256sum] = "e5c0b74bcf5955906f8142500a6c357ff360d2b9cc78ff5b0db2a8dc447320f4"
