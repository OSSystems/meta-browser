# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ebd55fdf7247761b0db1f93decdedb0"
SRC_URI[sha256sum] = "4791ef11ac5c139403835552764eb6b1d1463ad3d9f5b2a8a9bf9484a3ee41c7"
