# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8b235ee48257b654114ae52be7c7f800"
SRC_URI[sha256sum] = "e2821ae4345496b9e8ca62acf416af881951b72f28101a60258123378544505b"
