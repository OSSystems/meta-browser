# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6d9ce7d891bf5a233555884d375f452e"
SRC_URI[sha256sum] = "1ee276bc2707b51b4a1fbe46f06901ea44c101bfde39c5805d328eccbcd99e53"
