# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "242c974905eb87709c866e252047d525"
SRC_URI[sha256sum] = "245fd4867e8c0072c58dec301149dbc5b7004a91ae2c921988fb1b58c6ce63c8"
