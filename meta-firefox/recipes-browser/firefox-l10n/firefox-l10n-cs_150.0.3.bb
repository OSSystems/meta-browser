# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "1af64317431556434c966ed786ee85fcf30a2302bfe1634410d0607633e766b5"
