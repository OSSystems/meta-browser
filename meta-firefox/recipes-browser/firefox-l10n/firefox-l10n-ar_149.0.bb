# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ff5fa92d755c4f12fb388aa2ece45555"
SRC_URI[sha256sum] = "e611d3e5386b8f110062caa1b8956410be120c91f879485c42177d4c2373c241"
