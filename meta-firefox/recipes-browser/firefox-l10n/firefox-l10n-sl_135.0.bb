# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9b47add0f4f99562dc3e45e3318acc7d"
SRC_URI[sha256sum] = "d99298715ef9f1d9b888c757307595efd89473b3d7b6dbfa80a0f5f4c5d9a05a"
