# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "337a83284f6788874534dd79eb26649d"
SRC_URI[sha256sum] = "d092ef8e45a0454d8dda1f2a820f34ce03f00eaa6653da2e637336f4f34144fa"
