# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "75a023c3d6e664c48a128ea2f050556b"
SRC_URI[sha256sum] = "bd3bf3cdf293ca8ad0fe10108cf6293a958879c94501d2b5967b05fe4a2ed2d8"
