# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f7a109b8ad4c1e06340c3bb06f902bf6"
SRC_URI[sha256sum] = "9f9a6bc5574dfbbcff5be78e2dd520f805282d411baeefd164521bf0411c998a"
