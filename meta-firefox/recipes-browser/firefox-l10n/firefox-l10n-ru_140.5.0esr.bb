# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "475a2444338eb0dd349dcfa36fe8d240"
SRC_URI[sha256sum] = "a772365319f0ea2393ce60c8d8695df128263b3b6a8296be96feb395d2523e5e"
