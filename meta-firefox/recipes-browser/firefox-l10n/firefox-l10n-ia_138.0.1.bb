# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "41f448a4997c407965967c92376b1e62"
SRC_URI[sha256sum] = "500a7c5b643d10f6967f0ea4ca526edf19b8a57dd7bd39ec9ef86d9df8ae05a9"
