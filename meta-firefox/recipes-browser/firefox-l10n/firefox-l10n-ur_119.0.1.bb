# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9a7f9fa743e8e264c0cd7192eb48177f"
SRC_URI[sha256sum] = "56342064c91c18d69339b3a4fd227626af10f140fc01094c5cd884d6b7d3b850"
