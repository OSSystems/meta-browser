# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "6e0d0aeabbbb3c38f7d448407d54a9b723151835d26828b62158682cb12aa1d9"
