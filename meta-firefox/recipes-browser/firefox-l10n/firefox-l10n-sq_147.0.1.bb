# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c6c6341db1667a047720bd740372f486"
SRC_URI[sha256sum] = "d2ae24123b2ba2df557700e30aa262dfcd0340b94329d13d38235068df730297"
