# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "915849dce827bfbf5e540e2b90f07acb"
SRC_URI[sha256sum] = "cd29dea17656f98fca20e93f2528cee55d6713bd1015d60e38ba8702617330c2"
