# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "eec9d62e1293bbaf199fbb43e8f319ba378e40e630c57d192d059783e74bffd3"
