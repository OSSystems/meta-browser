# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "89a59951b4b558d1514813d25f85f717"
SRC_URI[sha256sum] = "feacdd89c3a287dc960864288a7328828caafe9ea7db15dd8bfac7c4cba02f8a"
