# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "750bdc80a1afb71e88324d93b04eb0a3"
SRC_URI[sha256sum] = "1f7db2b244f07f911505188fc7de8e19031c075a826933330cb9906e02a20649"
