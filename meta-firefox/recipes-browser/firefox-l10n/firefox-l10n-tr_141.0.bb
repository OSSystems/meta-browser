# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0196821a4f0b9e0ec5289885a150fb42"
SRC_URI[sha256sum] = "cec3d533e55a06d099e1f014263fef9cfd9ac088d2d2f7bc636ba6ff10086865"
