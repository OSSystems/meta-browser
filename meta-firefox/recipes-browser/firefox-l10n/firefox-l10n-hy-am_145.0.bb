# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2d0c9de40d547c958ce75f08b274f42a"
SRC_URI[sha256sum] = "a2af303d34e6256570ec82425a032cc3cccec384836d9cf59afd8e8bf689043c"
