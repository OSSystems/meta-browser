# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0e465355d68df08189dee4e4a458decf"
SRC_URI[sha256sum] = "5f1b00925bedba3d2537c8f29effdcb0bb2a3f43c6d1fa60c89082c594f92978"
