# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "66e942a05c6481ce7d1fe2b2a620111c"
SRC_URI[sha256sum] = "766aba669469bddd2fc4e8ecbc27ea527ca0e190dce59bbda9793b00a5120bae"
