# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d1df3e5e93a2fe4e58b975ca9e618f5d"
SRC_URI[sha256sum] = "133665b5844af8403dc4a9fca919048ffe28c71ed03827ef102141011da0ad4a"
