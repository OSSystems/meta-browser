# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ce4ed53638113d02b2bea9cd12f89c8c"
SRC_URI[sha256sum] = "764c84ff131aeaa5e7f8fbd6605cf95c46fdf3020ae793b35264afe006acfb5e"
