# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3928528d7ea21124c6b7d526c984f632"
SRC_URI[sha256sum] = "76b8076d9853301af523787e6a96423a7b7505d6293605858eba9a4af1d2b386"
