# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e89c31e3b5befbc74ead0f54a5decd65"
SRC_URI[sha256sum] = "2a7fc48cf23cc0f3aea446e1a214581986ca770686faeb277e4b7b2f5b94ed33"
