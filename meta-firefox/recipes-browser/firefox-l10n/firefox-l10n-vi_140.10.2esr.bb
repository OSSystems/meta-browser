# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3c9a97f96fee976816143e686cfc224384d3861b76ca968d1e72028aef6f308b"
