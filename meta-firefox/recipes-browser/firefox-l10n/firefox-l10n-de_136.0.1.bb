# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dc698597a0a0a0bb82ddb9fbc024d5a8"
SRC_URI[sha256sum] = "a055a49748e6d269cbaea25dec0f74593c76a9e4ac8824eb15cae4abf3f7f3c1"
