# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7ffaa12953387657bc4eb0267e8a097b"
SRC_URI[sha256sum] = "2f37632486f1ccb1d29ecb0d3e24e45c864d68e41dd6224c7b829fa077945636"
