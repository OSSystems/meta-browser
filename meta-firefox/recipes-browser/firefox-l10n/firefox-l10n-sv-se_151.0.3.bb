# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "85f7da5b8be8e0cf46ce8b5450f3055d76649688003f61237f8f44fc93ae8577"
