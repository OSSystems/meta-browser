# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7b47938f6ae7e7870dbb4960d4f1bc65"
SRC_URI[sha256sum] = "cfbab8e48f9baea1c74eae1cc5078821ca0f052ddd83d226f4ca0c8a34afc549"
