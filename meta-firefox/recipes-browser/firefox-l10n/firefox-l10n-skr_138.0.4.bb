# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "716df091c94de2e18c2bfa91fb731d95"
SRC_URI[sha256sum] = "75d5ac745812cb8ea2fdc03178ec9a2bf8317702ab5198297dfec125f91958d6"
