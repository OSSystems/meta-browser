# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a7b7f24e9c828ab34f18809bfc8cd7ea"
SRC_URI[sha256sum] = "3217f3b56da240f4bf643ff272484c906969496e3367755bbdececc09b132634"
