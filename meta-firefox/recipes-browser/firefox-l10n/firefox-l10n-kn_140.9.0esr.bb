# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8802cdc585d5e7b09d028071dcaae226"
SRC_URI[sha256sum] = "66bed5e0feebadf97b072edd860b1bb4c29af7d2af9d59dedc5b7eaa634ee16a"
