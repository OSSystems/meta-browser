# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2163236d922e2603e837064a14bc69a4"
SRC_URI[sha256sum] = "1cb10015d715d42406d19ab3b56c5bcd7be6b6b2dee2169b9f7babe17079a794"
