# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2a7fb646c07c72bbedf4be304f84873bdae35a7a79fb29cb5b39f47de2da818c"
