# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b74def683322f525cf7cf896ec16ef49"
SRC_URI[sha256sum] = "02d582174d0e10a7902f914eb5b9cfcc078aa5f4b160629b3285f23b265aa452"
