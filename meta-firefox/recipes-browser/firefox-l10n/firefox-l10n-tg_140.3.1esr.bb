# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dc9bd6f5e8f869ab9c961203e020d3a4"
SRC_URI[sha256sum] = "81ffdef31a2ac2bae94e6a10579c09ac85b539626fa766db1b7c7ba0e75e60c5"
