# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "058b636f9c13c187846b1a4cce3ca823"
SRC_URI[sha256sum] = "b7d161fcbf4a53270e8bca21620a1143f1c905b1b59226878c4c5d6581c9638b"
