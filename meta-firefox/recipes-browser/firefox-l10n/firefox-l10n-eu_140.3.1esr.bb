# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7985814fcf7536c33f3a0c749bf9016c"
SRC_URI[sha256sum] = "4c5647ae42f9306223c2623c063a0809cfe736f4ab2766ac5c8a6f856f94ca81"
