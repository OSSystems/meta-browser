# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a3340c4e7bf5857b7c23d7d561693252"
SRC_URI[sha256sum] = "9260fefbe4561279d6af6129bf29fe4c6e82277d363fb8713f1779313849737c"
