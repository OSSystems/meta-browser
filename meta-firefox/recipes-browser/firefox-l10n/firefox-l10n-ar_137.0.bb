# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "559f86aa42b3191091231275d4ebef37"
SRC_URI[sha256sum] = "11a5cd0b2cef8108567bc8aa28d6b9a7edf4d234e53cb3e859410fb02dd75623"
