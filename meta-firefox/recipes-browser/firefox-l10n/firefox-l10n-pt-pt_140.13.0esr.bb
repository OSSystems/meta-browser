# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2bc7729a6157df09d4d2ff1c566d0ac5be1449b5ee106bdd7431f78650ad8e0f"
