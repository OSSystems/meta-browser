# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eabbde193bd972e5a5672c2939189b98"
SRC_URI[sha256sum] = "b6f8f47602d1bd53ee5b4a3d52e3fde0bc2987c2428a464bba39a433334c914a"
