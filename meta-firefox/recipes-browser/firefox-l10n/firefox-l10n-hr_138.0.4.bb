# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c8473a3f4f82552dbfc2af2b92a53063"
SRC_URI[sha256sum] = "361713521bd2385aa191054faf7c04d371500c040aaa141c0add0242911332b7"
