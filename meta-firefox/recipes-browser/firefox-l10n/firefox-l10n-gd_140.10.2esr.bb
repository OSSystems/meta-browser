# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "b74760af59cfe2bf188480a7fe6f228cc76e288d33032d04aa69925a275be621"
