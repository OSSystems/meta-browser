# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f6b1a1b53d14846cc9c4719a134fdd50"
SRC_URI[sha256sum] = "627ebc1bd8ffe82ce5138e408badd7465b553b9103dfc26819133b5ca580eeb1"
