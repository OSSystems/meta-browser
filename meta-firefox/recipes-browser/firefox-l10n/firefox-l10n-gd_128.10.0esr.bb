# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "51314f5aa884d6fa6d8f1cafb43bc36f"
SRC_URI[sha256sum] = "d74d5c1950b608e31ea5e305caaea9a680c0a7a2ba41b85f5215365817f61fef"
