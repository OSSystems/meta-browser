# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "14d742507694c475bf9cc9ddbeab1fd4"
SRC_URI[sha256sum] = "f9a75bfa4e96acd2dc50c3d26c2b8eed4ca179fb08aef2edecabc30604745316"
