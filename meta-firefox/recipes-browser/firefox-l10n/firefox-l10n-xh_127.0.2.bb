# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b6319a8e48793553acd27681d3e1007c"
SRC_URI[sha256sum] = "74f9b6a028b816d1b8348250077e8822176f37b7f6938aa365e9389f55315170"
