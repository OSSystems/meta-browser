# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "65c84f0c73215dad0a81c43999cd7f32"
SRC_URI[sha256sum] = "e6cde9844f9d3b721ce4ae159b99b3368268b82b8d2b47742aa33191f29e5a20"
