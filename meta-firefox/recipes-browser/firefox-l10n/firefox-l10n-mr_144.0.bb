# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8b5153efc4f071aa98d385bb16810184"
SRC_URI[sha256sum] = "5a39f91bf68f492bd5e1f5d60713e5d6e985154f77b5f164879e4ac7228c0fdc"
