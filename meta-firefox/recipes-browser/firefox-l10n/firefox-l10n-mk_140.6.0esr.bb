# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9a103d4aa0a487921dbff5ce10893864"
SRC_URI[sha256sum] = "8b9e80bbb0037929743da7438fd6fc9149f76c6e0bec3747d05a00ba8e559797"
