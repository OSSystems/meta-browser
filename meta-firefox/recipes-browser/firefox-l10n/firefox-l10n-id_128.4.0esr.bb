# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "384481e3e115191ee897e9432ae1561a"
SRC_URI[sha256sum] = "36e649f3df6815d6adfa69d343df2b210780e95dddaa5186b3e61cdc5524ecf7"
