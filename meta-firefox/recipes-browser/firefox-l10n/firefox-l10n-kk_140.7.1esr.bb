# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b15c94d0b56a02e4a314a39036b694f3"
SRC_URI[sha256sum] = "73ba13c31cef0b9503037d1bb7a74b9ef1658419701b7f64376b9b393ee096ba"
