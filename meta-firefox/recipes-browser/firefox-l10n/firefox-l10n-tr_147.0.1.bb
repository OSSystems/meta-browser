# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "028a263831ff1c90d71bb0e41408f4bf"
SRC_URI[sha256sum] = "6a2ec3677f35a127e92db8dd92710e3672ddc6b2714943ecec88cf4fba0ba1ee"
