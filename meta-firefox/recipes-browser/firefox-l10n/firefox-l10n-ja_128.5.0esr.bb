# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "00516f9dc3f8814e7e99b8b749009d69"
SRC_URI[sha256sum] = "7d1a9a54c685b4d2355b2443e41e792f30a2da487f68f97b2582fa79ca5d0078"
