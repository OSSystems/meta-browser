# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "6dc5b529509355666c63bcec2f27c75d4f05a2474986f9e8cd79d0ff90e74722"
