# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8624fe5d6aa0acea1cce2f95d08c15d0"
SRC_URI[sha256sum] = "531f43ab7b3a56ec98e648240f69e607fb410dd3b81b33e6a916a45270c22dab"
