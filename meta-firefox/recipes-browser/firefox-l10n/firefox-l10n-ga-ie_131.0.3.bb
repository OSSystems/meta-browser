# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3d7a0e519ed57fedde60f447663355bd"
SRC_URI[sha256sum] = "ce16c0f04d3f0713b884fd24fe40304e0ec6e32ec65a929badcab78a526afc5d"
