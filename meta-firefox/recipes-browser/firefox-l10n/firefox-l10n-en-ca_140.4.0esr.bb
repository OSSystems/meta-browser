# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1cb0f66ae24b39247552e9b3f1fc16b2"
SRC_URI[sha256sum] = "1c51766a945b0619db4b4a4d624332ba66fc3f4f5a122a973a96bbc68afa7e62"
