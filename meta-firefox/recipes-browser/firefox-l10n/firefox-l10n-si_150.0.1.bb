# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d3e6ef660b1d5c6557da7542fda034361b2a9268cfec18e36a059d8c0e3f8379"
