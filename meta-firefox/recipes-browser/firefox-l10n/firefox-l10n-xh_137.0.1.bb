# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f423e78ca5c3e2958c5d3b5ee35527f9"
SRC_URI[sha256sum] = "476eac7ec1fa14c442ddf1f15d10c8b01bc9f00b4ee21783943b7dd5bd4c0545"
