# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a43c7e1f344676c70608f2323e811676"
SRC_URI[sha256sum] = "42d9ef8546db48da3736f5331bc5530e34ba669cbb9bbad50d496ad041b9efc3"
