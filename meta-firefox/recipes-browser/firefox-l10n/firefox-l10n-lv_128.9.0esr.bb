# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ce2ea61cbdd59b404c33d5d525f40ea0"
SRC_URI[sha256sum] = "628fd6f1cb94d01118298b798467ded24b444f436c4e36ce5cfa7e5141e5b148"
