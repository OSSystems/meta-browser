# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "09b6c67c7f630afae6c91be04b9239de"
SRC_URI[sha256sum] = "08019288b1561a8dbac510fd1a3cbd91109b6be73cbd64c215a9f28733179656"
