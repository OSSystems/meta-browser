# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2525bfc9d7419de98a22a62c67b54b06"
SRC_URI[sha256sum] = "fb35c5fdf2d38c3d0e6d9ae9eb361fbe222ae41280471a24a94f04df7cec2bcc"
