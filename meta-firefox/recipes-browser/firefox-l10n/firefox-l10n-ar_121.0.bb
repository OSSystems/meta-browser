# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "40f6865c5dd389815a55a5270f6cbcd6"
SRC_URI[sha256sum] = "9294b43b53a15a102910904e450da6ac540b7bb78b0aa851894e4965ac00bd80"
