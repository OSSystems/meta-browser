# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2f3948977a202e93da0228a638694e95"
SRC_URI[sha256sum] = "177dba132448bfbc92dbccd606c88bdae64d287218e888e272af82d8374dd08f"
