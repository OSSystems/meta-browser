# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0cb5715b3584272671504c56314e02d8"
SRC_URI[sha256sum] = "0a2dfee81763574fe38e092fd4cbe26a2c04570d6605bf11866097b9093b1328"
