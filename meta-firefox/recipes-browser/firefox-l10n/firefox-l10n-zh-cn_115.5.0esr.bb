# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d48432d4652f83f0bb3755e69f967d0d"
SRC_URI[sha256sum] = "27d74d617ff3326eb21427a327b76ae3cec9bbc848eff6703d9f7a3eb78dedca"
