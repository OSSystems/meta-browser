# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "521a749988b91419fcff35c56ac2141a"
SRC_URI[sha256sum] = "ecdfd9452e7ffd34d45afa2a409450c2907c2cec3c90ed35d2972b2c0f36f406"
