# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "83d69cee11f2779a29a98fead7b801c8"
SRC_URI[sha256sum] = "5c3a41295979d9c4b921a7cad0d72601a192ae79eb6ea747fe37ac7e825d6444"
