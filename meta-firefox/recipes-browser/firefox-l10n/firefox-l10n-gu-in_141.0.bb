# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "40040565dc6fb5270b73db5f8e6e402a"
SRC_URI[sha256sum] = "7fc65f9933e2e092e6202477f1b44295dbdcaed27ed97fc2b48ee85052d426c8"
