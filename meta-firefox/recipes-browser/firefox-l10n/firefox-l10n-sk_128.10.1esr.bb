# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "35e68f809d42c5aa28d80736a67532cf"
SRC_URI[sha256sum] = "96f16fee8bfe87d7c5539bb50e731fe8c313b0fa90ef9815ed3456d7e9f7591e"
