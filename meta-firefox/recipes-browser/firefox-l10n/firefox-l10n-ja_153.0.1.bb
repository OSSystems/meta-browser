# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "69f4e305dfa6b48b1cdb3ae47991c35f706475d58d9782fc9a1b27adb8f9f8c7"
