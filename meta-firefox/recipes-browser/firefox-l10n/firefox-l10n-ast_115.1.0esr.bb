# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "11acd45c6812103f1f7652e6f937131b"
SRC_URI[sha256sum] = "e4ab40303ef8b0573d7cd67b282b90bb66e38f7b81eadc693eec05b0ab13fa98"
