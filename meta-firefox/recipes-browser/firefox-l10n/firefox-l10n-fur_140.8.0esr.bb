# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ab9a4e314c5c3bfc83b837375ed7b962"
SRC_URI[sha256sum] = "2ec5642cf9c0f0680402c9c03e30c16ab3fe45d60c45ce5c5ff0a53df3101ff6"
