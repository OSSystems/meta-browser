# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "76fab28f334a278d5174d93eacb432a9"
SRC_URI[sha256sum] = "3ac67cbff9305affa39458396e1d0f37f16893f32372569a437a1d79aecf6cd6"
