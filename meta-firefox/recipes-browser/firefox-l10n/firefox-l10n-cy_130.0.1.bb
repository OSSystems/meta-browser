# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "981b867e6df9a19bef04dfba14e10efe"
SRC_URI[sha256sum] = "462216231250fa8e059aad510f4e6aeff992731688847c656c720d4eb2c2a1af"
