# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "11d9202180193c0caa8b700c48cf04d34f71e7e43f958b3d55838e2b2436f202"
