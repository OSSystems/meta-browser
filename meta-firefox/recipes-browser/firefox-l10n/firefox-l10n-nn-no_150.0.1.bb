# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7e393963d89f396330650c5eb1cebf4485e06a4930c8f8c08db6cbe7c5a3d595"
