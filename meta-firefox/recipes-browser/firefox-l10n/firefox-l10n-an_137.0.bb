# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b261609034b7d3a8e5e6118768840c97"
SRC_URI[sha256sum] = "7f1f14fef3b346ec7b7dc6944ef011da23373ad9bee3efc9c7bd3a098a8bfada"
