# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7b31469d2e1a6832be32d5bd593df418"
SRC_URI[sha256sum] = "a1554b392b6f0af85b9eb62774e26bcedf378ced11328904d3a44455c7fa088a"
