# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a5bfed023fce58aa71653e78fbd9005c"
SRC_URI[sha256sum] = "49459d27c8088024ed8e932a45a02a6458be200ac6262cbfa0e0d2c4a547cf6d"
