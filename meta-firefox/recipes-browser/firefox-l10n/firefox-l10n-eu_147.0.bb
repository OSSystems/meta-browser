# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "76cb91801d226f2d389838b8dccd53e1"
SRC_URI[sha256sum] = "f6b8ac969b42808c549cd805acebd9787a8b62f1ca1668c54fed974fac42e8f2"
