# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c50eff67f96f62f3fc8d9163831cc2e8"
SRC_URI[sha256sum] = "fc91adfbb9b782ffc9f07990bd6299d27d77e296514ab8904d43cc6645245eb8"
