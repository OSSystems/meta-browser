# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "095308f52165be522caba87fb36cf7e8"
SRC_URI[sha256sum] = "14168b754842934de8853991f2481149f395691fb320b606e21229ad8cbb58fa"
