# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "39501b5fa156dc448a9b8257dc5d9058"
SRC_URI[sha256sum] = "4556861e46d9990e0b59421c684760887ff1d5b488b6be4638772d8a86f6ef04"
