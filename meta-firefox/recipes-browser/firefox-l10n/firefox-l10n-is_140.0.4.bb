# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c43484098ca91d5dc714cdf872f7f2ee"
SRC_URI[sha256sum] = "75809dfa063727e3dc2302e3775f30270c79713459a2cd3f430d1ff39be122bc"
