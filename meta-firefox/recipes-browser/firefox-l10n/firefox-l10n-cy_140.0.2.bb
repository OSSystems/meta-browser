# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0e1803caddfc45817f929513592b3eb5"
SRC_URI[sha256sum] = "847ca3e0a49d500496508c84c22cd3cd171c090b63fce9f2439844585e394291"
