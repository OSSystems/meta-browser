# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3c8d806f12b15d362500a5aacb65f67116e584504e98a178de17672394ee54e3"
