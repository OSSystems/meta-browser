# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8737ef67ee6e7efd95b2b94fa8fec0ec"
SRC_URI[sha256sum] = "c0e3402f534567c6c7588f99389c1cd00a2e881a4b64f989d348fef450587461"
