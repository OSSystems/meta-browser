# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a222fcbe4421a632242b2f35deaaa113"
SRC_URI[sha256sum] = "c72649bc42f8d2ac6e0ee6453487f55a721b3e8a2a0402dc23706b0bcc3bfe0c"
