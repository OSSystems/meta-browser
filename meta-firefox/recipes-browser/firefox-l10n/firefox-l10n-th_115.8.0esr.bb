# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4d8b5c6bf736c124d690247ef0f270a3"
SRC_URI[sha256sum] = "f51daad59a782fec36c008e278f90184d9a76ba80bc701b950ad61eab3f38f5c"
