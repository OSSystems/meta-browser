# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "62acd2d549f1e483df62b60dc6163bfe"
SRC_URI[sha256sum] = "5ab8bfec9854d9cfb3da25a9254daad50f2018d4840d57005af77258f19c17bc"
