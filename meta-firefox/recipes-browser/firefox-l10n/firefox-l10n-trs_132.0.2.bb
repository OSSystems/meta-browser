# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "70990c317a452f114733f8fec6d9af8d"
SRC_URI[sha256sum] = "d1f8dbf1456a22347137a021190249ca41e652fc4a9342b59ffe07c865df2388"
