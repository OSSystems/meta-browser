# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "5d78082d2db25ed11fa459071749e318d3e2726c43821156fc2616fc8db3ac6b"
