# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b1a4e8f66c286f62422db1757bbe25fd"
SRC_URI[sha256sum] = "9dafdda3bf7243e5d2e334f2b07c79f6813ce3dd822e3afd215a814ad64d34aa"
