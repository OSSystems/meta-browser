# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f54245daea3339ee50d52b1e9a8dc3f7"
SRC_URI[sha256sum] = "0476a79733e7f696d3a5601130f57cd1bb7b44831b933017cc7ca1849ba7abce"
