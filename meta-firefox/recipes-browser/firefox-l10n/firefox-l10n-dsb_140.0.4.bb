# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e9b7c5bcdcb6ad985029b34b8f874937"
SRC_URI[sha256sum] = "928c21f5b0cea78f2d9cc0d777c186698324ce40eaede7a29e7d1b64aa4826f9"
