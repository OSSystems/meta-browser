# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "144f31ac6917f3803b22132cd7c71135"
SRC_URI[sha256sum] = "51ddfc1299ba8125d8b4214d1c912876676c62281fbd8ff27b68d96d89e4719a"
