# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0206172749e72a0d5a6454282dd775b3"
SRC_URI[sha256sum] = "345ba93999fab03737b364149f690dcd35ba202fbac595f822e0fc5e2f1dff83"
