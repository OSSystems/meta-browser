# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b4cb99725a81154172ec47ad98f69d80"
SRC_URI[sha256sum] = "4dde40a79893c5d2483b69a64cd344e2a8c6169a5902ee51325f9423ac7817d3"
