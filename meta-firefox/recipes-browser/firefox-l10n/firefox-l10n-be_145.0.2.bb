# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c69202f701c3ae482cf939d12a45706f"
SRC_URI[sha256sum] = "b119277b247421f6ad3ab8dfb9a13926789ce1a4314aeb618a77611ce6224f5c"
