# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a59f420b3410c6310e2180d3ab58cf42"
SRC_URI[sha256sum] = "a19d87bc905708ccad7f57df3c33b55262f282da87bddf939910abc7a7dedce7"
