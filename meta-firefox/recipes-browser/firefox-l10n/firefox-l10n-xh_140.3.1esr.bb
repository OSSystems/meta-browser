# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dcffe2dff19cd0a2301d80095bbdf9bd"
SRC_URI[sha256sum] = "edeff5686427926ba7a55ca865af874458f533c18bc383c55861fdfddea56f3b"
