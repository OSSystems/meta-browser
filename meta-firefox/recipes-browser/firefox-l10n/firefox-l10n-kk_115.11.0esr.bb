# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4b77c246b6d5681f4a39a7dd173c6acb"
SRC_URI[sha256sum] = "8677623785c6d08fbf0ceec661ee3cf9c50e3f6d670e49f98514b8dfaf00fc2d"
