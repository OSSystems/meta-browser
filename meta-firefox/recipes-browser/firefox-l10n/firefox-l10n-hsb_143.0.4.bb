# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fc5f25dbf120679f072b8f0413b09c7c"
SRC_URI[sha256sum] = "9ed9a45a1ec2565d912c8bfd146eb26eeb67863f5e585e893dbee3b8ddce1f8e"
