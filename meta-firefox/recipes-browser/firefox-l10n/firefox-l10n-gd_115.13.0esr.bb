# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7749435b34cecca1a5a7756be4c80fea"
SRC_URI[sha256sum] = "c2c07e1e44108423ec0358f5d1a2f4a772a8a6a191ebf9846becb855739ca9b0"
