# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "850652c7673db39914646a0593cdd29e"
SRC_URI[sha256sum] = "53c50a0c48404f0fa8ab319ac2fbc3b0dfd7ed1954f4bb3337c3f67406896a82"
