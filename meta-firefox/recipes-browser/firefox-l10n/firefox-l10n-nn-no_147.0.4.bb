# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e65dd0352b0678c3c384ebc4fa34a8fa"
SRC_URI[sha256sum] = "5dbba94e98d6dd5f9c24bafee36c01b7b9987d77de0e784b1d157aff87adce1e"
