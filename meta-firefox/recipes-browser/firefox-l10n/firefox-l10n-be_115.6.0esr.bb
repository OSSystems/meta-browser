# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d993004fae58167cfd4e7efe0452415d"
SRC_URI[sha256sum] = "d646e3b7ad04f50916008f46053f5d945ef0f47c9132d691dcdfc6ce6d7adff0"
