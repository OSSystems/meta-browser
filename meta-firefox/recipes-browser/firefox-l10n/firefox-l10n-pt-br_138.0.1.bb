# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9cbfa91ce4d904c2577df5d9f6e7f34c"
SRC_URI[sha256sum] = "ed943ec9ff764a504ed2ccabaae9b9d7ddab39aaabafd67c61982a59f4519919"
