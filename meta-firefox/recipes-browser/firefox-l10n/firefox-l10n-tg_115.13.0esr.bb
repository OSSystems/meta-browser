# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dd628a54a37cc6eaccd35a2b750ea517"
SRC_URI[sha256sum] = "d41a97834de5142fc3fc7a6a22074941f81ca3f2d0567a843f69b51273e765ee"
