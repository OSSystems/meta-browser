# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6a1ee2e886c7d9c76d883b6b0658286a"
SRC_URI[sha256sum] = "acb7f143f00ce726c46bdb6f3c75487535ebdc366c2bfda3229975093ba77287"
