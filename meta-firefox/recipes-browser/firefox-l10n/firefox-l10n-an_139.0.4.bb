# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d628105367138fd981fa93b50bbb448e"
SRC_URI[sha256sum] = "9c5146ac95152cba3d32785b11d4ba94551f7bdb0994deb17bb19dca975d18af"
