# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9dcaf3de4b0b00665c5ec53313108479"
SRC_URI[sha256sum] = "78a8d402a11addf18ad67e509c8c7c661c9c9396752d8c153d34b2be3a3f0fab"
