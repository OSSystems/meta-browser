# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "65ff858594c92c6a2b83db655a3bd771"
SRC_URI[sha256sum] = "7e96ac641ff6a753aa72026ce5f2ff622b4db42c2c0fa1bd9872432627813c42"
