# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5f1164575e0db72ccf8b3b0bd9434b9c"
SRC_URI[sha256sum] = "f475e0d66593cc22430fda8f6af274e56676420bb3cd1a036089fd233a12ffe0"
