# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "844e9b17175448e94a202386ea441fd9"
SRC_URI[sha256sum] = "184e108a0533c63f1d4d2133ecc824f1c846301fc7fdbbbe7d1282ef476a63e4"
