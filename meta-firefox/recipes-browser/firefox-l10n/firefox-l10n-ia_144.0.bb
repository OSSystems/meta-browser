# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9a22eb1b70d2a69e3af5f634af79bdae"
SRC_URI[sha256sum] = "47a00d001a87c9e594edb9dfc159bd7a3f518a2e2c2b9b4dffa6b24c99309ec9"
