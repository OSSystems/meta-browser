# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c7b9cea91f24d5f335b22c9414cbd8fd"
SRC_URI[sha256sum] = "472a9ba945f0d5c41140f1135a388878a7c45d1a8829a8b31d8afb4777df2802"
