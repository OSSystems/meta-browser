# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "625268f0845c0e41a4cfe94ff36b29c4bc78996ecda8fca0acc9abb941f528e3"
