# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "9b4f6e3e261174fd0150fdfaa6913a338821cc68ce8d580035183f6ed676cbbe"
