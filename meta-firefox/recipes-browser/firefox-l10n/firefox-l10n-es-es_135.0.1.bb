# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "65091d5e732bf831974590b94cd3aec9"
SRC_URI[sha256sum] = "e85be97f3c3f1d8c4f85d36a63eab51fa393e50a962daa252da08e5a771b9adb"
