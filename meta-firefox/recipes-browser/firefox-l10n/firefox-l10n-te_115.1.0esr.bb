# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "33c5eb925506e49f77a9bf7523c8a544"
SRC_URI[sha256sum] = "189c5f6b9b7197d84744833e65e75cf518f21f9748bd3540a254603e06f92459"
