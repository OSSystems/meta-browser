# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9da6d6ef6620140e66baa32c33127370"
SRC_URI[sha256sum] = "93dec724cc9e9fab527a56adc8a07af3d0baaac00b5ff17ce3c37bbb8cacb22c"
