# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b79fee821169202ea226b23a5398188f"
SRC_URI[sha256sum] = "65eda942af20cbbd3e388673dfdf07d0058ce2c9eaf19594f567199867ed0b12"
