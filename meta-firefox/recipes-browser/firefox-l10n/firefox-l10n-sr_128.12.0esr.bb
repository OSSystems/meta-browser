# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "43f033de72927cf05915d77c77bb08f5"
SRC_URI[sha256sum] = "2c06b48be6b5771a7744f8915e6adbeb33c34a2ae520cfc06e73a1d48fb98f24"
