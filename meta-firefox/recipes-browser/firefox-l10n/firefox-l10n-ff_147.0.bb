# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2b00840607b379dc9a8f9fdf7002a5df"
SRC_URI[sha256sum] = "5daa518f5c831e1e7a4b4230dbf4f2a37fd7489481b698735e500ba74043b605"
