# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "955a3ee051f992b3d5fc190d5e62333a"
SRC_URI[sha256sum] = "c3732b3e783361bf873efaca66f9eb2f26b790398bb582efc2986b17c9ac0494"
