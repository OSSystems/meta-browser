# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ce9a4478fb2cfc8aacde429d3543d278"
SRC_URI[sha256sum] = "a8de59029465f62e77dbefad49dad8244f8161c381417b04a47fc8cd2d122dc0"
