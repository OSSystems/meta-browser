# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8842c6b4688c0fb98d6ed15695539f26"
SRC_URI[sha256sum] = "e991f1c450502b7916ae214fc6b1b2efe911b5cb277267b5979212cc6efcf0a9"
