# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f660d4614c83de6db9622abbcf9efa2c"
SRC_URI[sha256sum] = "fe238a0b54dba057cd0fc013753a4f6454a0a54a887a25d3b00f30c18c693219"
