# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4728c0d0a3dfc1b97025ceaa91c6935c"
SRC_URI[sha256sum] = "8550066450572824f09031e6c66e95dba53801c77f4630b0261f70656ca0f274"
