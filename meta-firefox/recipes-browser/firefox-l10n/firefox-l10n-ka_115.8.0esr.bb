# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0530535424babdf08384cb325c7e9625"
SRC_URI[sha256sum] = "1bf99566c5d244f53e40f70161e3fd7661b121082b16c2ed3a44917c15007224"
