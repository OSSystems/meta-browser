# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "97df24003f90f99ffbbe8b79a60ed9b2"
SRC_URI[sha256sum] = "2b46afb71a63e84f2058a97330a36892892cbf0355540f6a69dbe9e2725cd885"
