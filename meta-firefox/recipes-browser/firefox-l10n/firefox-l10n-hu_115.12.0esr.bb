# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0e21e91bb0f46b62ea8431a5f76a8d18"
SRC_URI[sha256sum] = "e3a5f37557e307578d65676f325c4e56427ee71bed0c02ef8678e612dde4c567"
