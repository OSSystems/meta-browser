# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b8d9ba954f02b015136c511f2471e8a7"
SRC_URI[sha256sum] = "d8856276c2e7da6a9bbe853d874756942b2fec58e87856130ebcbf62727ea7f0"
