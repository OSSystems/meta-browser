# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6647dc21012bd981cf9a7f006dcfad13"
SRC_URI[sha256sum] = "086ec09057db3b89bc6be29a8ed1bba886b47477518bedf02de7ac240a606711"
