# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "27b5d35e2cc83d800db297090d1faac513c7e44572a5331e41eb770902cdba8f"
