# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6faecae08b546f53e0e3082a15461d53"
SRC_URI[sha256sum] = "2ef68f63b427173623db34c7f414ee82227a36d99eae0605e9d760ead804d379"
