# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e7c634967ed9ece17cb654e91df5479a"
SRC_URI[sha256sum] = "ee658672982805af842a6a3efa769fe4809a77ea1e99c3093f986cf117d86026"
