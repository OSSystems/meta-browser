# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fd010feed5dd7627babdffc14d6c75db"
SRC_URI[sha256sum] = "e8e1d1ea8a6542246b2751a324f3f6536e3240678d08cc9c8e89673aa1bfb07c"
