# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ffebebab20f39647239f4e51af25de13"
SRC_URI[sha256sum] = "ed75b8ae2c32295514476a2492bf0352e6c1b950473a41380cb90e44d3c0a9c1"
