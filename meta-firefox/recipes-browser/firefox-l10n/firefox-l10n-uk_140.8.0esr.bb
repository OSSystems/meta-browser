# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "06374cbb28dd41c4ea7174f8d79e90b2"
SRC_URI[sha256sum] = "6be93874392e7c441cc034b8a108305411793fe972bb6c395aca3301383cc54a"
