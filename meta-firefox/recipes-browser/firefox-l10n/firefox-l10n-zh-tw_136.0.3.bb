# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a68e9352e80a215d78dca06cc9325c0d"
SRC_URI[sha256sum] = "ac238cf463c4ba2f1fe3c219d70b7ef2fa7f5dc7802a417d146f554fa27e102c"
