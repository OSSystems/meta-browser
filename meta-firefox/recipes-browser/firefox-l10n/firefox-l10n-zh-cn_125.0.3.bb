# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8c7be318f48e4a470a89c6be26221c19"
SRC_URI[sha256sum] = "c1f171742db43b825e41afc7ae5ddb8596fb746131332b356ba3699f03e0cade"
