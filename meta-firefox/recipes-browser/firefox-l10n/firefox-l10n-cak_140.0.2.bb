# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "058969252cd1366bd7aeba5d871425f5"
SRC_URI[sha256sum] = "94b9de65420211263298ec9e78fcbc20632dc95d5486ebe91dd3541ce9c2de01"
