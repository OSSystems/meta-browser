# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a4986bfe41f937968e0be02e94853e0c"
SRC_URI[sha256sum] = "cf87e33ea77d69c79b321cd4d2cbf9c1e0f7500973048b4f3885656868df81bc"
