# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0208046d43a20d6eead091253a97d385"
SRC_URI[sha256sum] = "298139d9be0cf2989517eae04973a41e4811ba380fc0c3f7ef048bbc65d6e88c"
