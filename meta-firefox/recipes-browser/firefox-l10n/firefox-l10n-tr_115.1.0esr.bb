# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c7e419a67a0af3146e3705ea3d981bd9"
SRC_URI[sha256sum] = "63f67f9434efae736afc909cea9e4bb8246ffde2658d8ef1ea1656e214bb3272"
