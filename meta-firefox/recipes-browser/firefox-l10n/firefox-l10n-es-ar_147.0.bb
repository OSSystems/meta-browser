# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9136a244857be0bf5442ae81a8aa5001"
SRC_URI[sha256sum] = "99a6af1c5779e03675b5fe846e015d34415d5e50b8086bcd7c54547c2d4deb74"
