# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "471d302865f58ecc9ed0fb829c267653"
SRC_URI[sha256sum] = "9872f13e24f1217a326b096519eb8a66aaff84dafbc5f506439d950bccb5d574"
