# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d0d0562fc9ab8a61224efc439319947e"
SRC_URI[sha256sum] = "a8cb346e781b3ba4a0cd459b5e6022f5fc53ce2bf29ef281cce0da1e1cc8a1b1"
