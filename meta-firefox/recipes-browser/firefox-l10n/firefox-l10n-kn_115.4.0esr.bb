# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aed4a8fe7abb391628fb17cb18f3d66b"
SRC_URI[sha256sum] = "d3494c3c3658719dbff644dd81424ba1564ab1125957d87fb75877faeb039891"
