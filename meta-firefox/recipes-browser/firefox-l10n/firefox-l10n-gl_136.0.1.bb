# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c41d796a64761e2fcc0a044dd2d3d651"
SRC_URI[sha256sum] = "5eaa2656d83072821794c9fba8a8e760a6a0d2dd3feec380657143899495097b"
