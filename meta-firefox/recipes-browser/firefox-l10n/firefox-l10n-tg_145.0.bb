# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d790affe363bee56a9782d26020b5ec5"
SRC_URI[sha256sum] = "f467b3c75cc8c078eba4ee5697c21c302c2bb5d471cef69facd8cb1b1d73034d"
