# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "6abbf53303b48c13d6110e0f0bb22d4624254fa2a3f97174f2373a294265b434"
