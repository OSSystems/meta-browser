# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ff798757f17df52a30e99c9db8324631"
SRC_URI[sha256sum] = "2e6b44ab2a0ec51a3d57ba7e1b377b241c680b4ae45a9f4a91095e31bb818c15"
