# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "02acd26a84a91b38b1691d45de3cf5bd830106cc2809890445ff54b03c434b65"
