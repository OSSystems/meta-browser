# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ac6b3a99458166dad0d2b363b983696b"
SRC_URI[sha256sum] = "5eb5e2f16c7f4220c54fbd4e9678eaf98c4e20dea57af7ac677022dd563eb8a3"
