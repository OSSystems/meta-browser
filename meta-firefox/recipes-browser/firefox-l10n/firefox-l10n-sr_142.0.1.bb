# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db6cb8e093f52f2ab835dc66e45a0c95"
SRC_URI[sha256sum] = "c7ecab2f88da24e483696bd92389b1d8f2492aad4d3ff1134c0b387c4ea5e536"
