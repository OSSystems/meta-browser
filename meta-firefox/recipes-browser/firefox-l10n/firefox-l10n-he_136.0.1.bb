# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4c1f094b9f53624bf05f0603f65524f2"
SRC_URI[sha256sum] = "48dcfcb6fba4013d5615a4cddca7cad1848cde3c12292bc888de7c02f69290b0"
