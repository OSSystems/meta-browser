# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "70d4b0291c45b50eacfaf3d0f565c0e8"
SRC_URI[sha256sum] = "2ee4c3ea3ef8ac93cd9abdf601033d43f0e7fa7bbeca22c1e54b54f7390d78aa"
