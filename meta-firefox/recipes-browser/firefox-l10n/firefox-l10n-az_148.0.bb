# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "39c4da9020d974a78895290bf830dfb7"
SRC_URI[sha256sum] = "80e748aec0643ae9aeb8ff8224b34dea5951d890f0769285146abfa4dede6ec5"
