# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1c9040f7e1fb63c2b447401c91c82c91"
SRC_URI[sha256sum] = "dbef2c01592e6c98cc4c2ddfe0f4b197b36471b3360ae1d0c57623c7e3e70717"
