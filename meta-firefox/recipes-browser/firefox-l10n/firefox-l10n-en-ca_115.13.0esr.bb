# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "67c026ce387b399f4114367afcd5ddfb"
SRC_URI[sha256sum] = "c3577a2d07cfe30d804760554791cc1907d8f0042128ed6c7fab01dd23d45ebe"
