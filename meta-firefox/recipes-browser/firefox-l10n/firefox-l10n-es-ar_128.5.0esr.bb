# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0bf73f462e1df85525a3e3098965e5f9"
SRC_URI[sha256sum] = "32767fa56b2ce514a2f09f7f25b769571fd63a2572dd0997f015723be2290f53"
