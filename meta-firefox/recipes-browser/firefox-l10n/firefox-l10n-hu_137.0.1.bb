# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fe3433d2b80129036651099a616c6aec"
SRC_URI[sha256sum] = "a307f6d5e3f4d5ec960b656b07ac45640be93b4c78d7fc4705c35ea0c06c0afd"
