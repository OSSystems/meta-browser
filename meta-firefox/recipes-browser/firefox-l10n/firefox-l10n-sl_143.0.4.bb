# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1dfcab6d2d818d26b52ebfed03e1948c"
SRC_URI[sha256sum] = "c0ce7ce79455ac51318435121d1929074a464d55effb562f3ef48e58fc851875"
