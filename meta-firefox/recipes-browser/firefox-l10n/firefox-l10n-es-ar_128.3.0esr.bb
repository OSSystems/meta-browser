# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "46af1b6369d48b8dca8c864cf2253067"
SRC_URI[sha256sum] = "7a068e6367ce2b64551e65607ea3664be3a56e82af008e8af8d35d3a2d6fa875"
