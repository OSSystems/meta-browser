# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "004cd35d9384a294a5ca9e5694607c93"
SRC_URI[sha256sum] = "7300c5ae7e2ca787cfc9826d5cc883901c8448d95d36cbef2c4d5468482ec41d"
