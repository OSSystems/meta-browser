# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "196742d1e12040e57241666587aae518"
SRC_URI[sha256sum] = "0374002343b47632e2b844ab6fb0b9fc8d758a66bbd8954656e1de439dc78fa3"
