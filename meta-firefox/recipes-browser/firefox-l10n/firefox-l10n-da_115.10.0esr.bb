# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7233918b8bc8fdb8c4ab26e116f4db73"
SRC_URI[sha256sum] = "d7dbd090dccc5235f8f6f4fde6c75473f61895f9eec02399485b36031d34ab28"
