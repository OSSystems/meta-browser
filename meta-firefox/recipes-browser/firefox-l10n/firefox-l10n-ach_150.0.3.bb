# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "a24a83aa80a5060914f5941b277cee73ebcbf74e4eb101f240e68bdfe8cb3aa7"
