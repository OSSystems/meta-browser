# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "86c8440680fc555b0b877909ee4afc99"
SRC_URI[sha256sum] = "328d54a8c842dd6e8959fa2c26636411ee8bb3a42de4957b89d200dfe8f22238"
