# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a177773e4446344214d9fce517c3b529"
SRC_URI[sha256sum] = "310f1c4921e04b188117200cb203d7f1f91e99c0c401f3ff64d263558508f258"
