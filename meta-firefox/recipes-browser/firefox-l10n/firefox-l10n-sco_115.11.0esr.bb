# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "177d8670066c48c83c9f4f5fec189be5"
SRC_URI[sha256sum] = "213194c6f0e9ac6074707c5afa58d23c98b41f68a9b9365c726ef2bdf37122d1"
