# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c78d8000a1f3eeb1ffdecf3e53272153"
SRC_URI[sha256sum] = "892f66bac48f4825c5dfcd194480a96ad2f4e94d43c56313a2e17e4fe0e6d150"
