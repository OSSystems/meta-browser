# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e2e1cf1a5f01bfb753844881c4dabac46a6c6b782d220fb1c2203cca53377110"
