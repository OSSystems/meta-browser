# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3ae0344117b9ad859ea753bbbac82002"
SRC_URI[sha256sum] = "8b3b6c5c5029d3eff633a39ac3b32c14f431e047fd1f36a0a46484e1731180ad"
