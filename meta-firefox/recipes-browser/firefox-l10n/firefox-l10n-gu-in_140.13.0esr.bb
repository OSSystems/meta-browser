# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e9bf175cfe9b5eb8743e5da1901eaf2ab0ae98658acb862162e142ba3f9c408b"
