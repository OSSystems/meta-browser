# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fa3356b55d9dcbaafc46e99c42a454b9"
SRC_URI[sha256sum] = "709e285c3eae7af294e9d9194ad119fcaf2d6e7e291f5f6fd5a7780ffb98861b"
