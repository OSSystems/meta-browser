# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ae6e3c44451d0709725d5f7c1b7743a6"
SRC_URI[sha256sum] = "8b547a83cf4649b28786cb4d8b5c209403d7b40f8bd2a744ee05d847ea804150"
