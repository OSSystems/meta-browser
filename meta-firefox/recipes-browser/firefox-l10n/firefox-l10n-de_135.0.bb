# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ad3f664a403c5237794be9a13b1fea9b"
SRC_URI[sha256sum] = "abf9037a97612db09e5e051224128795d46ede4b731a497e2557af1f84d12035"
