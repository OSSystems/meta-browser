# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2ea569f6ce3e1a2b92a5479e30afc345"
SRC_URI[sha256sum] = "4c7024fed5d9853dcde259098bdbe912b7e7f71df5fd0dc07ea4febe113b7600"
