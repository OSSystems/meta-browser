# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "87a8f882c1dccc16387ce3240c446f17"
SRC_URI[sha256sum] = "90b619ebb81468c6cb42c22110c330648aa0efe7025dfc573b2480ba44a89c63"
