# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "de86dd431e0eaf84311ca817b751c070"
SRC_URI[sha256sum] = "b4e9468f8b683ef56fed148dede8f8d4bc99327eaeb02817c48ee3576a51ad74"
