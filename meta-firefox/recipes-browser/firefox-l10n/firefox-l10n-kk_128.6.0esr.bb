# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bec27567fa04e6b23c8337f230e39261"
SRC_URI[sha256sum] = "d2905592e8f6d46c48ef16f811d1c4db537bae0a060509df2724dc0174d63c00"
