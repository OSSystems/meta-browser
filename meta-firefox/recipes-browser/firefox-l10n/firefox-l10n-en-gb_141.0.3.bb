# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "42ff73f9f541d31c07d5e9b3c9eb19e6"
SRC_URI[sha256sum] = "fb867dfcb4c71e70f0412ec0855b62bfaae1d32d1c27428dde3974c108ebf45b"
