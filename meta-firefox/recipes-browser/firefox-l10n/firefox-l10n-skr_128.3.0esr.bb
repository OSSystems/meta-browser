# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "332a6ea7d0b119e71a489f63f11eb1c6"
SRC_URI[sha256sum] = "ec0330b8bf628d29019d2abdd92791964730226f7e796f6b2757bcefb7a51a6d"
