# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fdcc7379541f2c6491605346930f5e0b"
SRC_URI[sha256sum] = "dca54bf00ea60238a308c73e79587db621dac2d4f56f76a6a7c58850d553436f"
