# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "58d35c9723c4b22df94957af9f5b29fe"
SRC_URI[sha256sum] = "01806c7091f0b80e2e7c29254d1a3e47fc39292a06e0e50ea69bc3a1a2fd8311"
