# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8c347e40933c0fb1ae6050c1b901f351"
SRC_URI[sha256sum] = "26bbff57b40e17d270e669cbb2664412dedec3ab506ee02b54be4d678e9a1b55"
