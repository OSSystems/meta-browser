# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "307f22040372b62efa10d53cf05389c2"
SRC_URI[sha256sum] = "bf5804bcfbbdbaa07a74c3a4d9ab937de841284245228609c808ea9372a18866"
