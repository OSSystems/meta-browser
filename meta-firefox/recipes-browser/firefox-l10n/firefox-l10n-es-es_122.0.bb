# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "06488aaa0c2929532f73fe2950327cb4"
SRC_URI[sha256sum] = "fd16a0fb166d3f4a55acbba3e17977303e12ddfe1809d28aa402ea9df6bc8825"
