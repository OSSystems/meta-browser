# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "76e4a8dcce7e5aeaa31145170aa25425"
SRC_URI[sha256sum] = "f3297510dc35db7736c1a9a9cc8a4eda91cc38380567876512f0c3747f657ea4"
