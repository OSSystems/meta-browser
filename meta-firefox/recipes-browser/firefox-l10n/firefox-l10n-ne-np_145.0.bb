# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c4f135e5ca53bf04cbd731c037f8539"
SRC_URI[sha256sum] = "c9ad13fb2fa12637e615e021e2854c034c2e68be8da2c142ca8c263fc4aa93df"
