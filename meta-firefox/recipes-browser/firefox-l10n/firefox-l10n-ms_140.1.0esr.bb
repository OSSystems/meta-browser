# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5988306678067c82b53092f992dd04ec"
SRC_URI[sha256sum] = "24ce82a8524606b9818abb3f362449ab8fb0cce7c05e336fa81ed481fd2eede0"
