# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "84a81ef16b43fdfcd69fd01d1f1c8547"
SRC_URI[sha256sum] = "bf07bbd8ebfe6477db742eb91a94404689af580cb11355a021fa5d46a7b8a950"
