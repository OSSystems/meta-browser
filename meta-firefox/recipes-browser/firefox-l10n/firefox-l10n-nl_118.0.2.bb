# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5d734f60456046283d7af42221038e72"
SRC_URI[sha256sum] = "a26f179662e982b919c074d79d88a19250d9701e1d4e864563cdfe26bf3b2f62"
