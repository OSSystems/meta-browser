# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4a741352a27f4a518b6a931f8319bec5"
SRC_URI[sha256sum] = "d0f567c43f23a982170e52876dcf7a4495f4db8288328322a75e067dc4c701cd"
