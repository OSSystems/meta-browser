# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "23d1d238b402668bc7f354e267749c05"
SRC_URI[sha256sum] = "02a6883c8f2855fa960629f6f4753a0121da294e3c45ce296fa5c225ce53155f"
