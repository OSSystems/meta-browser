# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d66a0a5ab03abaa654ecf642b5e9c5ef80f6956c8db3916ce44d46c98536dbab"
