# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "68b25b11781c4879dd812534c93cf060a03b6d67eb7ecb9fffde2802b0d42ceb"
