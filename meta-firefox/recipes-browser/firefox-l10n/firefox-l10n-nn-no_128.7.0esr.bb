# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6fe3df52739ae15db88345c71949e8e8"
SRC_URI[sha256sum] = "9544452fe3001031e27eed7b2b836686679f15a08d30dbf96e945602a50d48cc"
