# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b7a25cd614b869a13ee7591459923ed3"
SRC_URI[sha256sum] = "ce66a10d46ba1fcbee8e4e0dd01d914afcd44a9ab62e87866d540ba11f9c68df"
