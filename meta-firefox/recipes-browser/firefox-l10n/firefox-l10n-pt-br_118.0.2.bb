# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "960f56e828ae99fece194aeb837ebb89"
SRC_URI[sha256sum] = "5e5fe977ccfe2d095551e4128ace64f0fe94bfdfdf69f98e9f43bb00e13ae95f"
