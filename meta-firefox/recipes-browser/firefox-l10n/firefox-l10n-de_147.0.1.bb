# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3d53a37018b11e53eb72e859bbb476c6"
SRC_URI[sha256sum] = "670d9b2bedcd10653f83926516831664f9a5bf07843fb430929aaed091236c4c"
