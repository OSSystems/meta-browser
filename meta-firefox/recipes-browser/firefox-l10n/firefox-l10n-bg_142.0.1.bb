# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a8d72dc1712f9bc6dcf6ff6f64cef67f"
SRC_URI[sha256sum] = "f5196e7de3867fa555ba407461300453672786f955017ba6369dc8e36f75bd59"
