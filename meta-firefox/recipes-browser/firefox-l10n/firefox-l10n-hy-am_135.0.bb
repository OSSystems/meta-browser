# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2ddac72109d1d7ac8222435155a8cda9"
SRC_URI[sha256sum] = "7767d47859a9e5487906dab6fdb2cb915196381ecd6e7c64b625fe4d2a0d5292"
