# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7032374d1b22ac0bdb115e84975892ef"
SRC_URI[sha256sum] = "b0c08b876e7e6da3f80a3fc906486f18c8b0dc8bf2d5b09aa33aafe941eab3a9"
