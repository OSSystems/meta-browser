# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6428e9ed0b9f48ebfe93a3098dd9b0b9"
SRC_URI[sha256sum] = "45cfd38aa4f15c2bbadff23e51c016b1cab43306bbb43af8509c38e21834f11d"
