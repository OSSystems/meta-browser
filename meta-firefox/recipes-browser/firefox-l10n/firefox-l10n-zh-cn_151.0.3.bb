# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7382b7e1a36db3842f102eae0444c7ca61cc760bd0daccc7e5ef7434450db92e"
