# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6f33a83346e03ec41862b5fe462bb69e"
SRC_URI[sha256sum] = "5d2f156fb670385de98abc8ae8fafd8296720abf1715b8d47d97961f2c558964"
