# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ea2c24a3d58d9f22c377007e15c4d45b"
SRC_URI[sha256sum] = "e91a51e4cb0b1df18a67c6c82a8e9bae0ddb4c4236fa91a9711efc40ffc36487"
