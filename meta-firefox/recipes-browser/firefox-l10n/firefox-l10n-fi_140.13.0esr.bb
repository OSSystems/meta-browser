# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3e4dfa9da9e3b6131b2f84d92f732b9831621f15f797b708a6f6e6560b21053d"
