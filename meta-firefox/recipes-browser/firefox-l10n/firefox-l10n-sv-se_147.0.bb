# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "34e8bc7b5cede480431d6ae14351e1ff"
SRC_URI[sha256sum] = "9653d1c1dfa554b37ef2ba0e71daec163d1a54fc9ba99f74856f98c64476255d"
