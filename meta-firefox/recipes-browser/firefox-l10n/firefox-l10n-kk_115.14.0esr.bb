# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bd144aed5de153d0aff42af136131667"
SRC_URI[sha256sum] = "1d7015d54ac261e9dfa5ed9717900e12675ab6bff7fcaf8a1e9dad8bee04deec"
