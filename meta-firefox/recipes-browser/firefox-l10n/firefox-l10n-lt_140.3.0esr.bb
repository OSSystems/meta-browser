# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6c50e57e8facad6977d178d897c30d6f"
SRC_URI[sha256sum] = "58beb9e26c5253e8c23a5a13caf2e3fc860a6e0d8eed994c36090941d3a7ca2a"
