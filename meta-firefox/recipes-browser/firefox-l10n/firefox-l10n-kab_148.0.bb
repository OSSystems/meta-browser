# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8f3fe151ec37cd91bca5c33e2bd5a95d"
SRC_URI[sha256sum] = "429584e4c3a854cddc9f70311aa06e9662c15aa1da3fca3f13e7d55b34a484f1"
