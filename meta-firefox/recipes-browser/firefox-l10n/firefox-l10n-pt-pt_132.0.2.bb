# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "85018afb482dc073d190d2b212499757"
SRC_URI[sha256sum] = "85349fb149ed1efe1fabe9660ba6e9dead688cab26651da9369f2d824adab404"
