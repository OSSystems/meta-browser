# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "496ddd47c7bf27bd88808b51b1cb215a"
SRC_URI[sha256sum] = "d7109c8be7cb92f87b20bf08e5f7d85b60ef2bca2cca1bed88a738de826e82f4"
