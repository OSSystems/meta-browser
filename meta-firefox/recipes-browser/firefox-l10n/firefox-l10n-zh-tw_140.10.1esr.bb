# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "22f96d06e2861ddee67e6f1162b449a6678a22737b92c48fcf815abaa3307656"
