# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "72105d4558a2c5d36b25e5c0533d85df"
SRC_URI[sha256sum] = "5d72330a2300e0c10ba515604a30eefc6b0444f5777334dc7ca59e40b8f72675"
