# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "80dc0466ed2d4e74a6d24339fa236600"
SRC_URI[sha256sum] = "7c2f839c4f101d30ee07177523469d911b6f453b67c3839820ba5c9ee412de64"
