# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "a0db11e68cb98626155eae0a7f2e1181982b81fbf7fb8718c76422e5a4a3920d"
