# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0ea70b35ab8df53c52cc9c7f71e2c08d"
SRC_URI[sha256sum] = "31d9c4faf841434b4420368b3e2def46285e3d0cb21c55f8e6eab2b4f44e0d14"
