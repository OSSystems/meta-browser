# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "81fc3e9eee8330578907c55d549ed503"
SRC_URI[sha256sum] = "30ea5c030eeddc66164dd47433b6989a1259b091be76cea6fcdc641180092716"
