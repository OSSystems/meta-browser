# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ac532bbf776670b2ef641396ec1e4bb286fa261efa995ed8c9489c342b95da69"
