# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "40194cdb00c1879339c8e3971f3bd247"
SRC_URI[sha256sum] = "595c5e55e61adf2e123303ca74abc1afb9839d3991ee2a57a888bd7ad128e2d7"
