# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1cb234a249b56e677859f0e004e63a2d"
SRC_URI[sha256sum] = "7aaf335e51f858823b6603c604b4ded43db19978943ba20295bdf8796de74dd9"
