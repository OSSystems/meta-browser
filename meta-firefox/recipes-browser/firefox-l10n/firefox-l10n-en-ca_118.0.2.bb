# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c3e28eb91ff70ba303510f03a048240d"
SRC_URI[sha256sum] = "efe1fdc6434b24273f8efd6902d0e74e96b71de997f3fdf7d09c022f00dfedbd"
