# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bf8fc5f6ffb94040e629680c4c11819c"
SRC_URI[sha256sum] = "688e35d5e70defacbe6f847ab96e902c0afa4af420fa0ea3f7c4b7bcbce2648a"
