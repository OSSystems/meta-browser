# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3053045eb1620e60abe8ed43565ca50ab3c3eab8e05931d8672799b2cdaef42f"
