# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ed87f146af738e9d9bb20992719cb157"
SRC_URI[sha256sum] = "04853a2575b876e0ac2da3865c453cd55961afadf4d939d7e6c0f90810e2b5df"
