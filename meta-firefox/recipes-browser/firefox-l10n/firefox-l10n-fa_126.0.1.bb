# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bc8d6b5ae1cf038ba08d00e5ccaa6026"
SRC_URI[sha256sum] = "218af6e2b2bc582d6af929e566b1d5ac1a82b601bc7d23b0069494b22ce0bbe3"
