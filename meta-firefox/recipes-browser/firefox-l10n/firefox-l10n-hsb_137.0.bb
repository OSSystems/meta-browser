# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e147d86ab4164fdeda24a0fb79a83068"
SRC_URI[sha256sum] = "addc43971f859f641db6d430172e4bf79dc9228170e37f35f4a91ca0ae03f264"
