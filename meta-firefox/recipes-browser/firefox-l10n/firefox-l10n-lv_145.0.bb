# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "affd58bcbb21a14fb6d53fbf390027ab"
SRC_URI[sha256sum] = "cb8062f524f92efdf16ddf3e04a00c0c18801238215618eb69e618cf7fc14b0b"
