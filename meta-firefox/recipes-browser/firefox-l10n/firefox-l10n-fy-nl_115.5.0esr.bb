# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b90424dfa4a915090ebb8edf76873d1e"
SRC_URI[sha256sum] = "eb9f864ecaf73875239978805e14d126f0c3615e9787d30f5fb35c105e51d89d"
