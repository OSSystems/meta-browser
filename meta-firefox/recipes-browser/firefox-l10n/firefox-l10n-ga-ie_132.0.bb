# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "40d92b6429a34e97921bf79b57fefc70"
SRC_URI[sha256sum] = "79d8cf638ac93f8a2bf6b942618671670a031a58b2f55bfe97c28b03645ef236"
