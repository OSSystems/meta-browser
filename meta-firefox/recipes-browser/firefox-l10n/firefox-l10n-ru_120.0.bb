# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d25ce906625d22930bf51c6c50240362"
SRC_URI[sha256sum] = "5be766a26693d53ae6d5901eabb165f9e1671e05ab47d65f5f432eae7dc1ed36"
