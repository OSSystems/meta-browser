# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2bc9cf7345c47bc3389262940b6b1009"
SRC_URI[sha256sum] = "1dbe1a87e2c6d4edbbb9c4901bab2624c5f3bf03a1a589e4e6166ce867d2972d"
