# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2fbbe33dcf30fbf1281e436ed505de5f9ae0e8cb3f356e826210031f08e3e39c"
