# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "719678e4a8ee3a5f45403ba591f2e9d7"
SRC_URI[sha256sum] = "76fa7f1ad35d43a28e75f2be01c40f10a244b45fa0016e29988dc56d92da7aab"
