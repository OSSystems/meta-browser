# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "72575f6151ba976ee7819a04fbd9d04bcd5754454d18a20aa3fb81c9446b1da8"
