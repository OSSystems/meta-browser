# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "113619cb26e4bd2eab1b2a72fa165fc1"
SRC_URI[sha256sum] = "300ed04ab12036970bef511594ec80bbd9d1602eb54466c2fa1dd4e791ec24c4"
