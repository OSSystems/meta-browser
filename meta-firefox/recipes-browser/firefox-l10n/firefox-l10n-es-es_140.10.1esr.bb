# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "75a0dcc7363ad17a0960c3345b4c70ee0f0b43d241dd13f9c37b766e7be5d11b"
