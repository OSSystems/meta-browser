# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "001bf835be7ab04c0e2fd8777178eed9"
SRC_URI[sha256sum] = "0ab52fac2a6927e344e669c40536d4f12bb6e2bfe98078d6ccd233a4a6fb1aab"
