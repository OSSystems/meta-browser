# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ec8a41cdfca32b605243fbe60f495912caa856822ddd21bd3885c90082dcd2e3"
