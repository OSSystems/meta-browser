# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "a2510eaa8e446e4737455689ce13cff76b206c5e81b65dc13a5375cfbce4ca2e"
