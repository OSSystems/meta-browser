# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3e55e9c2e036fd0732616046d99f4f52"
SRC_URI[sha256sum] = "ff4d3f18c4f396cb8fc34cb3a32d80b4933a3d9002b316a736b9bdd4e7d9d4ce"
