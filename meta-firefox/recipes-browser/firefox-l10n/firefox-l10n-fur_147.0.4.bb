# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "93696dc9c54caf7604c64cf36929c8d0"
SRC_URI[sha256sum] = "79d32a9bec1046160c57c753043e51aebb318e8a44b46af686276d17355ff70c"
