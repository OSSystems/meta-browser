# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cee1bc07d14e5fb3cb598e7a6c0fb782"
SRC_URI[sha256sum] = "5a4f18b173cc9651f42a3d80f0abb5779435124cc5c2ac4a7d7d7e9cbe519521"
