# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "de4b299b450d3d76cf53452417f4bc68"
SRC_URI[sha256sum] = "cbd572c775be0a8329c1ebe3fa90053402bf2a800b98a4006569dc2c3f371037"
