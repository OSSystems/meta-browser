# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "96f3f6def6d9d0589561bd9d8f52b92a"
SRC_URI[sha256sum] = "4f03613172245b723b451d6c1d3fa1cd0843cca2684f37b72024e60d912e771b"
