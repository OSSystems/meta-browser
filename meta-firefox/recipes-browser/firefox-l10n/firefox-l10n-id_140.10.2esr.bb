# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "b2fc3b35d1397f9ec98d218391b8955a1b2b08a301e450146cacc4ca75170ed3"
