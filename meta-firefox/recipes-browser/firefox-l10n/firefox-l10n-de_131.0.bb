# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5d932da8da2e9aadf55b0d88e50e0447"
SRC_URI[sha256sum] = "80e71511956c82041224ccad0f6b1bf7cad7e749ebd1564d665c9beda881070e"
