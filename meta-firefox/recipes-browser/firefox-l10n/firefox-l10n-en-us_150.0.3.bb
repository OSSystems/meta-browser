# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "fa21d6ab8ad08d6645033597e0c5bb08c2f2637d8d4b01c9b69e8010bf6db61a"
