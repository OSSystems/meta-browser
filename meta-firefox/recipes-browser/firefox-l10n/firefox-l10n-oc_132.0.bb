# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7f9d6372ab2aa0112329909c30e21f12"
SRC_URI[sha256sum] = "1df766693c5a2f37d19338aff5074a7239fa07ebfcf6a615da3498390791bd26"
