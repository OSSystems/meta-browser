# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e7e24166e632883c89e5d9dd821bcac7"
SRC_URI[sha256sum] = "b47e29dc9ffa20439732d9595009b74b0000aef0e417cedfb3ae15721b91d211"
