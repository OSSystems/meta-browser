# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "176ad7efc420743989e9ad80b7b94354"
SRC_URI[sha256sum] = "16f6723d09df192edec495d414ffb4d43d3e9b14811fbf2b1e87cb3d069ab556"
