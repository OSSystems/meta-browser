# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3d95d5e0b216bd10d5b7683165fefbb2"
SRC_URI[sha256sum] = "94e0d0f6d7f35723f16934df248566ba3acdef442847ab3df3a0214d556c0f39"
