# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "121127e8ba3168d8aa770e6f38e52beb"
SRC_URI[sha256sum] = "603e2d07be7e66d537c6fb594324541a479a475cd0a06644539ec445afb15666"
