# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "09fbd003f3c899e79c64f7c0a03ae4366752d4698d5d20d4c060ae7e25744e78"
