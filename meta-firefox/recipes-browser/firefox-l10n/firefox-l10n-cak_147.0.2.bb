# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3e7cbf612c030d23b3d7ee7a6dbec5bf"
SRC_URI[sha256sum] = "78ce23f96400f35a84900790f6b4ca67239403a999f2762eab7ea6136997f4b8"
