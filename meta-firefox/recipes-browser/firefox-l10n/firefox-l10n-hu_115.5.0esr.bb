# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f10bd62fd4d09aefa2b08bbca91a7f3b"
SRC_URI[sha256sum] = "288b60c68918c13f095e5dd5bb6359ff81eb1bbed797ef47d9bb183783871541"
