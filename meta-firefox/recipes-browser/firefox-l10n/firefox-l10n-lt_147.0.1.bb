# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2284cb8fcc2d28a70f423c6fbfe0e98f"
SRC_URI[sha256sum] = "092ec98a42220cdc664ba9bfdce2faac7e9a10277de5a872e1cc3e0dd2d6f8e2"
