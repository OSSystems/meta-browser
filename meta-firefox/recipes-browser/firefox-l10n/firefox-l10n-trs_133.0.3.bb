# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "817a43bdf8308cf091cf4c2289f109d6"
SRC_URI[sha256sum] = "128084487ca8e13a65284bfb0b6d9fd9fcbab697f1384f96f6dcab5f0d15864e"
