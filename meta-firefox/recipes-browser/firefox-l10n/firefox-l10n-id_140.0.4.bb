# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bcb63196f8b1e8038a1b88f79efde41a"
SRC_URI[sha256sum] = "3ffb5f021817cd0b570958c159d72fae854bfa425688b9dfc52fd08b0ef0c8cc"
