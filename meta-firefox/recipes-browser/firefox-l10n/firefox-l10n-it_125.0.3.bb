# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c2057a9d4a14daba598b442809482bae"
SRC_URI[sha256sum] = "89c08a8688830596866ff50ffc2adda1615fc664e52c263c262057b95fdc771f"
