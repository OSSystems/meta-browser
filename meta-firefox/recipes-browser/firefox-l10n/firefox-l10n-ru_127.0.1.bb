# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "83a5390ac04f463ae9ea37d3fe8eddbc"
SRC_URI[sha256sum] = "b21716dc88db035879a906d49d5220379668f613fb8086e9e721ff19b92a7f15"
