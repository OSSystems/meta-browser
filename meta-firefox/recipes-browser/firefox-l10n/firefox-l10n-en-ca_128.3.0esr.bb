# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "34f2f55438dbdb72e379d1220936ea38"
SRC_URI[sha256sum] = "2ed9c5e3cc7869fecd197d635b43701b0487cd805cdbebf268c233cacf1b5b1a"
