# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "0a1a6ba2f342757533602cc661f591ec49ae90ed26452ab2b47c16850c19a07b"
