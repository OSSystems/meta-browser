# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "607903c8650bf8f69b5133e79d00bcde"
SRC_URI[sha256sum] = "31c40803b478339eaa2ef51d601be92eab1315d9d9b7359c2a3f892312bbcd20"
