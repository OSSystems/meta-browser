# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "94882d4f91aae9ab15c8de4033a32b92"
SRC_URI[sha256sum] = "50ba5874d6851bb6414954668b909c23c8b62e9b0ce82271bd7eb1167f9b6d4c"
