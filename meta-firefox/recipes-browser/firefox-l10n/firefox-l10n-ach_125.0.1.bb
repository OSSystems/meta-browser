# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c06a76f25452fad56325aa5341391ba8"
SRC_URI[sha256sum] = "96165cf6f9aed8ac073200f420b125ceb38bd22913e78657b7d1905e041ab256"
