# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5bedc9609245f987a68d911d6c42e7bf"
SRC_URI[sha256sum] = "d363110ce326cc00593066d498a7a8311bc8e5eae8048f9e0cd2b178a39ea6d3"
