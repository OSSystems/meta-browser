# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "06f817c76f029a228b4ab840a96935fd"
SRC_URI[sha256sum] = "70ead1adbc37b26b39e8fd73beb306fa15e124dbcd10a56164d57414ca16a580"
