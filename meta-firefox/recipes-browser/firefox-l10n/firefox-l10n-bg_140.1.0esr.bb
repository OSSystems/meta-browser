# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "935c46c7d94b8954db99c65938cd8075"
SRC_URI[sha256sum] = "8d58e1ec5014df01f1abeab93a09312f7c4e2c3a68e8d31b620ef8ae92d5fbe4"
