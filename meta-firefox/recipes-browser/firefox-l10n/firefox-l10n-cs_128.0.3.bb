# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f66abc608e1dfb65d1a03526893cf82b"
SRC_URI[sha256sum] = "7b8c1134d4b3eacd78216ce1481bf59261a681fc92131f1e692d435fe8acba81"
