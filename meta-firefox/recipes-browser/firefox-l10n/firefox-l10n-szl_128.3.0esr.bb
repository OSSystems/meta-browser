# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e95829da2415356a52c5494c69681aec"
SRC_URI[sha256sum] = "b322aad14b84d8706aee5c3b9c732eb361dac8dcea5efe4c6cdbcc7cd2375c32"
