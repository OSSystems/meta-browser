# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0d166aacbf7b0f40d6f2645609a46390"
SRC_URI[sha256sum] = "6c5ccf1e254137ac62152c2a8381809a9dc2506cc81ac009778f4fba3d7edffd"
