# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "604757e747a1b59bc6928e320e876507"
SRC_URI[sha256sum] = "ea5170cc171d0fcfec5e3681d2e6084184e2537145b15b5fe917c6b5f4b7529c"
