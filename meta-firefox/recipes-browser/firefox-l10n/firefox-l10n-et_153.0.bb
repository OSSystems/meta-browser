# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "6f9699f52dea18f95a4a4d0149fca8618b8d04634ec82de695fa31acf8090cc1"
