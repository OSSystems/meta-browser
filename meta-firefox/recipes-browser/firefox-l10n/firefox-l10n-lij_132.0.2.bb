# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9fad54bfe39d4891508006a61ce32fab"
SRC_URI[sha256sum] = "63165cdecde384fc177ba2e5d4a3caee37912f2c3e64e4692caa132e497dc69f"
