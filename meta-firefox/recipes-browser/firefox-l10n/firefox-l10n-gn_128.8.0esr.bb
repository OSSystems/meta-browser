# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8f6ca70134d63bf82064ee0e033b21df"
SRC_URI[sha256sum] = "5d4571728a1a3be0046f525f43a6041edcfd8ac6c67b1197ee9638a767ab1d9f"
