# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a0751b2fadb39c00cfb7a31dee131d6c"
SRC_URI[sha256sum] = "7ff6ab9f5b97b183e6d188a17d18a3ac9d093f311509216eb8b7e871d1bf41a8"
