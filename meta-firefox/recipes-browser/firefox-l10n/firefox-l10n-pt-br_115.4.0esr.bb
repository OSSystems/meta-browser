# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "69233a72ffb547e8f0f4a3b986e82289"
SRC_URI[sha256sum] = "9491be7f755a25115b60ddbfb19283c83e381425c039a04d4adb3826fffaef07"
