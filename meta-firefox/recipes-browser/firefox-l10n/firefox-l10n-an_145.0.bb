# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4c0e1f7228835d209d17c3ecccaf81ec"
SRC_URI[sha256sum] = "321d2d40cc7dd0e6973dc670c5adcfa8b2afb84f70e93a4340cc1371e749a40d"
