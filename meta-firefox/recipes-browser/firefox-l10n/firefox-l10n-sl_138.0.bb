# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9e55a7b6fb38464acf24fcb861549bba"
SRC_URI[sha256sum] = "3a2a1a0c89ef256f90e8a1bc152ab5ca52cde80cf30f775d356a7b9bcdadee5e"
