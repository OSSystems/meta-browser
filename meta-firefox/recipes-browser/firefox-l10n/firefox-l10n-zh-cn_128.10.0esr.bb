# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d3a0ad43564f1ae390dc781c09fb35f6"
SRC_URI[sha256sum] = "d328a94f2e03d9bbb4695e353d02f8eb0edb6cf60db6b675acaf1833c756f125"
