# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7eaa637b1be09b14025bfcb93a401611"
SRC_URI[sha256sum] = "dafd2b73c0c4a14136d48d6c6228ada3c12a346840965534a95174ebb4d7b263"
