# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "1d2abff5058dd1a0ddf5f1b12e87b755c3a3d022a3075094afa65693a4240652"
