# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f3cceb578c4329db530ea8b21b9294ac"
SRC_URI[sha256sum] = "b85b136ab02f5a5cac2e99f40fa48ccc921080984a7d39e8aa4f40cc4cbb4458"
