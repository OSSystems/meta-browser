# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "237d1e305b3d8e195bc9398e5d291818"
SRC_URI[sha256sum] = "8577b1d4ab75c1d7eb91ee8b0a388b626e60663cdfccba352b92c2b5327d3b0c"
