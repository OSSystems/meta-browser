# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "179ebb6b5f1638a7051e4690c8e78fff"
SRC_URI[sha256sum] = "663be3c0fb4af8ae55591ed503e3bbfce4fa40bb0837cfab778f793854505c41"
