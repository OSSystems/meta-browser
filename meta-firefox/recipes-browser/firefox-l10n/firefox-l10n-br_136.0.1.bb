# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1f2dae101c4fd8a83c59cdd49bc7bd52"
SRC_URI[sha256sum] = "b1d7792243ef6f38c61eb1901e4f647a467077c01fb471bbd8f08e4a6aeacacd"
