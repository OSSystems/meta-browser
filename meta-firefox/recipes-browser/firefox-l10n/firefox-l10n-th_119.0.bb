# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "26dfcc1f6ade04698410d1731063675f"
SRC_URI[sha256sum] = "ce10d11263f80b34897c9dbef668e377481e1c85d5e2c05f9544e5a8af686aec"
