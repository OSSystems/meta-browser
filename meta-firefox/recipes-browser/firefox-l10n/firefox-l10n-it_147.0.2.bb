# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bfefc4b080a319fd1f4df221b47cedb4"
SRC_URI[sha256sum] = "e089cfd79361d4b1f675b06c59c78fec42ff0086a06bb2fcd2710ca4cd5fc00d"
