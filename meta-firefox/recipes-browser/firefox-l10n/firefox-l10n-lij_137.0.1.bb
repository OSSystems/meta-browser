# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4c46a8941ade715b41a6170be7901f2a"
SRC_URI[sha256sum] = "d1302ee81574b02e28530867e046c1e58547afe8fbc5ae87e4c064583e529aa0"
