# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "eb831470265fe0c38cff8064a9cf045267a142b10cc1b6870c9448a450a5c95a"
