# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "1070381beb3ae6e74db88cab36a01ac15ce0ab4f62953ee0275dc7bc28ab688e"
