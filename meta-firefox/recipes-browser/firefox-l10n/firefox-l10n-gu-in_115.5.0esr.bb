# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f119362e78edf8c8a5415911b8536c95"
SRC_URI[sha256sum] = "2bb6c29093c2785806e7e4cad079ce99525541461b4ec960ec25372d278ca159"
