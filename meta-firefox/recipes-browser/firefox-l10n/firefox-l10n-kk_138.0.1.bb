# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0371d9a8fdd34f3cde576f249e1aa741"
SRC_URI[sha256sum] = "4a4f2e514dab6193c121813481b8a58ad583d373889f4624303385d158ebb366"
