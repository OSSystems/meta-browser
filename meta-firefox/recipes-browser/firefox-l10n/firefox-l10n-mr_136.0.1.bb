# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a94e5c28897cba62783455419e9d586f"
SRC_URI[sha256sum] = "0abd31060008ca3985095ce0f55d7e9dd7f12f8e9df0e0fe5d70c386b3212139"
