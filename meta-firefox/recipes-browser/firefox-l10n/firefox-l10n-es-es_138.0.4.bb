# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "53fa54484ea23bcb1ccd59094c1b7e78"
SRC_URI[sha256sum] = "0a8989f5290f34750aedeb9b9306b66627fecca2960cb0ab1ced97989276c2fd"
