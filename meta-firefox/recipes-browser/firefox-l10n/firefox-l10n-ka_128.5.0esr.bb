# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f48e4aa27d0168a1c5e537eb7bb44a82"
SRC_URI[sha256sum] = "2282885df2e93ebe92d5d19daa96b911332645531c5b333a92f8b91fb17d1d00"
