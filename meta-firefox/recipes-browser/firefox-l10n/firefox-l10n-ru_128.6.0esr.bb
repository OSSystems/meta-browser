# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "371514f058a40509672c9b776caa9247"
SRC_URI[sha256sum] = "d8006731be0c6307b2eb92d40d9750936bea59d244f376c61f9fdde7ba977259"
