# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "363ab8b7643c880a64ad55b53b0145d6"
SRC_URI[sha256sum] = "b1a4dd54675aed61c3f91fe214971649c51a5fe8c1e218da1b063c704a40a8ea"
