# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "a2604e13076d5f5a6bdb9a4e4a77785fd04316077d5947ab9d3e9fe17a010cb3"
