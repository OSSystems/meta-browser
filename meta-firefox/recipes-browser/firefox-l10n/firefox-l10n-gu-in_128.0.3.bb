# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e32c35636e310005386c06cdce328e28"
SRC_URI[sha256sum] = "cefeb9b51352ae9267f6774874a21c66cfd9785a93dbb286fa39eacff7b00e99"
