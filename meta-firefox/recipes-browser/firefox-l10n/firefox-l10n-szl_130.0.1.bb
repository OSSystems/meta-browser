# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "618d914f6adb0e9490734b4cfd3961be"
SRC_URI[sha256sum] = "6874f8a1ba5028e5cc778e6f68f3ef542d2e54697dcf7054888c175e20de2bfa"
