# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "9dd13bb523b5d475b9a387644036ca79ddb682a165b47074690ce52c40298153"
