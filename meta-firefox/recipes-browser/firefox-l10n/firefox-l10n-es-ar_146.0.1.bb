# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4cb26c399ee0013f0f53a5f8be2680b4"
SRC_URI[sha256sum] = "c5e20ebe6a3c3698c47ae9b8271a0a0538f0545201fa12e0c66dd3b1b1449940"
