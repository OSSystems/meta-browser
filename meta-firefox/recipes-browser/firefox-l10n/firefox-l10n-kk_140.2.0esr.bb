# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a86f121496172a1fb9734d423ddf5883"
SRC_URI[sha256sum] = "3c0367061141af4c10a40c36466028f0ca70cae38b23baada5cab88621cd4d09"
