# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "6109d543ccdba7997659b636170fe68dd97757a4a5cfd738b14b2003b1dada7d"
