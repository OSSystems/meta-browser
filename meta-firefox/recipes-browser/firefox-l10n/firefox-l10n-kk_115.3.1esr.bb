# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "124177f53582b648a7e6afd665af3c1d"
SRC_URI[sha256sum] = "c976475eef2aaf931de7cf17d747bc0baadd28356b63f5f16ec6b65d147728d5"
