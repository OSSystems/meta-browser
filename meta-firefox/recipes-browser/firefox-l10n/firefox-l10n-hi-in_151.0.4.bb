# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "8c2033f9871c7a4aac7c549d1745a7ff4049a9540a6a8ec1b3955d93762abd03"
