# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "810ac4e18d24f8592641df625d42ed99"
SRC_URI[sha256sum] = "696ed70f90d553c8a36b8160c66b9500b5491068a4ff8dccb1767645ae59eb0b"
