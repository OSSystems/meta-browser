# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3943878fe832d950436720190024f0de"
SRC_URI[sha256sum] = "11118e9bae4f0f2c9b4f68d601c85d0eeee5b33de15c1be2a1e87304efad6f03"
