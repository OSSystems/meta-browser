# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7e7f07aa93bdcf6f89400f6055e71ba99b407e2ec61fc3708ef714c0df6854ca"
