# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "49dcd8b2ca6a5b115bdc9609bc040193"
SRC_URI[sha256sum] = "fdd87436934997c118b4e3c38c54152b8048680955c10d4936bf90a0eea43751"
