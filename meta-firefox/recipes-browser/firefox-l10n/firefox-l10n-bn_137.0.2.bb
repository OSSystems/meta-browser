# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "30c0a979e89247b03d130ab053e35a58"
SRC_URI[sha256sum] = "2509fb7cafbead26943f9c9041bf90883e26e1ef22851f84d6ce6961cc99e9c6"
