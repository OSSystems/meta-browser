# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cf2138009f70b70d909a969b1ded1683"
SRC_URI[sha256sum] = "f10ba09cbfd803fb6fcc370495e06d938e3dfa7d4f72028f8c77d6b0a05d91a3"
