# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "152698d60943712791eaa5f56e8365e9"
SRC_URI[sha256sum] = "8ffed94ea60a4df00a9badb5e2c2d046001062d33bdccb74e3553673bed52dd4"
