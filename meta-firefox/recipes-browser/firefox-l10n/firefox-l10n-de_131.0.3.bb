# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6935823a77919ec3e9ff4553b731b610"
SRC_URI[sha256sum] = "88d058f55230c49a3d7e9c76225dd6111eadcb65ef582bf9d0f0a4627fb9117f"
