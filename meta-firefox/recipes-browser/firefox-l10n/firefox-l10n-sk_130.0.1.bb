# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cc7ff14824feb7cb0e329ec38d6c5bf6"
SRC_URI[sha256sum] = "cc973eea5e2bd06d13c2717cf500ccc5db2d159c3e57c81fe0e071ec7e444f2a"
