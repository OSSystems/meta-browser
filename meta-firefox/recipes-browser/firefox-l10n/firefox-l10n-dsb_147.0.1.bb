# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ba170bad0ededea3ddbba93825b61e6d"
SRC_URI[sha256sum] = "6dab19059efe2a4851e91225d95cfa50f706491dac52f2cc77837fb7ec542620"
