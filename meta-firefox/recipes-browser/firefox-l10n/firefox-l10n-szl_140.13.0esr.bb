# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "56ce378cc0493a6732ac250de684ec2c11f268e472946cca1702e806c97044fb"
