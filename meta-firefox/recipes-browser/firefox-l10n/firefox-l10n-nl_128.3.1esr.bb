# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9933884a18cddb6546d68332628462ec"
SRC_URI[sha256sum] = "0cd56c16c57af2e0abb5b764b8e40573feb073d3488c60834ea37796c995dc56"
