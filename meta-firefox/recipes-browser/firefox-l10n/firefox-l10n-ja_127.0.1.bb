# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cd48edc516d4c7b1df4e312782a5b407"
SRC_URI[sha256sum] = "c42a0328104c452301c6f31a232e2840681cf458c3dce4e74c2b7acc4e429d3c"
