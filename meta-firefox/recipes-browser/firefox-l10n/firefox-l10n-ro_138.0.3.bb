# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b3c8f373a061bce0c75e10daadeb727f"
SRC_URI[sha256sum] = "fc1d33b2aaf21dcc507c83730bcb26371f280c112a6d43ee7c4791a41f5ec8e6"
