# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "37411b3e8cd078ecd111ec98a15de688"
SRC_URI[sha256sum] = "690087e78278e3c69d5733acabf02610c980d70cb0eb1ca0e37efa7f72936a8a"
