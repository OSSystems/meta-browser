# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a27667b2b1a9ff0c279039c80c34c9f1"
SRC_URI[sha256sum] = "a44047a1b5afcdfed388b1835c8059d61c26748899aa51bfb4b4fc774b154bf3"
