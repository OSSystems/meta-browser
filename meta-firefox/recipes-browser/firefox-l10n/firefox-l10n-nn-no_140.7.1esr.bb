# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "957a74458caba356dae359ca436e13e5"
SRC_URI[sha256sum] = "dee20c015aa33f5936d83ca5b54476db2c357ecbc22be27cf9244db64e8610bb"
