# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b0ab37d69b4fab4d3b7bf71d017f8a19"
SRC_URI[sha256sum] = "e82debd66580d474723ac69a6f264607d395943a05d33ae5e3be68cd9212b775"
