# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c7214a8ecc7d8164df53592f44b1ef4812719dc47ff2f426ed935f1066fd20d9"
