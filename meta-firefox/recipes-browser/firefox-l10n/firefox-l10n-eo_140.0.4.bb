# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a98998c8ce33e8106f40e0c006e92334"
SRC_URI[sha256sum] = "bb41d2622ccb1a76a54c434a4c4564d3fa76c0ea330da142b59e0b416eea1982"
