# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2dc52b109c03e84464ec1503542a225c"
SRC_URI[sha256sum] = "8261a79d254faded733578a6bc89121f1569b9bb4a05e094a80d51b5fa12f7da"
