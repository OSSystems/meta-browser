# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8f49b9debf561296b2f3ee2a0cc6f273"
SRC_URI[sha256sum] = "946a9f39763debf1ce54a012400892b7b56c1239047586285374fcae6dbb46fc"
