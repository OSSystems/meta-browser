# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a28a0bc357b3b85749d0aa4cf6d0327f"
SRC_URI[sha256sum] = "d543cc6dafb33bf7a2669da1e17a7dc6f1acc703359be3fc81bbe0869320ed9a"
