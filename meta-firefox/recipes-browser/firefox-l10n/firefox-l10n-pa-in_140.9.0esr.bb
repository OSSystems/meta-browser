# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "648a569ba6ea9237acf25600d3f68d92"
SRC_URI[sha256sum] = "f6bd626cd6e236d9d323553fac53ae997b95c1e443c4518f7d39f980d4a9c9d6"
