# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d486252cfc1c703b36d6ba55909f0a0f6cc7205d4b1e6745df03b5f27484730d"
