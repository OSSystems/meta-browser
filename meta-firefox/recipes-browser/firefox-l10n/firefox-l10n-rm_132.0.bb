# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ad142c7780ca7ee2f6394daeb62e8f5b"
SRC_URI[sha256sum] = "4dfde35b72365a0aeb6641c8306ee864c249eaa8f5d273c9654cbd98dc5636da"
