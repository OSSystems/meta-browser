# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "28e48fb2dbd5ce71638542eb8f147d94"
SRC_URI[sha256sum] = "3bcc6381fb51eadadcec60dc426fb4aa0f5f127fa7c0b2dd2330fbdb3fcc408d"
