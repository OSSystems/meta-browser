# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b4d75ea2c7a03c2d674a5e08bddab37a"
SRC_URI[sha256sum] = "595e11d6d3de22c545bf7a399c1c6baf25a841ceed7d8917260afe928a8258d5"
