# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d323ed3480d80b98d9b6fba01fed218c"
SRC_URI[sha256sum] = "c5245544a671d3df84c59e09b81b3930bb32f30acd49d3e2edb1539abcca5562"
