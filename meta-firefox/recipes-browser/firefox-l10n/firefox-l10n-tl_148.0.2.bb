# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f4c76f001529ff042e3c781dbf788d38"
SRC_URI[sha256sum] = "6a4f3b6bcfb13e1e88dbefc97f482f12fa0f2b3bc3644707fb44beb28c6a40b5"
