# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "41bfb328f90e755aa58256e7674cf376"
SRC_URI[sha256sum] = "0b573bf17287e7e15d1ed9864f7039bf392fb9d0f3ee3a0933d11d3f4be8cbc7"
