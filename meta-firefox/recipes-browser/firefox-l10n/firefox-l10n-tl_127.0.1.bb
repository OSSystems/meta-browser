# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9898b528be336726edae7f776562a203"
SRC_URI[sha256sum] = "20a453d10ea2f52da9e6c6ab803f43902b9ed66a4a476559e92804a0532e44ef"
