# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d0b30ad08ebd1203f4da0eb87c580a68"
SRC_URI[sha256sum] = "a25239ae5cd799beaf3543c8f5826f867635c28a7320f4c50f81778f28adf488"
