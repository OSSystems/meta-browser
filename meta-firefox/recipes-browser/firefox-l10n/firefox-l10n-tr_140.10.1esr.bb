# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "375096d704aa17dfdd55f4f041a02f5a1cbb3aecbdef04c323e9b2dbb0ab181c"
