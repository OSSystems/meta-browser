# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3e4717983e37a2357cab5777e6ba72b4020c7bc4ad0ca8bfc4af1701b70f51ab"
