# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d021355e6ce10761e26d6caf98298721"
SRC_URI[sha256sum] = "68c26cd95c907a615e7d5e2e0c37bb72fcbc0ca77aa27a5fa3a792a23a4ca98c"
