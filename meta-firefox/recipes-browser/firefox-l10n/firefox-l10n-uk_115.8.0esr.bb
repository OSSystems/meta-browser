# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ad105adff751c9944a19871a23be8ea9"
SRC_URI[sha256sum] = "7d67d6d7fa493a66736617d7d0407e43f85f080f2eb5fb86e832e668e151ce34"
