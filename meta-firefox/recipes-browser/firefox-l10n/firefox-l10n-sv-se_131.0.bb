# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ccca423aa8217ab69f54e03912f2a3f1"
SRC_URI[sha256sum] = "96e6461a90e96a7d82816c34edb5771e2ff858c9eeb833a688f5b973a7e773ec"
