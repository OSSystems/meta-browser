# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "654262c3d6a4296737360b5a4b3ccc06"
SRC_URI[sha256sum] = "f40b8a3d1b66bc553a195361878525ecc01ff958ab80d12bec3a1146313d3522"
