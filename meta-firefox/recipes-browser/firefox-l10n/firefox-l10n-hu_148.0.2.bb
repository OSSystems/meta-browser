# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "32d8238d510fd5b86953b572af4c095d"
SRC_URI[sha256sum] = "bdc83c6b092c09b968ff04067637a350658e6c636c1937c7410537a80f28d090"
