# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "71065a0251226a4cb8eaeb020b381977"
SRC_URI[sha256sum] = "fd0fa132c66cf3c18ade20b9a3ced2b13a5ccfd739371331341187e7afb05bd7"
