# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e86fc7128cf4f75a339c47ad9a038ed3"
SRC_URI[sha256sum] = "1d2e30d807d2a38e4ea4c6406596d3688bff2c86c042ed9536f24dae27cb8a88"
