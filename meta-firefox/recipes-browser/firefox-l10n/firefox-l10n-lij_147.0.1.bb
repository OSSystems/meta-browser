# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a72b24041a5babfe9bf769d84d6dbdfa"
SRC_URI[sha256sum] = "e81c5ed64331cfdc5d3a9b95faeaedc0097eb0e00f18d923af9dd22cd0d2a363"
