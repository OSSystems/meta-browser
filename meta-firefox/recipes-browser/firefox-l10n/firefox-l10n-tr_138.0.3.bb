# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "06358e3869233e99fbacc76241582f37"
SRC_URI[sha256sum] = "a4be244e337ed06d25d595a52c04575c7789474654236d150a8f07858baea040"
