# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c2d0598a6b5e6e117519e119ab65e885"
SRC_URI[sha256sum] = "e09a9745d86b6594d88b48a3f48f0b1d1819a42e39c9de7bdc71d279e829dea6"
