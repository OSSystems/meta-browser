# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f926136d395424fce19776555793b7f1"
SRC_URI[sha256sum] = "17352462b0d1c6c7c421bbcef7b599a4daca0b4b0be743872970a76b52a16e4c"
