# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "02953e8a9c5abc7cd3a63cd248ea0b0a"
SRC_URI[sha256sum] = "6c28b730e61f97fb6dfdc3ac00efb9d6ca7e1951180cd62cbf6be56d063ee379"
