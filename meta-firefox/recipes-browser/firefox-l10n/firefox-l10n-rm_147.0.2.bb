# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b2b5dd59009a3e43adb995843de0332c"
SRC_URI[sha256sum] = "0a9f7656c92d00fc60e4e383415cf0ccb3efb71688c1c04db468f797894bad6a"
