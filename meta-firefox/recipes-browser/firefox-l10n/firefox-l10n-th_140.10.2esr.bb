# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "a5e389d43b865b55da70864f64343fa4fc3f98da14c4c0326358acada8060e5d"
