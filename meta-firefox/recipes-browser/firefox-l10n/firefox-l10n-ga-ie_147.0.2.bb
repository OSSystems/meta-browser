# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "99c54da72d3669ca3ae7467e2d68899d"
SRC_URI[sha256sum] = "9272b081abaf6f2e98689e1c5570ffef50b769228211eff8a605f5d9a6e8e1eb"
