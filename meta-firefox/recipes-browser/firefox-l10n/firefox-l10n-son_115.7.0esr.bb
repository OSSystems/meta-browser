# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2937715faab5eaac06069d462b2858ce"
SRC_URI[sha256sum] = "59a5648daf816bd3112daf99725a83b769455ee9a855ff80ecd764fc1db532bd"
