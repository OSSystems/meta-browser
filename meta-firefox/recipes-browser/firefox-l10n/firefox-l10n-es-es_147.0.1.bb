# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d014bfe57fb35830635585d54292920f"
SRC_URI[sha256sum] = "80ae67157b246fc4cda5df17d19bad49437693cd69e88980bf858852dfb423d3"
