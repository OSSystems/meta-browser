# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fc242089ad9cc9218344b1893ef8b2c1"
SRC_URI[sha256sum] = "a56edf6afac8adcf604597e633cfe8759d2c1d8ef51f44b42e0a5cdc19ffede1"
