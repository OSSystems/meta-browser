# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ee51ee550b563a4a6e942f0d38cd9c13"
SRC_URI[sha256sum] = "130f7f63c3ff69e02b41594f2a30d96acf713462f1e3c40de032164c29cbaf5e"
