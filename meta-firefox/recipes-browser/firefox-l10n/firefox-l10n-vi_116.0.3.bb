# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "52de0df5a294ca1cace447662c5bc0bf"
SRC_URI[sha256sum] = "5791177ca70148f10553808cd34430ad3e4160078bd422598807906de69bd12f"
