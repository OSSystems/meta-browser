# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9df1cf0e714ffc275d093a4756267025"
SRC_URI[sha256sum] = "bd8ac74981d13684b54180725c15672b3391890b6088714f56073ce351614bc3"
