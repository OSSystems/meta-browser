# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c2b5ee9958d392712bd0603cfd155218"
SRC_URI[sha256sum] = "40901c6d8fe69cb5646ea1d217f4cf3eb85b14086a90b57621981563c91bc080"
