# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4806e56abd60c89ac2fe29afeededd74"
SRC_URI[sha256sum] = "5f1cb82d3ea9ed63546368026ac2b7a29e3ea7411d37cbee143b87e91539821e"
