# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7e978ec7eec917d5ef565b3e0b190efd"
SRC_URI[sha256sum] = "30d2a4e56a8cf4e2e2609d47c5c82e08ed3c7754d6815abfc533d0bd614fa939"
