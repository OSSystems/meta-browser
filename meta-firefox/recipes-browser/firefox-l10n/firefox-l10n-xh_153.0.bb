# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "db84e2d0ff2a8bcdf0775520d977c8ab8a397ecfa12133ca005632fa720e4645"
