# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1fb7e2d0e6cac3195aa60e8bc2f0c708"
SRC_URI[sha256sum] = "bfbdc4bd31eb3117c1038f1b16023ef4edf2cb7f378b4841c95b332e1c022425"
