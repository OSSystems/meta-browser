# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "30eb8e0c71d1af1bbed0b0bdd2c074ef"
SRC_URI[sha256sum] = "7bb1f5f96dc5763a79fbbbcec9564e66034976ca6838ec015d8bf5df4be1d58d"
