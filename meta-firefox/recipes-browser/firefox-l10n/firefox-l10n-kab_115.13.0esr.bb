# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "492e2ad359572e58f9930dbb26616cd9"
SRC_URI[sha256sum] = "336ba0c673271f4b6b579b2272704141f4fafefde739d18233b9ec022f1f3304"
