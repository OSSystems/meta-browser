# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bb9ea93a62103e62dfe093213e714d74"
SRC_URI[sha256sum] = "9bea5733f6b1f5ce2f7a8334e297cbec3d7f81063903a462a6784ede621c8789"
