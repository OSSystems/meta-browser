# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "75d416f3275fd25e15bd590f746ce282"
SRC_URI[sha256sum] = "701d9ead0c69b603f362184dd9d4e7db5677d711e4ede3e27f1b868cf49aaf29"
