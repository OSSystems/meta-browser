# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b1613d888abd202f9c35c45cc2038ef1"
SRC_URI[sha256sum] = "50611cfbdc4277d43cdb33df373455a66d29d06d094417fb5e2a3722e4e204a4"
