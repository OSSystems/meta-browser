# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e6b34e7f5e5fff98e42bf4f941f109ef"
SRC_URI[sha256sum] = "fa0ff389a6481988d76aa4e37a28fb56717c5f07e632440759b907c6ba8f90fd"
