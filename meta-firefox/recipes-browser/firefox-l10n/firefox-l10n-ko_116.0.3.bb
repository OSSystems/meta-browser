# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5173ba393210b8305760800f18aa365e"
SRC_URI[sha256sum] = "623e2d389fb7250c0e5e1dd348d8bfc610acf6c46f6c741bb87c0ed22fc7d80a"
