# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "203ba36a6112a258497e3947d2cec559"
SRC_URI[sha256sum] = "247c403f51b62ded5e426b6314423a8a1e70dab9c357e17920508942a3cdb657"
