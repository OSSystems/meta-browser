# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eb2d7e659c1f1d3928bbbdeab134ecf6"
SRC_URI[sha256sum] = "7825ff45ccf83c192137fa5aa911384c79947a0706e111beb95e4aac48fcedd9"
