# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c0b51b944680b1d7eecdc12925949bdc"
SRC_URI[sha256sum] = "4e9f71947038661ee96729bbb38e4eff3b3603874abd111a429a49bbf84988d3"
