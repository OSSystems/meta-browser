# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4eb021fb858acbef51999af1b66c2f65"
SRC_URI[sha256sum] = "3d2a71e0d8200b84de0bf3aecb45aff4c9fbf5920908e0417d87cd6223828d2f"
