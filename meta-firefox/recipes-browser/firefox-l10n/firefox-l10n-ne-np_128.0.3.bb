# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "344c0625f026598166f34c9cfddc516d"
SRC_URI[sha256sum] = "9d3400ba2ddf110ac9f217a672f797899c3eb99dacdfe2e900c21ab635283ece"
