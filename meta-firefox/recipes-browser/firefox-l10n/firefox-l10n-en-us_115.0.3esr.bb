# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4721f97bf438a9497243335edf787315"
SRC_URI[sha256sum] = "ed0762ffaf7fb86a111f30f11372bf9a0a2feb0080da15c7654cd320b08dac52"
