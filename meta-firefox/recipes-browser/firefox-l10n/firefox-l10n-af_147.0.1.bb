# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fcf58cc01104f85df8eba9d657c7a987"
SRC_URI[sha256sum] = "00aa14d68b7ae92b55fe0d05460512d0ebe820d4c36e397b00e4a68905857e68"
