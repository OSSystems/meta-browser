# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5e0fe75965a5a542824e66893ac39028"
SRC_URI[sha256sum] = "0ebba052604ec57f6638d55c4582f0b1b7e08a4b66ab92d65b05406fe2127cab"
