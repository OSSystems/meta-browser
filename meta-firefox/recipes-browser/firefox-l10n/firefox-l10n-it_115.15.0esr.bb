# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "44b86199e4079873ac1c4d34e4c1ea8a"
SRC_URI[sha256sum] = "5560897077c44e878688351c2bd06e21aa46263f1eee2e55d7bdbbb554589b1a"
