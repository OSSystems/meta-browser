# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8706c9c177af636a50d7509faf07a6df"
SRC_URI[sha256sum] = "6abe33415309ab80a9f44452238f39ae0a71ab8cbcc8ca7515de1287380fa9b3"
