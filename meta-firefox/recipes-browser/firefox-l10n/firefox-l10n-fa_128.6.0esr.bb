# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "26555259da25287aae1217af704189d4"
SRC_URI[sha256sum] = "14b81026fddfdeea5ee40eeffaaadddcca74f600ce0e8d4303075d931c62ed0c"
