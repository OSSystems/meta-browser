# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6de839daeb1b141d2cfb806ff9686387"
SRC_URI[sha256sum] = "048b3c18771e812772e907ebd7ff57904fd4d7329e843bb744078aca7120487a"
