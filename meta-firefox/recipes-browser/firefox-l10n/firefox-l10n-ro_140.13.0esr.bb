# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c2847215aba7b27d821a5ef2736be8e854a43c70698d511be653c45ae0da7e6d"
