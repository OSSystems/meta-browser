# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cc7e7e69de70416fa3ca7de6474854ab"
SRC_URI[sha256sum] = "07683f1bdabf212cf256e2c064b97853bcad28edc17171897608bbe221832965"
