# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b50b1ffb43441c654c26d0eaf07ade4f"
SRC_URI[sha256sum] = "928e72bf07366d19e7627decfb163c7861312f59f50d4069a55fc4481f35527c"
