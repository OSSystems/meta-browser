# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6b1dc8410a4c7be427de6001f6160f36"
SRC_URI[sha256sum] = "83717e22a27cdd023c932784de320323c1cfb229f623812fa2de71cadb3d2691"
