# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d2903d1ec23150755c8fb0bd47d94c8e"
SRC_URI[sha256sum] = "f6a0e0a3b2fcd2d40341d53dcee611caf6f68aa31190cd3b8a379470bde24130"
