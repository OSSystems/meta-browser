# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6840c31dca3a65e8451cff8c1adc1a01"
SRC_URI[sha256sum] = "e41f68126a7009014fa2c812761bcc58d7c9e1b3b98fb689db4d54457d930cb7"
