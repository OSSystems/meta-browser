# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a0860bea5d7c0af9958cde8888128459"
SRC_URI[sha256sum] = "ac230daa16af35e6390aa58fb4be58fea8b83b2ef3164f52b0c45f9884007574"
