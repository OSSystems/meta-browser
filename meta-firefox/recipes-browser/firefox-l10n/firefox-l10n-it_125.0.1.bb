# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "44fa0fba0f3f4816ddc88f94200dba77"
SRC_URI[sha256sum] = "64f7fd58d31d779655ebad34a33b62c7b24cf9a1fea2235dff71f2663b7db5ac"
