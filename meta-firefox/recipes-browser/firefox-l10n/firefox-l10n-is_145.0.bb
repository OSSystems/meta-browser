# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "38cf33cfeaa000b2bb7f5f9dd8857e13"
SRC_URI[sha256sum] = "6f6a71c6f2f38d69b164b66c3ed56e17d16ec7868172502035378d3bd538bbbf"
