# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "116a4318a80f2ddd80fdf944b672a87b"
SRC_URI[sha256sum] = "c9466116925c119b9eb17d006adea2d2ab86afd16390653931afb0a91433c729"
