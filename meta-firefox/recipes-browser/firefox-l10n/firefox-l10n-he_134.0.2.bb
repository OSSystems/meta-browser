# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ab1e135c62610d480deed9b807f9a484"
SRC_URI[sha256sum] = "db065ce68854e2d12832818c67cecdb62df9a123da07e1b87f380521153a96d9"
