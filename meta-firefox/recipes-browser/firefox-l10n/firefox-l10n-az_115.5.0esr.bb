# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5d7c5c6d741008b7819bee3f84425380"
SRC_URI[sha256sum] = "33524192ece83ac6c3727af46ee3b731d7ec294fd68a00e626fd1eefc9bda0a3"
