# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9d31d9b998b400af6b1348e0296debd3"
SRC_URI[sha256sum] = "2e32c0f6af456a07b6ddc7ffae8e098f80c111e7a5ddf93f5c869a541a8e8264"
