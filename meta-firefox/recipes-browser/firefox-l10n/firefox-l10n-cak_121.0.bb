# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a5e4068b208dd01bbc346dac4c323a16"
SRC_URI[sha256sum] = "f45a4f9a09b7cfdc24e1710b8234e055bf123d9cb30356e7a49741a18c5a21e9"
