# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "57219ed623d2f378ca26e0f8395a890764df4a6bdbe7c70aff3e6ef440c53ad7"
