# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6e3ebefed4f2f3635cbb85e268383c64"
SRC_URI[sha256sum] = "f603ec820ac9dbadc50bd4fddd65a9370cf41df7b5fc9db7e81904fc20df1cb3"
