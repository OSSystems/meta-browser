# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "f3c38b41ef7b888a226d79c747ccfad47e0be84713413072c297612e74640c9a"
