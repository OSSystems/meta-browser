# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6889ff3e9640e4f2c851644d38840012"
SRC_URI[sha256sum] = "b232b5ac7241eb850c9587cbaa9bd5507296ffabb0dbc6fd19e618669df91ec7"
