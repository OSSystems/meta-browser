# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d0c6af8d6d0069cc0c8216193d196f9a"
SRC_URI[sha256sum] = "514388a046f6e3990a18d133acaf1faf83e5e243371ad00bece89165ace172cb"
