# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bb9d03b76e1c0e5f27d049dd3c169100"
SRC_URI[sha256sum] = "a4c6bb8569c11a11670c2c33ba6399857654ecfb32da9c8e0c38f1dfa5724ea8"
