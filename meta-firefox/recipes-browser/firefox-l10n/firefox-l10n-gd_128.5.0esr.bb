# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cd8c720f9e592f5a6b2d51953b900750"
SRC_URI[sha256sum] = "82ebb3f0a8f2554aecf3a7d0d7f8c309acd7056bf6e968ef948c30ebfd1d7c3c"
