# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eaaf1700403b8acb709ffeb65ebb3f57"
SRC_URI[sha256sum] = "d18fa49c39eafb2008ce4568e416ddf90951f18abbaa4fe3b44f9ae88be13c91"
