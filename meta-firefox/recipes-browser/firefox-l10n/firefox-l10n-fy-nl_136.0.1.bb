# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1d4b24fbaba4d3d9dbe77dc15f2cc532"
SRC_URI[sha256sum] = "88bd9f0a00444918b92d602d2ff28c2f643e4a2cd21b09c657be8f76f26cf385"
