# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4bed3a3a7572dfb3916bb6fdaff0431e"
SRC_URI[sha256sum] = "d1fb8b347eed128f3ff29c27c53715bd590fe961906c9f471765ddd153950756"
