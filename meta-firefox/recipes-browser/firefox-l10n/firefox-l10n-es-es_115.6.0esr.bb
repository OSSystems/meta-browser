# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7c3b5351736eb977ff6b775d64b23cc5"
SRC_URI[sha256sum] = "3363f0333a090e9101970348772f2b7f221d5f6f8ac00c3e5d8440aa1c452633"
