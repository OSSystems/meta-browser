# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7bb55e87f136f28936a724fda77fc7c2"
SRC_URI[sha256sum] = "0db02fde9a3431566c9d3b083b20ed26222daf233619ed2bbec819645343380a"
