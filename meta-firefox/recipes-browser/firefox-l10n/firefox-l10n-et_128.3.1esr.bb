# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9a783d73a90ebc1e1fb05bafda87ecbc"
SRC_URI[sha256sum] = "2c59c7dee1db9bfa6a22818de16afd1f959e131324a42838ae8e6ecd57143832"
