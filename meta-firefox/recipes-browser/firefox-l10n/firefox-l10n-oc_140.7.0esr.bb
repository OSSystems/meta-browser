# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "41c44fa9dfa3b875ecf82e4395e381be"
SRC_URI[sha256sum] = "22f2325734551629ef134b1a2973653c01e71dfadd3e4d9c4ab769ad45dd5813"
