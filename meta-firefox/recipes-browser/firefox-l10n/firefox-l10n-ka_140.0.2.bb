# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f7adddfc9f92853efcfa835b92f9bae1"
SRC_URI[sha256sum] = "5b9de9e2e9ec40da34b7eb3088b695631983cf0202301be08a0bf8f6f8ab138b"
