# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "5f6fb0570d2defac00dfdf0fb10ac6081bd103e3907eec01ec5d83bab19fdb24"
