# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b2d6cd5ff857a4827def8dfa89435066"
SRC_URI[sha256sum] = "c8a4e3b9efbecd43e0a25ca88ad61f09cc9d2ebd20cceacd79fe5400a0e76150"
