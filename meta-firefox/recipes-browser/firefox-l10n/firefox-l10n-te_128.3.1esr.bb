# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e09dd6ff59010e2cf924ecf549960898"
SRC_URI[sha256sum] = "9dc8e724fc9b80786a773d0603bd84286fd2ec7c072721dd4164d707080063fe"
