# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4743f7a288436be7c3a4f86fd438f2da"
SRC_URI[sha256sum] = "d3d797a161dd4af723f91f9a6edf314d715e287731cfec88ae12b6644af6dc5f"
