# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ba5b2f78ac889211381bc22f14785ffa"
SRC_URI[sha256sum] = "5af0dbbc36c23ab38bf04131c6568480677248e4d217e285408153429a121c24"
