# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "59645079f58809d533946817e5b6ed5d"
SRC_URI[sha256sum] = "e37569dc11cfe735a93685449fdeffcceda1dd3fc74c2413a5abba3c454e6b2e"
