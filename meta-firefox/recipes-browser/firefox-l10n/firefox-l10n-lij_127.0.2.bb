# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ace726970e1c45bdab5a1ac9d7865c59"
SRC_URI[sha256sum] = "e1958faf80ca11aeabf0cb1055ecd7842b2dff4ca08c6059af741b968f717d12"
