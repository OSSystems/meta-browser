# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "adb5b9fd2216d675db7b3f9156f712db"
SRC_URI[sha256sum] = "7acf9324703ee0b7fc715a1b1fb486b961c6632f9d697a2a79bd1a4af18e2fb4"
