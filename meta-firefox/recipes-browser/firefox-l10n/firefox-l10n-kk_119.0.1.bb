# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9cfbedb0233cdbde097ac7497b8f3ba3"
SRC_URI[sha256sum] = "c29d7595722ec6f5fb0fd3aa6f01779f5cf113bba6c32551ba443e40da6eecbe"
