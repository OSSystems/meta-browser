# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2177ece1a1fcf923bc1b22727401fceb"
SRC_URI[sha256sum] = "c7d62e3c89a4912cf41e740c35cd770e9c24ab0e125b9aa8f12b599824fb56d8"
