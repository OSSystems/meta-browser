# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "174b44bc10f75b3f4b19303de5a618b4"
SRC_URI[sha256sum] = "1135537bdd96277a01c995dd7136081ca4b83d3e9567f1677f6f037f5939abed"
