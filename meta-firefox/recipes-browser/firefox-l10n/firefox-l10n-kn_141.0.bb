# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "55fef0724bd88dec21e7377c6a0557f5"
SRC_URI[sha256sum] = "ad773727efd70bb214467fec434dee6ec4ddc61b310a57d629be61e910720f79"
