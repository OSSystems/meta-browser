# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "12d743b55e0a570b7438ceea3e8ebb04"
SRC_URI[sha256sum] = "6d898be61c679905f72f66f2fd4384500e09a8a1fd3c576f4816bb4d25d25375"
