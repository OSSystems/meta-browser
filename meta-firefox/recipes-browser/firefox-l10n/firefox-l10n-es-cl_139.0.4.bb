# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7c17700080da4518f7250f699ae52554"
SRC_URI[sha256sum] = "e328db8a5549f1ba1f02d46d7c9e98d1b4225ef09578a3897d96f87ba9ebf6da"
