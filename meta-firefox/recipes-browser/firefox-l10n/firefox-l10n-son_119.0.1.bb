# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "375a8db31f4d01a4ba4ab631170c86c3"
SRC_URI[sha256sum] = "08e078098f04151b88f862c789ecd3dd854d7bc487f4c1f24b480dc1e98a4a4d"
