# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c3ee08d79f328a75800a460ff1a97df"
SRC_URI[sha256sum] = "43a4c62ce08f3aa0ef279aec927f2250904678ec42cd417b8064d719ea958c9e"
