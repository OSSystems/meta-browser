# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "dbac4737a4d7309482adbe60ac5998a96d7d8548a66903f0815052a7d84ff6ab"
