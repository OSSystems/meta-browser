# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6c588f5c606bb78da21f720d6570126e"
SRC_URI[sha256sum] = "df93cc49d2c81dbf17ac114b3d72fd280f76d5672324682025627928b8bfeec3"
