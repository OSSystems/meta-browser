# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "50be9633e744b481b890e3d33e7dcc02"
SRC_URI[sha256sum] = "8860ee2004d2b3b0d892f1cf48fce212a4d7176967ab6cf187c1e5735f37e1c7"
