# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "19507f87536c8cbf317df519b16cc3af"
SRC_URI[sha256sum] = "f7026b5fc8f2073f7716b83eaf2ad64a590b1b778112b2a604d9eb70fe91ce79"
