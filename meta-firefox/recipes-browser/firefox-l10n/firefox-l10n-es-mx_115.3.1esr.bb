# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c126a7d4778d17b7286023b73fc978d3"
SRC_URI[sha256sum] = "6e0485f1f15cb00bc665e4a4dc32494bf6b2eb799236bdd750dafe22d7275e0f"
