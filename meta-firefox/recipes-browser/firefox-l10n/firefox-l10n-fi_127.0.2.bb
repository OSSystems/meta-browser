# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a6266b93a12c742390bf581b093e0f3a"
SRC_URI[sha256sum] = "53d46f234df16af3d50b7565de99916d99458db0eb0262682c3e9e9a35fa1c08"
