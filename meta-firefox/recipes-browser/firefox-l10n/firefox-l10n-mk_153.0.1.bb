# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "cbc82d404bfe3de71c56feb73cf2654c5cd47007cd7098472d832c968e7cda1a"
