# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8aecb5cd7108fbdba0e933b521465e8a"
SRC_URI[sha256sum] = "f37b15d0e263eefe4acc3f4dc93de7a71b725d03452cffc956b8f26970a808b3"
