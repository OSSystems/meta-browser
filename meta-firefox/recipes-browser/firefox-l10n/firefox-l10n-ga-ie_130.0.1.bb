# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3595d57a458fd56f7411fffc5277183a"
SRC_URI[sha256sum] = "c56031f20bd847943a089ce962d753bb1f9c94152a5f4d42e59908e81fe1800c"
