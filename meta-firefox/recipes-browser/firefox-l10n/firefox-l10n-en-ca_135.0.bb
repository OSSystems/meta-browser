# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "82fe5799b963a348beb81d0196d5f4f2"
SRC_URI[sha256sum] = "841c4c7da73a508427dfb3a90b2c59b3681ef41e59f900fd606e1f989cabb594"
