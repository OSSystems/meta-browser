# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ab415f7c866d23c1cc5031d675e9c1b2"
SRC_URI[sha256sum] = "3f2b1ad185f3042e5119f39fa200afa62cf795ed44dba37f3f75237572275b66"
