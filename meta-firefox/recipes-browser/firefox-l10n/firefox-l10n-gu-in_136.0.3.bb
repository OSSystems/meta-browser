# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7f6bd4352ec1665f0e97f3d9d549244b"
SRC_URI[sha256sum] = "3e6b9f3ab51456e26eda798f0ef587b379c2db4e780b62c31485ae86fb1160d0"
