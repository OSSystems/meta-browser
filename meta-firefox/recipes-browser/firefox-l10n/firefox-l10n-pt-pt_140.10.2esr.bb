# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d1b85686aafaee8c65330bac06c530d90bcbc78519baee22112dfd73471f0071"
