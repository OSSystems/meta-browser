# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3ba24686f93de687b33fcba611c66a32"
SRC_URI[sha256sum] = "6d5c076b05cfbb8208314c0a7762086b9d96e9b2cde7cc77c20eb1ce80b285b6"
