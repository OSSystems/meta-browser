# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dc1e75e5599a423f37fa2c6a6a5a4380"
SRC_URI[sha256sum] = "528776de27b40b01e2d46e83c8cceb1b815609fe80ccac44817e712c123fad1e"
