# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "36406a397bef358a1aa45d00046982a9"
SRC_URI[sha256sum] = "e613e70d2c6470bd69c5cc8cf1153aa264300cf7c0ac8a071c791af1bfbba0dc"
