# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "16647b6f728bd55fcdae8bb7dd7d3d33"
SRC_URI[sha256sum] = "fd9b6d707ca10e84a02300fb5cca7aafc108d3d6962dd83131b702603952116c"
