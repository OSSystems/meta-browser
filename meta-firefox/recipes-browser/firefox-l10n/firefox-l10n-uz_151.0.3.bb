# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "18c924e8ed58bc3d0485d2fec057940024f4ad9c5794e829631028445412abcc"
