# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f028325b36eb42bd767f51f3bf0b0403"
SRC_URI[sha256sum] = "03f0084eacd55b12074d813ef704b027f01a72eb7119f1004fa763c56c36fecf"
