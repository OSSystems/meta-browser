# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "df9be5c3e9fda89d15df0d3c52359764"
SRC_URI[sha256sum] = "e818d423bdfa89f99e526ed68efce03344ad948b73ce46ccec63c2d218ead292"
