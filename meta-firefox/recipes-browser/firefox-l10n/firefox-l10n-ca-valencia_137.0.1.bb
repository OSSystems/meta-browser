# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "26809116754ff316447ad01735acb0e3"
SRC_URI[sha256sum] = "2ceede226abc53ee636ad6d0e043a9186421e296b8e21a697c92031d3a3fcb22"
