# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "365f85135028c41a86b518e0159e2820"
SRC_URI[sha256sum] = "19fdcf8855a01237495ed8528a4b3a1557493c52d85f2e4e1f1a418d32b0c33a"
