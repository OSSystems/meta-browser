# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "976918cd5fd9c87bd53ff9cfd46024de"
SRC_URI[sha256sum] = "89a6c822b9e876b34a5091d0dc0efebfc9b115536765dc5221138ebd4b345bfa"
