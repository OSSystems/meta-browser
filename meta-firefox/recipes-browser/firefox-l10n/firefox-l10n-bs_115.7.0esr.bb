# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a6ce24327d7896a0ca17ce7c23c44555"
SRC_URI[sha256sum] = "a599f205a6e9f812064ae5d2f862f31c746d69e1070144749a81bbf1518f0b8f"
