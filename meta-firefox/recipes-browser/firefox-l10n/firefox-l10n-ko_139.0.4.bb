# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fd54e30515afeb44038ee03d4a0ee77a"
SRC_URI[sha256sum] = "f11cce849e15c5b17c2d4c2f489f620e63bda5911b3b714e16a30db551422a12"
