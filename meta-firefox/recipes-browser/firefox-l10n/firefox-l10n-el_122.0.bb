# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b463ce193383aa7c63f9dc71addfc109"
SRC_URI[sha256sum] = "f31cac5fcca307372694340b83dd3fd5ab208d1797f34ac35f0b301c787706cb"
