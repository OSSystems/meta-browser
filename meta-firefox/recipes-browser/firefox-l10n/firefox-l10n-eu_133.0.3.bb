# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7f2ff1ce907d036563d25f0c859a1344"
SRC_URI[sha256sum] = "cfc68182ce0e00e3a2e30cc2b040f33fc0b74f8f6ed67891c1abc0d96d4bf066"
