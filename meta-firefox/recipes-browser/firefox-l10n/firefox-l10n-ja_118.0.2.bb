# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d451fd7262938ac78d57482b8c9f8d09"
SRC_URI[sha256sum] = "982dd102d7aaa08a139eed1257e094487648816e713ac5b39871581478e64e39"
