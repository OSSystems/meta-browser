# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "99597bcc0b320503237e2a714688a06c"
SRC_URI[sha256sum] = "211713847f3ee03a53f431f70058f4b2b5b114c1dcdbe5323f47df7f588f453e"
