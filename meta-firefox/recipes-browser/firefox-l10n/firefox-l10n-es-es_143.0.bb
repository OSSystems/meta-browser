# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3bfe4a790e1c855d35381787ece19ccb"
SRC_URI[sha256sum] = "7c714935f06fe9417f0d9747b765bb6bfd8c9e656413b860c8f8f586a47b6fd1"
