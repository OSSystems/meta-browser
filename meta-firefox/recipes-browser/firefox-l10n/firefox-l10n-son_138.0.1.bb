# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "759e3655a5fde6d5098c165c08bc2c0d"
SRC_URI[sha256sum] = "ac2bb9a52cec7b6018247cbce22db68acedd4fb1130f0500b50af79b359d1b25"
