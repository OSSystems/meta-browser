# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b19987a4c85dc86b6357bc72dbacbebf"
SRC_URI[sha256sum] = "af433efd76577aa17cf4aa3c5300b509c51c99063b28ba816150cc4d78d2930b"
