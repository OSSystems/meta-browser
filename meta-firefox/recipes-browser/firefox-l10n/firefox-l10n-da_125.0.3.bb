# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "614f7e23f00e58b9c8e96f785469b5d7"
SRC_URI[sha256sum] = "f9eba855bb58b3d70b65d94915659b57cb8b268a84bb066a17585cf21482e350"
