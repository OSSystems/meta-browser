# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0d5a721f7371cf82a2f3c0f17bf76d29"
SRC_URI[sha256sum] = "e4b34dfefa75144ae8f76f8de6c10755ca061a1af141dffa06536ffad59ba202"
