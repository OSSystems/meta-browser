# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "42f3406ea9a6434be0e906974f1815b4"
SRC_URI[sha256sum] = "bdb96dd72ff08c6fa1529560cf08e15158404cf2ef9d460bd0036c710324151e"
