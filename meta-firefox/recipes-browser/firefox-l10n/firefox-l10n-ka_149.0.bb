# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8c2b6f70e1c2df8850727977d931f04f"
SRC_URI[sha256sum] = "0685162f73850366c015db87f5b1c47fd8c6c10610980dacc73a68902620b363"
