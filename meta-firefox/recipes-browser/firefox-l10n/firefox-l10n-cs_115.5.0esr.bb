# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "73c3aacbbe8f2bead19ff35f7f6d736c"
SRC_URI[sha256sum] = "d6d596953eab200ae7d136e446f449925122a647da02e4905358963283a9f68f"
