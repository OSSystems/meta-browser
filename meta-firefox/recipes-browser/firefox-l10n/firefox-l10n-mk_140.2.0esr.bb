# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7155152e4028e5cce32fde0c72986f35"
SRC_URI[sha256sum] = "b1dbb9c31f6f94d10a3fa8005612f43a22e5009ef150610b8ee49dea7042324c"
