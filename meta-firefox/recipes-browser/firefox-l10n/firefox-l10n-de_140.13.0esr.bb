# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "78b9e0c0e1dfccead9ce019bfb02719914902c453e8947bd6b9e3c26709fb4ee"
