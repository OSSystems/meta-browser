# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5527a71fb82b209598f544c27116fc98"
SRC_URI[sha256sum] = "3d36a95aa28adde298475ef2be948096f11ffc6d13eb31c60512862dee39531a"
