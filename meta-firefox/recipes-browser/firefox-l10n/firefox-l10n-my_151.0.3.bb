# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "8986f9beae2b94de98c0b83dbbb06b4a103ab1155cf39e17df5ab0b8dc76de10"
