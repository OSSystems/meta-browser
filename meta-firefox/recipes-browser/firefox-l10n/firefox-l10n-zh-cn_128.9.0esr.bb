# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9f5f53aa6b945ca820f5de69d81f7e3f"
SRC_URI[sha256sum] = "c21e3bfabbf8fd166e414a4a593067ddb3e93cbfcf7a4c9d243773b867bc7fd0"
