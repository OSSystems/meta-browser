# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "16f63f579a0f9c76b057a29687e99f27"
SRC_URI[sha256sum] = "cb001d4d94708dd824377d1ed546fe1fb51f0dad232376738ccc720216f6c560"
