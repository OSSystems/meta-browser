# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "052f3c4ad8cffab17834e6fa6b53bd3a"
SRC_URI[sha256sum] = "7b1aa61c4f02fa5470465a6915d3a410e77acf57d581119a5512d767d9fe3679"
