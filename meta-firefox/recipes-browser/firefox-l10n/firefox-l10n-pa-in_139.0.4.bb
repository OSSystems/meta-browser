# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a906a95517b1c96ced85232e79d26f36"
SRC_URI[sha256sum] = "d2bdc9be553b1d0a3f9bc71233dac0c092fb95ac436df3ead93898d8db6ae417"
