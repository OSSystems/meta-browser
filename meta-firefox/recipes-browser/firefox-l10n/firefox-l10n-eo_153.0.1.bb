# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e9b05bf8d7bed0c62e0ae6fb8c604c9488e3383298a26c90432ca48c539d96b0"
