# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a8bb2394b7ddb355700c1fd16dbd342c"
SRC_URI[sha256sum] = "521f9eae0d7cc5472b15ef1b99d6f06f32ca8507be1630e86d550a8aaf2bd52b"
