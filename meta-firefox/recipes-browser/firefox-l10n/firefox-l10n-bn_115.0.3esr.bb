# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dd24d0a4b7d2ca74de6bd003878b35aa"
SRC_URI[sha256sum] = "32a8ff5779bb83bc7817965c37c91987daee4108daa191f28bd5345eb642f8bd"
