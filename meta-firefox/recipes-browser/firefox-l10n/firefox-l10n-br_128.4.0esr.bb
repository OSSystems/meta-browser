# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d1bde54ec4252e85e17ef18d0afd50c1"
SRC_URI[sha256sum] = "56241717e9754d1b3ad50d12cbe5c79fda85b0a6d77c1adc4fc55c791498f76c"
