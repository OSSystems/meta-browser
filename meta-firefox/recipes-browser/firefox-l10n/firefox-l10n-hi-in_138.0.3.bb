# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2341dcedf755afc41a5a2b6596ab9833"
SRC_URI[sha256sum] = "b5fc7669d978df76d7ee3df17599cea11db5fee8fa8e5b06eb76a7e45727b079"
