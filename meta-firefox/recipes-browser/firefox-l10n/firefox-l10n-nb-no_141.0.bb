# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a25afb5179e9d840c196e2c405010f1a"
SRC_URI[sha256sum] = "538b29f559a7159d001c22fc542b16d1808f728939284228f558099fb4129730"
