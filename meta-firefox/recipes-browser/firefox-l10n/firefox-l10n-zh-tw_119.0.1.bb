# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f37865812ed9e08c0f9ad19a57a7e9bc"
SRC_URI[sha256sum] = "ec71f53c6f92392dfe90819cdc69fafc27a0ff234b01437b7df8ba57f57c7062"
