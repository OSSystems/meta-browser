# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "63705112e3623a3e1224d7d0d499f481"
SRC_URI[sha256sum] = "7b28f36c3f0f7ece89e4cd33235723c957893f975db15a4a37dcb41b3f7d347e"
