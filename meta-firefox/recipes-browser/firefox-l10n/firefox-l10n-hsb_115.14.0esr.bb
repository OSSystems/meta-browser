# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6087e2cf1d1673fde14c6efea7a9db9b"
SRC_URI[sha256sum] = "6bdac6d9f5127fef0f7c198460a4ee1b3943978d04a1327efb99844782eb77a5"
