# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "46fbd814fde7b76ee74eaf5584874ca8"
SRC_URI[sha256sum] = "351391d5dd4ee401c5971850c1ca3496f64e13db7174b7b8507297b6980fea81"
