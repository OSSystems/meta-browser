# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a7f119bea7b60c2ed77f08f05b600083"
SRC_URI[sha256sum] = "8de76bdfa6d9e4ccadadce314f04ec5c6191ef2c36fadca2c6c2e1eac4c339dc"
