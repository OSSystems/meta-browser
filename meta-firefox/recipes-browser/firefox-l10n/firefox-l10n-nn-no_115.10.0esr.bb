# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e89b548e1919e4ae6bf83e585a167826"
SRC_URI[sha256sum] = "d84187b0aacc290122c157579d2a94b18736cc038ad49e2d2e11db09474ad7c3"
