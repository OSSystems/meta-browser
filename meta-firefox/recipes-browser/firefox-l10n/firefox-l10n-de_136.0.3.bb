# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3d95477e06634bf9d51aa9aaf037b9ae"
SRC_URI[sha256sum] = "2d1c2f9253cb334996fb73cda5809328e05e96655c985a5b7dcffff3b41c832a"
