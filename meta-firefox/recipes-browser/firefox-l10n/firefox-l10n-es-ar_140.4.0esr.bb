# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "95a5d5a9b62a6f9b9971317c90eff327"
SRC_URI[sha256sum] = "783bc9c9798fb0c5cc80bd685a05ec1d63ea54fc26241a2579d47445c04762ea"
