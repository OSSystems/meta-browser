# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7d9679afb8a35c02ad1c4d4ed1326ed8"
SRC_URI[sha256sum] = "1f5d364601c82739b65132cdcf8f3a745f84fd03fb6b4447ff3ff083521f7912"
