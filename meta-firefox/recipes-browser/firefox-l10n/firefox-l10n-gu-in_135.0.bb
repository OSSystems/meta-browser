# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "07adce1d2cc196d77a09e50d138a3d36"
SRC_URI[sha256sum] = "61f66e25b682bf4b4ddc1c3337767984f088d1c3558651469417f2e6eb0a7669"
