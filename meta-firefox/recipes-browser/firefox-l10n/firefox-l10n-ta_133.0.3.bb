# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "34227b7c287c186f2375d24e8cfcb7d3"
SRC_URI[sha256sum] = "52622742e3d1d06971a589e36d2101b9dd460e6b8ad177c48e5c4fbbadd43b4f"
