# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2e223994b2f1778918b7fb4180a88519"
SRC_URI[sha256sum] = "5a0e8400be5c4dc61929b6b0e5d9f06f9f9b458d237c5039dbb1f4711930d69c"
