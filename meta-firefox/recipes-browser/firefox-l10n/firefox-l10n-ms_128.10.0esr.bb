# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7655317778d5e3dd45ca8146a9d9332f"
SRC_URI[sha256sum] = "b570a702f5c8a50827b4f75a0f79fc880f12a01017e72c3e6a54327fe8b3cd50"
