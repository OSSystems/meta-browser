# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ccf4a8bf26eb6ed58f4605624356886"
SRC_URI[sha256sum] = "7d67a25e8895733ad089e709ef3ee38c6ab00b32695f1e658d5c677402427421"
