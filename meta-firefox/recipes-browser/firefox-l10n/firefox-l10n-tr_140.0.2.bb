# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5094c5c5606c891042203a3ed2797d05"
SRC_URI[sha256sum] = "f765d8ff9d88207d6bc79af76bfd342450ab2421f4586176e985ef056bad5af3"
