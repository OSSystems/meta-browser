# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7ebde2740f64013c20c75fce0920a4d5"
SRC_URI[sha256sum] = "42fd20504d6a4ffcfac1deb1cceaf3f2d55cbaa387e903915f35d396d47b94ae"
