# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f349135369c9025308f549508314f7fb"
SRC_URI[sha256sum] = "f2b734e5f7a2d0a5b2005ac741f6b485199218fef91ef886cfbe873b1d167353"
