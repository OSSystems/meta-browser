# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7c62298ffe155c3ed202d909efb88179"
SRC_URI[sha256sum] = "ade636f6aa254b0867814977c2da5084b2b475fc6a1160cd82310a5309a5d352"
