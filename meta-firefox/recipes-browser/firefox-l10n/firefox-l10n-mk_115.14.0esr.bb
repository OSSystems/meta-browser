# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d4f72bd53bb58361f74879dc0bed1df8"
SRC_URI[sha256sum] = "dc035b2446a200daa8024f5a4f9a88e87082a7ca3ab6c2e2299b0a3633ee876d"
