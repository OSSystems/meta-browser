# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "53647f0d3ee951275fdd34569bfc9a75"
SRC_URI[sha256sum] = "c608c4dbbea4335b3e16ef82c3b1bab02dc80b98bed180d094efaf4a6705921a"
