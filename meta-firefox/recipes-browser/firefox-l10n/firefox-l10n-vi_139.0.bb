# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "097321a16aa1c483c9a21f9446714c29"
SRC_URI[sha256sum] = "3dece1e126d160bfd8bbe11cc3c17d95736f5ab4b22a46b7924ecf064326e1bb"
