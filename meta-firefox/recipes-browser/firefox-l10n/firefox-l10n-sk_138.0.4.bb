# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "79c224b02cd244c86e3b70549161b293"
SRC_URI[sha256sum] = "9ec27ede49011b472a4d978490fcfd51c5a6095eea2064d25e8cf800b1759e2a"
