# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "27e1d7bbdb72c847ab35bc0156bc3b95"
SRC_URI[sha256sum] = "e647c53853998dbc6286e7335d4b048eddd103176f3c73538fa4ed1cfd7e5b03"
