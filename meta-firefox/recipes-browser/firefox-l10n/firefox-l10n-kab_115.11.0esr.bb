# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c1e4d3bbaa71a16a608f1340d8b50cb2"
SRC_URI[sha256sum] = "5163f61ca993a2d24994cfe2462ee6ed3f3751c7054bd782cd5b25cc5e22b98d"
