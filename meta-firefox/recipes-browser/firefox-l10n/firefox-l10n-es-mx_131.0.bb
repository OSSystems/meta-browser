# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c7c980aa21592b3f956d988d59d72c07"
SRC_URI[sha256sum] = "c717dd48a85eb12b46d278b82f75906856c7d40f9a75d5acc39b9be482b64981"
