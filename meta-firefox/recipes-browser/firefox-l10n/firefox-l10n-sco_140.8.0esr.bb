# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "02141c00814e04baa635c0d2057140c0"
SRC_URI[sha256sum] = "7b38bc7a15d530da53be71f077913bc542e2f4e1c06e38ad2bef573c3e3420c8"
