# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a2a1b95a5a18c64f2f4aaf6016f72db9"
SRC_URI[sha256sum] = "240597723929fa7a468ac5867c1cb648c3a24f83698fabbb48592de2bc46cd02"
