# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "acadba5e6de922728b72a88fc0b0fa31"
SRC_URI[sha256sum] = "444af7ec8db1e12a763a9ce1ec17c16a2ce9dcb062df580d9f27e0a822211485"
