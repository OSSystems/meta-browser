# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c00eb0c04a027318ac1b840c44eff4c9"
SRC_URI[sha256sum] = "3c59bc442ad19f089bd68f87a52c6c18e5c06674cf8ab0f56cc52257b06f8f4a"
