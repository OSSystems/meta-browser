# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1439e20885399fe011d277728031de7a"
SRC_URI[sha256sum] = "1be576b609fcb273646ec0d4615203f1b8de2da0621cb477cc93323fcfbbd363"
