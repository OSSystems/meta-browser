# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7388b6c42da1daa8bf4d30f91f33fec0"
SRC_URI[sha256sum] = "5c59d33d9f10d01eaf2907076f8a9b0f2c6b7016b0618f77e9d71c6963cacd16"
