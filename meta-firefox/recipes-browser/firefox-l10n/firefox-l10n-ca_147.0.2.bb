# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c1fa7d598af61e7717619a22b44124a0"
SRC_URI[sha256sum] = "54d117469d13f6bf657892e5457b2e1b781ef2291a2d1631200ae4ce3e440fbb"
