# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8ac50b5eaf716efaa1649b637956d0a0"
SRC_URI[sha256sum] = "6f97b077a5e0b3e83894e1247a4db87422f44f1eb4444ec0e5658a1ca636a822"
