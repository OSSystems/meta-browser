# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "509989b92cfb10429f929b8761cfba72"
SRC_URI[sha256sum] = "f3003b312ad7c4855bc5f22f5b505ff9c9b2bd1887166362beeedfbacdc90e0b"
