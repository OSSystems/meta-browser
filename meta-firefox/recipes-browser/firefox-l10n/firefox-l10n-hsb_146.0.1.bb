# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b816c9e73f764e587c719a371b3e2d04"
SRC_URI[sha256sum] = "b3d94ec387733d5ba5788f8525add15f725682c1237ded6eda55c33f9afc7c35"
