# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f6553ae7a5bcef3f16b36d36fd8a53fd"
SRC_URI[sha256sum] = "2a125d217403a1a23e3051bfdb10c5126c10715a1eb46b746ea5a27c32130363"
