# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "716ec25b3483ccc7bbf795623bb7d9263981474e9ab77248bba89f6670257d80"
