# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2779a1862210b3061e21b24b98e88b07"
SRC_URI[sha256sum] = "3acafd0fde75d1981bc13b4f6811a1af34dee466bac7e59edd1e0add84f1bce8"
