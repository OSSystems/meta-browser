# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b2ec9bbbbbff0fcf50df4856bc0336b8"
SRC_URI[sha256sum] = "728bcedeca15da989a3625bc929233973ca44a4ee895eeb51b0b5612cddc07fd"
