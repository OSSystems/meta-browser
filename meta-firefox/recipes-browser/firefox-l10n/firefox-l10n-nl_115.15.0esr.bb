# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "607ce165a018e37f177c0fc4c25c8d8d"
SRC_URI[sha256sum] = "24d049614cb34ddc16cb1349d995967af9a9384ddefb207cf8be8b17761cb9ac"
