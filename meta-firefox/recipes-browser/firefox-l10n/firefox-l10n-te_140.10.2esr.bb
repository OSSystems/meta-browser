# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "72b229daa03703e12d46462d7b079299ccf96e72f3c57d1c690a8ba14cda38fc"
