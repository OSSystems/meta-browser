# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "befe6569653b05d520fa523e86271118"
SRC_URI[sha256sum] = "91092b87d1d59516cb91e3dbed0dcd54a8e8ee2f48e8aa7e075b9f5b2175f14d"
