# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1d94532e7eb8c0cd7add1663aae605d0"
SRC_URI[sha256sum] = "0980cc9ea6b1d54177896e0a74197056a560a5c933dcc32ce3bb8bc5baa05640"
