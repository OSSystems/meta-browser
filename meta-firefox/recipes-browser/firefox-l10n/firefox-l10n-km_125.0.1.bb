# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8f71998f13ca66531f4f008552e371be"
SRC_URI[sha256sum] = "8028094096cc6bf4abb28ecda19e5bee8ac4e7ce0791318b285384cc3ae249c5"
