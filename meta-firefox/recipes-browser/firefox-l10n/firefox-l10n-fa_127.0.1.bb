# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "434e2dbfcd057eb2725dd06757cd2b5e"
SRC_URI[sha256sum] = "bfc78b5453fbcb1530884bedb75fd1fbf57fb26f14ec5a8a0ec81b3b17669be3"
