# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e1a1a4083018890c40dc28835e8dfd50"
SRC_URI[sha256sum] = "ba37553e645823095bb81213f8c71bb7898963e234a80da0e975290f3259796b"
