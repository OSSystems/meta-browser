# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bf94c5cb4b03ce950369570cb1bb3759"
SRC_URI[sha256sum] = "ee8a0f01bd6006a6270a41bcdaff15cbbf25b9a0c235a87e356b40e4ef99aeab"
