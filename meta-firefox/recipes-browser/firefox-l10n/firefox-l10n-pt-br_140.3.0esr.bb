# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a69a7e65d7d064f0f74fabeb0d6a37da"
SRC_URI[sha256sum] = "b62ef8d4330d7d94a6a739200879e9796ea335d9b3d88cb17dfc659be55661d0"
