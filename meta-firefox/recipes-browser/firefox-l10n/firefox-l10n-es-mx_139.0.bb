# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ce89b698df5e5bcb35cc66dfd266f3a1"
SRC_URI[sha256sum] = "db2f1bc99acbd98c57f804e2594c437626ab184c82e8c5864c7ddc241ea23439"
