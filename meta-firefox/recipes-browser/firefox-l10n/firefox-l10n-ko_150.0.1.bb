# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "1fdc6e48e64622150e86e907e68107f1b7b14119fc1faf32dda7301f2a262aae"
