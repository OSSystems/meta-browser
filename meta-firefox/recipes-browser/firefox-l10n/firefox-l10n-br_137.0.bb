# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4f4a6b5d0926233c95a60f4d6af16ded"
SRC_URI[sha256sum] = "0715b53e4392edcc813adca1482e81e4ff3074b022017e5ce8fbc7110b9c23e7"
