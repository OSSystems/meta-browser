# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6cc68e5529fa20cef09ff40e3c51989d"
SRC_URI[sha256sum] = "0e1bcc77920d1fa449eff73552d99341e4fe37aeee19a4bfd3189b41706f49f9"
