# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1a9ce3415fa40e0d859a629179d8a15f"
SRC_URI[sha256sum] = "37586a0123c65f0252aad754a8b3a7bc65e9036f4eb6591e9af4a18338a59885"
