# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6296c506a439402ad1f59e14da02b7f6"
SRC_URI[sha256sum] = "79af8afc369d69fe716a94f928809ae3180148cc557467834d392364e56e7bf1"
