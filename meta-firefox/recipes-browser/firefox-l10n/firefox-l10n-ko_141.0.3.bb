# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "127c6b0f5541b0a69f0340f4d50c8606"
SRC_URI[sha256sum] = "854ab04fc03edc622d30724e143546b77f77871d20c6d9e90a7e3ded220b9159"
