# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0a3bfb075f96edf61c887a97fac3dd24"
SRC_URI[sha256sum] = "1296a5cb64f5527b1ec399834c849463d09edfa3b8a7f1d16a91653eba0e85a7"
