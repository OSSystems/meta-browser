# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a150d51cd06b331dff802a16b1690cc0"
SRC_URI[sha256sum] = "01ee0aff3149ad51fae2f7a22564ed5703a1d49666370325b3bc770c8badca3e"
