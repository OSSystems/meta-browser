# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7742761741814a500ee7905b3e479a7d"
SRC_URI[sha256sum] = "4a1d85a263f0df3ddd61eb0b435bdbf6170648a276f55e28dfda2dc0e2876dd1"
