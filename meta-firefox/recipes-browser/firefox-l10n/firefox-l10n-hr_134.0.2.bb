# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "56e0b865c594de50ef5d854498b5b640"
SRC_URI[sha256sum] = "f44c6f5a0e8d2a1bc14e56cdf335d9ebca388cac322be6ae34f3e8c065e39e9f"
