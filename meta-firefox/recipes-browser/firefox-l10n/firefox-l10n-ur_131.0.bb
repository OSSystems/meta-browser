# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c75ed15d71a51c3e4d1f46d3b12b58c0"
SRC_URI[sha256sum] = "3f581c7e434f2a015cbd70f5fa291e5c0a473c3049910ad4846d7023c32bc2dc"
