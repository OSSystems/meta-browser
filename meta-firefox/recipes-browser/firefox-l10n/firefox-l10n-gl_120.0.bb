# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2b6774b7ee4f0ca79b0803760cf131a7"
SRC_URI[sha256sum] = "bacbdf00eb25dd6cced57b72cbbaaacac2e8aa15804fa2fac39e164b38bbde6b"
