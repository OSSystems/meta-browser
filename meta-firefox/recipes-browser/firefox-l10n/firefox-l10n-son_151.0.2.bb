# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ea985883b7b5a95fb7fd3ec7cb53ea4e7528b704f751e3f18ca3008caed0b252"
