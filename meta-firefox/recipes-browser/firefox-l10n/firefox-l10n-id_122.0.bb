# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "344f6828c98d88521090fa80ab78bff6"
SRC_URI[sha256sum] = "4f925e77b29e48504d132b04bd97e12b01bbfa0bd587fb7349a8d002135454b2"
