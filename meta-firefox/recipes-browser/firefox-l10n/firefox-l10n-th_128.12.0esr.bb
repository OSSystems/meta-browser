# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bf0316faeb7dca796af0ff870b4f89b4"
SRC_URI[sha256sum] = "2a5b14796f96222c9e4196162598e7e3c5c46a8d13df80171f4ee6558a979667"
