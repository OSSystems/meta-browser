# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fd57e84e2fdb9c13ef53caa8037bef71"
SRC_URI[sha256sum] = "5fd297f351c67f014972c5ba2b58a31e1674964bf77e6d50feb993c47c9ee446"
