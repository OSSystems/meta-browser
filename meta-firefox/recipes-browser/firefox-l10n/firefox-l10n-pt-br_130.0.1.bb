# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1e2574fa46b9b387d1ee08262bf96808"
SRC_URI[sha256sum] = "6500affbdef6d5f10dee7250c2593a2400b9db6ec30d9c8f2aef9d499447d1c2"
