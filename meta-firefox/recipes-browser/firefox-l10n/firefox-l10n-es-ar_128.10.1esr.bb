# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2f6d6391d11fd617bd596cb000c34d4d"
SRC_URI[sha256sum] = "62f3f6c01668d472b18c0ed25e8116e7f5101550cd6d500c1cfb8d1317a14b5f"
