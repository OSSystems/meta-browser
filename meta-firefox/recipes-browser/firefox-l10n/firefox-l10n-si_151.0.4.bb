# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c66bdef33b88a9ebf81d60aec113697350c861aea2c176388cbb7e1d54896f8f"
