# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8439d60a8d8c0f287952fe9d050c7f35"
SRC_URI[sha256sum] = "f721d3cc6108b64be075264013015f15ff534e8c5ac26c1e07b057f087d0cc36"
