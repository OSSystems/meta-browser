# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "6213234778a0ce3d047a63294d03b063d6874508f6ad547f3ee9c6efeea9bd29"
