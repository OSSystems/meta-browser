# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a9d84ef802676082f0452fe94f42eccf"
SRC_URI[sha256sum] = "3c59ec8665a09ab80729d0d9b25b3472d70b240b09a7fc5a22b7988e59aa45a2"
