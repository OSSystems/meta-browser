# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d870a01cdbd016202882aae8376c703d"
SRC_URI[sha256sum] = "30e3f358c8f601a645ac252471336993d2487b20333e5aec14cde5566494f4ea"
