# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c0980a015e8a946d17fb4e7969252329"
SRC_URI[sha256sum] = "26142e498317a411b6e19be66d41fa6c5bc38ef0ac2db5dee44565e2eba3fba4"
