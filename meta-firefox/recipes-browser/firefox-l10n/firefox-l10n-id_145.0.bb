# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5b6b10328968eeb8166c7d480fb9e889"
SRC_URI[sha256sum] = "64bb36737421fcfb773f8305602e0d8b7a4d469506bd11d0c12974b10c4b31de"
