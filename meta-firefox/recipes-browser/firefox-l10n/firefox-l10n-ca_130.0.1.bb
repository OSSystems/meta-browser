# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0b37d74db133cd2781b1d1e376785f43"
SRC_URI[sha256sum] = "ac22e9a8bd9a15dbd91ae02b458ffaa61fb565318e6a3fd6c9d60fabe792f550"
