# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0ce762cafca563a15d4e88ee5f8ac6e9"
SRC_URI[sha256sum] = "4f814b6fbd588abe89b9fec0054e77ee3c5414745170de90f6010749a0991f1e"
