# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c9ad25a880a843c905758e4d46afce6c"
SRC_URI[sha256sum] = "9703fb03245de4ecc9eb721ca52b4bac882f9d50b7a1f43449be0404f943f467"
