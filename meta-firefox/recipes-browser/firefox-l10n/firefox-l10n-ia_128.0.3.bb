# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9fb9b705b78d5f6a076f18e55e73eb00"
SRC_URI[sha256sum] = "832d363e53c3ffc5f16b2461a6371de664bfdfb8015bffc2c80b36ec3a7268b9"
