# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f7090b1eedaad64da5090f674941c8e9"
SRC_URI[sha256sum] = "36429a9577339779ae798d9df7d1068893c35b7120b7d784f6a0b52dcabdc208"
