# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "83740e2af63c609330d395adf8d0ee28"
SRC_URI[sha256sum] = "00e91d146188542fe59bec7ed8eceded048760296278b0009f8af3c5a45b2711"
