# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "72b89e623abf2a5738bf66f8e5448851"
SRC_URI[sha256sum] = "a426463a42af6680bf931ce7ae3bd530c9905e4d324ecf03fc1dbff752aacb2d"
