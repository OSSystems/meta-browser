# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "28ad59d9a5f62b080d29629209ea28a0"
SRC_URI[sha256sum] = "e9a134b0f78850818907572be92b5b6c6d19f38caeeefd2dc305d3467a375c3f"
