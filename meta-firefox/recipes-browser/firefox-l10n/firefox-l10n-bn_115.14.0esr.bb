# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "71646507222ff4703e0ea21dd3870101"
SRC_URI[sha256sum] = "83cba962bb57a0dd67ea87867d546d899c8b51bb4402b90537a18b1a544c8437"
