# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9530d5a120bfb10256f7af66a43ab873"
SRC_URI[sha256sum] = "ea2f4f06781083ff9095519a34b7cbf679942903e46860a66a28f0a83888aec7"
