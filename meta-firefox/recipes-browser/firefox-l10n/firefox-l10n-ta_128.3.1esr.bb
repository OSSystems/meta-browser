# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7bed524c4340b8b50f2bc10eff001a4a"
SRC_URI[sha256sum] = "4e5f5605bf09c24000dec976d178ab09447f4a0328e4e8107678afd55481f832"
