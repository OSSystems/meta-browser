# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "4da71e7c3525ab5afc8fe7732d98f9558103c74e7de42a48e18f51d5af4b1c8b"
