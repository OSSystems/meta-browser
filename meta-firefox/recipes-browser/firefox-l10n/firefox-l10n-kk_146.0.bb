# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "573cd50c39bdc3a19a5a6d7463ffd517"
SRC_URI[sha256sum] = "7595326c59e07e5c5ecfd6a5ac2c0d4e4a46a85d1e3922771fba11541544474b"
