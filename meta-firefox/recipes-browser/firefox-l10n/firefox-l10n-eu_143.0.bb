# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "692fe9fd5c7c2130aaf8901e28f23dab"
SRC_URI[sha256sum] = "0bc7da5992ef772f6a66c4c7322a2b4c56490be637d64e2ae0d10b722f4dc1c1"
