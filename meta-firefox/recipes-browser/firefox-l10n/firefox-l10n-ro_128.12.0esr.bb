# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5589548c8a9cf849c3132d41c7eed765"
SRC_URI[sha256sum] = "a3269de55873493bd933022e7dcc7230c7f290986e801a88d7865745d67bd55f"
