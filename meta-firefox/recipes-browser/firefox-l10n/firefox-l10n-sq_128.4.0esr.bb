# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "afe60a1afcb3a9f91da9e6cf8f15f48f"
SRC_URI[sha256sum] = "33721ed310a26160943a3b2fbd0192059b52fca94e73225c4177f9d5dd1c9561"
