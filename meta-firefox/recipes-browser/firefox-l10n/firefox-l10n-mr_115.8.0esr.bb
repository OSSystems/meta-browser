# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2231702d5395c3e740cf45bcd3504a8d"
SRC_URI[sha256sum] = "610c260b575dc7404a2c4d4cbdb7667419f97dcb4c6aa409d70474c28ecced7d"
