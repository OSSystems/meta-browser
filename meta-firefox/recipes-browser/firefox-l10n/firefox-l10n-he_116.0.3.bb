# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b918d086ee63a902571d6f21c781ea90"
SRC_URI[sha256sum] = "2c8ff20a3446b37cc1167550741047076f03c307cdba66d5eff77b5523fd4a34"
