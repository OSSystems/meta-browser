# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "a0d9bf15b6821b1c115f8fb710ca8996b86277bdd92c6808c16f15819fedb2ed"
