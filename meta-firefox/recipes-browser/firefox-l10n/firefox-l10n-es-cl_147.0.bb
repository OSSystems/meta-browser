# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "622dded158b5c1c5b14ec0d201f71378"
SRC_URI[sha256sum] = "d4c1917b1351e36d2aea34fe2206f8a77d67efc5bb282097c61c1bab0576a046"
