# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3cd6defc55734b68c312b214e90b2ae3"
SRC_URI[sha256sum] = "1a332d041f6330379f2b7c77fc7481979bee77b846fe22f1f99fd26888638d3e"
