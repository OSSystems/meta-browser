# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2d135ca1ea9430f9e340bb0bca5dcbf3"
SRC_URI[sha256sum] = "a988ecc1e38e8321669f99b895a1b22198414f754aba7c8feffaa064cc1eb71c"
