# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7e5336a8dfbc28c8e3246936d3633c1ad11b85d321f9583eccb8abee7ca655cc"
