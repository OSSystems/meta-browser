# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "04975b84f0d54c83d2efe264cf8efc5b"
SRC_URI[sha256sum] = "d4160d10bae9aa3a448d5ba6111d0d73791329e7e4b0f969ceb9ad363c93a074"
