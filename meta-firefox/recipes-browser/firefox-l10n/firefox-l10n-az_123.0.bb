# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9cf7eb658d4ff9a0d9691ac46a1c1e5c"
SRC_URI[sha256sum] = "9c8bc2cda53723a8b3b5439b8b9271aa00aa985f3ae76b27f21149953ef1f734"
