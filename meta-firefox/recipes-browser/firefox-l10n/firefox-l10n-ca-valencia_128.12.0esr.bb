# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "99bb5e5b52380a84402cf80a0e46148a"
SRC_URI[sha256sum] = "6c57787e2e3f6cca8337245b1138cd5bf89d5d436dfe9fc71d93485ede947947"
