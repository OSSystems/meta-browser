# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "307f0ef836528dfb03006ae3b048ba8e"
SRC_URI[sha256sum] = "aee3baeabe4d719d1f97cc0eab8e3fac8f8567df2eed149b61546d31c334a738"
