# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b10d04dece783ec35f63706f0f8559f2"
SRC_URI[sha256sum] = "6378eb4bf7af44f78dbc587520e08901f63afa940a14d9e4c4c6a21dd0bcba80"
