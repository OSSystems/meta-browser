# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b92d78dea4ea72682017b181d7784ee0"
SRC_URI[sha256sum] = "49c682abe1f9c7b05722b46aae5ae2d9fab106da883d14517c56a650ba8af629"
