# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3ce5ce17cb0ac82ef44bcf905e2e7af5"
SRC_URI[sha256sum] = "70f2f79affc2852c551620a009bbe86049783d788bceb5d5eefa2db27c295e14"
