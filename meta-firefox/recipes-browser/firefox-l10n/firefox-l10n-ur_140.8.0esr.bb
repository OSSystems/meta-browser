# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a8ca86c55e977179de89fe74c07da09c"
SRC_URI[sha256sum] = "f53dd5bbe7eec00bc31f318659bf4a7178491e9eddd6f3f5f6af15e7d313d999"
