# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9d6857fc287fe5582251520c94b9dbca"
SRC_URI[sha256sum] = "47c9916f99e3d91111c64a49f49a0566d241a6019425f2556d47257df23ef027"
