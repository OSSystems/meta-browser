# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ff5ca6d7e3a42b3ed9660ef62958923b"
SRC_URI[sha256sum] = "30e4e6fac23cceecfa07ea44171a67ed9157824c69b4b85588d457b29a0442e0"
