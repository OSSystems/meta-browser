# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d42c07ed781ae1b4407fbb30c33d51f8"
SRC_URI[sha256sum] = "42ec68b77bf4b3163c16ee7935659aec4f37d40f49b6d8db9c29a0b169781b0a"
