# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b0fed9d28490358139dfc3b715d8d086"
SRC_URI[sha256sum] = "e989afd767a055d77f5d76a9ccb07fcdbb4326f094a4dd629e847598bfdf034d"
