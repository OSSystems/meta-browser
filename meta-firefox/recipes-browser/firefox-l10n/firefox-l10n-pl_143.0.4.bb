# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b5aa7a962b43530b8822697203f1df09"
SRC_URI[sha256sum] = "6f4be05d3bc0c23cfd6a13b8e384a261aa469763d1f67003148cf3c914a60f6a"
