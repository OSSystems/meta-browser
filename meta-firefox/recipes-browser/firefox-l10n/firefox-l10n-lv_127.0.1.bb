# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0847ded0b00293fc54b4fc367e57d312"
SRC_URI[sha256sum] = "cac233bb8e7ca0e0f5fca8777a75cc35db5591890ad0d7d07a8e72831c151b07"
