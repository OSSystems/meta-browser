# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e3f18f1b7d2a087b5b3aa3f6a6faa07b"
SRC_URI[sha256sum] = "a1f54cdf9ee6398c4c05a7c3a4ecc86a0b2f7cf64fa5705184b30203e5763f40"
