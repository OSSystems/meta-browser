# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7807843459d380cf41c37596e9d69a49"
SRC_URI[sha256sum] = "59ed2288594a58210904bb07f157287c8aed21f78955dc3dca958d5f4a28e327"
