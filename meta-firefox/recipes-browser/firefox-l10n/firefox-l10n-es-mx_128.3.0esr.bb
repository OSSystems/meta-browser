# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "32a6a41f30950e21567d3c9d8d1f1515"
SRC_URI[sha256sum] = "1205b85de158c98f3526b81ff9b483d53dc89c282c819426e898ddfd367d755c"
