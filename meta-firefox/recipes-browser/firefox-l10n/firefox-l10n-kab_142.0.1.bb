# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9e64cd8f70d85594123d720cec4988b5"
SRC_URI[sha256sum] = "2cf6a7ad9ad365eba9f62bb5ab7f88c27460ac9b8476234484133af02726adab"
