# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b54c03449faae465239d3a13e01562dd"
SRC_URI[sha256sum] = "8a40539e9e2cbe32952454ca8437f3b673587dda02113e270fc42c5717cf2480"
