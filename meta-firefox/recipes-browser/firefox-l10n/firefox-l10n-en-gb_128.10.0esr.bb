# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4de7af2e7ddf70338b699a51dcba04aa"
SRC_URI[sha256sum] = "7630d6afe414808125b527b9305b41c5b68451d21bfd91b3d5ddec4b5aa9d3f0"
