# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "66dce49558a4779de6e799dcbf88cd3a"
SRC_URI[sha256sum] = "e493d7583939fc2f823966ece0136f3c15d5bb528053f8c727ecc7966675cb05"
