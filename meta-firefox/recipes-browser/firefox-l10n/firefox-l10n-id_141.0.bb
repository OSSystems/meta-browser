# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c50f9fa2f5a24b8a3a07b5c2990741e3"
SRC_URI[sha256sum] = "1009e5f2413fb31b2388a0d13ac33bc6817e32ba7ebc4ee17c57ef5785e88c5b"
