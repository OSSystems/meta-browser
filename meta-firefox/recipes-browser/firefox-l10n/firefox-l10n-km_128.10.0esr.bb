# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5fc3963968fa795980bb5a203b22b52e"
SRC_URI[sha256sum] = "35d3a8f1028c455ccedb307bd4189701fd5a8031fda5724bd01a661be5b68da4"
