# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b3a3aa63c495a15c15862ea532605884"
SRC_URI[sha256sum] = "64650a3c006a0c0123840075b84757d97e630609105019c6e30ffcad95db1029"
