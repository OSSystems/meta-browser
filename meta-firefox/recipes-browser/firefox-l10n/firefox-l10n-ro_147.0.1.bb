# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "256babb62ea61095e027528bf733e6e3"
SRC_URI[sha256sum] = "748672dda07560e0848ca7bce7cb5c36650795df0882c439d899fd02b3d23bc3"
