# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "831767dad7da6dd9aa510869cd53974d"
SRC_URI[sha256sum] = "1f21e823667be3ce619a6ce8f3a28389470dfb0565f7c6da35a2b77ebdfb6adf"
