# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5dfeed728cd7af9a1a6fda189230ad0e"
SRC_URI[sha256sum] = "26f5b9f3f7d2f1a6b887818e49f5e7ed6c10d93699595c6dddc1ab1a76793893"
