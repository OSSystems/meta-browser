# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c4521a2a03fd458c3a6aa132758faa0d"
SRC_URI[sha256sum] = "991bc5d918da908372a7d34d3c76597b13b006162af14ed77a94ad076a967e27"
