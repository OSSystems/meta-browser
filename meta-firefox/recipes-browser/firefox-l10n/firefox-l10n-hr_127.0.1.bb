# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c35400972e680be2ffc1f6116d29213d"
SRC_URI[sha256sum] = "4cc799012b53e2b414c85057031d0dbfaa134b78fdc942ff414ea1f6b5603557"
