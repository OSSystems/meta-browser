# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "48a7f08b89f4f6283977af629c659916957be31544f1a879158b7d9d5d273dac"
