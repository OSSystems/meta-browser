# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fcd52caf41565215a41920229478d716"
SRC_URI[sha256sum] = "ce363704e871456eda4ee6391b841855f9f511820274d387647fcd5ce396370f"
