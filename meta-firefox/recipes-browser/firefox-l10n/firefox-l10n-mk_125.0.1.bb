# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4d5c1586c5bc270790d847040031a5c8"
SRC_URI[sha256sum] = "f5291d2235dee677b4a6cba77254611d4687381bdd6da73a3ffbcf5ffcd9b8f8"
