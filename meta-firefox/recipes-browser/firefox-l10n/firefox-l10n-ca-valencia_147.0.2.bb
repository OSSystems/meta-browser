# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dcb779063039d579b4fd4eb107b41f6c"
SRC_URI[sha256sum] = "9b80a82d42353026d967560dcb8c6c39d43b1a661681f6305d5910c487acd71f"
