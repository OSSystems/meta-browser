# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e3727be0050db821998154f015f78bf4"
SRC_URI[sha256sum] = "e848cf3a138f18175b16c0f42c20e75ac74fbf42eb1945dd1260384d429deb96"
