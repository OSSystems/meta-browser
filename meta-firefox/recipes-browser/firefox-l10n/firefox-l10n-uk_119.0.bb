# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "27b137491ef70715c0a57db10892ae08"
SRC_URI[sha256sum] = "5132ea73f6c716377acd9528fe604a66326af082ca26da66351832f45bd5d114"
