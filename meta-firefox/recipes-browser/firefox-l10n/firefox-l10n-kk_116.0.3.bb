# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2c6ba8b45c921b3406dd02555ab5ba7b"
SRC_URI[sha256sum] = "2be08ebf6b9d0f17e8daf291905ee705857aaf351fc87c0b101bb2493afaba4c"
