# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6562b764fa8c23e965de7f05f3328434"
SRC_URI[sha256sum] = "9bb228823771dd44c9551a4cb54ff8d56b34db628640fcd02a3dd73e608b17f2"
