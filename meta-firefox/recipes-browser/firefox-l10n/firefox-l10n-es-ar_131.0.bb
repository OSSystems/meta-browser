# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6c202ac4c2b9b895524098368df4214d"
SRC_URI[sha256sum] = "80a3b7a7757656fbb818bece48b9bcb8f210c1c6a9eff0a37409ed5cb66be1c7"
