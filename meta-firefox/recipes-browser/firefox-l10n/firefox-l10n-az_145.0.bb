# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dcbd237ff60b192c8ab188b0dc24498c"
SRC_URI[sha256sum] = "484e04069f84e638a88ad3eaec15428b6008ffc7750a3146ed131734969e9dc3"
