# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5d55a1534ef243237c79b0be0fb5a6da"
SRC_URI[sha256sum] = "5e3cc64dbe8d5fafc1232562bdab44c3d6cfd093e7333483cb8ad3ea0f99655c"
