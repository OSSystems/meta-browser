# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7f8b7f279dae60f687ca0ad5be833847"
SRC_URI[sha256sum] = "a75100e9f4e11e17d41f20b4db39cc7e1f79d2e117e6255b07198d103bda98be"
