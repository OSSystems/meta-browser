# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "44d3beceee6fba379cd3cb0faa4338a9116290e2bee8dc4160024b4b92441abf"
