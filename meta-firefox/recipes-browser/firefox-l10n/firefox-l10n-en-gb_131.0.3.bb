# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ad7b7eba4ee66f582522cccc71811774"
SRC_URI[sha256sum] = "b4e60464b3cd681a4c6d922bfa42c8c86fe0e5d6ae640267ab762f4f21c08aef"
