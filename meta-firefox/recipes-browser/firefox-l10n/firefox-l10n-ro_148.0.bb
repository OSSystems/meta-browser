# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "16987c85e15db1dbf201d98f7e1b3f1e"
SRC_URI[sha256sum] = "db64ba466cadfaccc69d730e51d674f932b89b11d6776aca363f12536147d093"
