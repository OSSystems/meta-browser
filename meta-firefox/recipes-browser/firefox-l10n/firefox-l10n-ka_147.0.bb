# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eb457f29f7596ad290b8a22bf419ba90"
SRC_URI[sha256sum] = "e90dff37228024231ab10104ddc0766ca443c10c1d28394f3512d0c772caa502"
