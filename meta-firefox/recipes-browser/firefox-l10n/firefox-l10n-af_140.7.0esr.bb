# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9255b6715f9102de7c93948fc0283412"
SRC_URI[sha256sum] = "c68f5bef6fdf00c133017ed9cdea9db0389452deb418677486faca30183f65c4"
