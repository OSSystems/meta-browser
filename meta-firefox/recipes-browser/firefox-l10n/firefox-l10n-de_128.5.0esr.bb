# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9171da704eb8d2efb353c6a13e738f2b"
SRC_URI[sha256sum] = "9fdbc3330661561de730968a68745d4be5c77d6df33b8e0ce6998969e334ca61"
