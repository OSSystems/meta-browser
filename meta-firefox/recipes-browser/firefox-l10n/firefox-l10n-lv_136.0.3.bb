# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c51565e5aaf073abb18af6097560f45f"
SRC_URI[sha256sum] = "c29cf968c4481003f48f503058f93681ff611da45e0899d70ae758a9c7c2c6fb"
