# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d8208f440c7f90e3296b4a80691cb11a"
SRC_URI[sha256sum] = "6f6efe2d7109fdf4815206d49d55d4b7c6c94d5508861f22674bd56bdb88d4dc"
