# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7b26dac81b2712fe0be84b4bb8001865"
SRC_URI[sha256sum] = "411a9d66c02fe45c9e7393bbfd778a28a7026c985328b61092031e227f64b9f9"
