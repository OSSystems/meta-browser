# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7b22d42bd2fed6f80b04428fdbf4a1e7"
SRC_URI[sha256sum] = "f4806858e2c577331c6d2387c3b1f7c35e3f4f207183b10a8531b44bc2ce81fb"
