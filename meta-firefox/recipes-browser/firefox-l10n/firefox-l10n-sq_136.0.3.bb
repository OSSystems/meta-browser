# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eb09d9c2776f2b11d565de05b8ed0629"
SRC_URI[sha256sum] = "6352f427f80eb6227f9c2772d808802018066d7f3bc09c0e25bd4090b963486d"
