# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e7d31528f2174ade093e52bb1a34e3d3"
SRC_URI[sha256sum] = "65362416fc721c3849c6712e89bf0c3ceff400acc887fd29b82d4d6fb15ff3e5"
