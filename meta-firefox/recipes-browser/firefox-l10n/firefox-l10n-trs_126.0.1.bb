# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5fb4333b5bd11c3ef7d9a02739f97d6f"
SRC_URI[sha256sum] = "374750a61b7284c4e89c093caa71fdee88775d60a0c49ae01300428335dee52e"
