# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d01aec1eca4f8f82658f288384c251ea"
SRC_URI[sha256sum] = "549a82081ae7a7221bf6933c71af7c794cf706279a40a3571f8ac3d8d9c18dac"
