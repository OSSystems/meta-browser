# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3612d6e3aa797e1e4670533547db430dea50458673c80f21b7789cb6fe3424ed"
