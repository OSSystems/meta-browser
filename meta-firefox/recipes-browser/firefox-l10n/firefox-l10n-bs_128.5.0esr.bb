# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0ff421a803c46407d849714a049800c5"
SRC_URI[sha256sum] = "08513b2b808b41ef046eade4a3c701011f0473190d7b91e802c751f8c888704f"
