# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a0dda8a3d5bd1b59fc2e1d89ef6d2ebd"
SRC_URI[sha256sum] = "dc69c8035233f800c62bc98ccfd7df52d3c95397853ffd861be419be1031d1a6"
