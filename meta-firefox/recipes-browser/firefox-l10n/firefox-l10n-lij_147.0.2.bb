# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c1281600bf17edcb07836f1109eab012"
SRC_URI[sha256sum] = "d6aba207a30c8878dcc5b62e899df8b1f817996d4072fce4e80cb0715b516fc5"
