# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "20774b8d74fb3edd5263c2418254405a"
SRC_URI[sha256sum] = "f40f8c7ef2f06a839e1c78ca2e8c6b4e47fbf55accded0100f6ad174943dead5"
