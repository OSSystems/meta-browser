# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4681754a7784448f9996dbc41eb17293"
SRC_URI[sha256sum] = "e82d2b3d9d4c425c578ae3d4cf641d04fe86c6419bb2f0c4e803286de45bf454"
