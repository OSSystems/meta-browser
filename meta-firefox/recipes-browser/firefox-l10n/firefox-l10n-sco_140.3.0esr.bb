# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "12199c7375de3b86f7f543296d7ad10e"
SRC_URI[sha256sum] = "c6a19dabd2b04f6f38db6076a9507410321feb635523cbd8a90a8dac06d53f92"
