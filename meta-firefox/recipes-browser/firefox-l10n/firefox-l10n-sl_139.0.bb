# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2b43e90e71d51310d99cafd0652133ba"
SRC_URI[sha256sum] = "20755cdb8b47d0e8fb9031134d4fd4085a5317d5964a459458c9f8172a3cd10f"
