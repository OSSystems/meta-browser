# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3b5689a46f8398b449da572e26cc2819"
SRC_URI[sha256sum] = "0bba6d2472aa5ffe8e5aca55fd2a1f77f2fb8ac311231cf47c964d682718bb36"
