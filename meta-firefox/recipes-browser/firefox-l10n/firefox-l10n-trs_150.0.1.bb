# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "dca87b257804c834faba6525069684be2933baaabbf23e74c480998ba8aa486c"
