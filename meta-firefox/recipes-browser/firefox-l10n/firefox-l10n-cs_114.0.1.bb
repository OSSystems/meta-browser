# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9dfe81d12b519e8be030fdc84777fbf9"
SRC_URI[sha256sum] = "5b29708a06571ad6e93f1a05d18d1f4b3443a03e009082de4f4d19b7abd74e54"
