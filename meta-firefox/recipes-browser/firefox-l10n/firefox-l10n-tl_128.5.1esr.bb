# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "203ff28d03a93cc5ee8d2f71e415bd37"
SRC_URI[sha256sum] = "5e76afa736a4ef61321d305e530e4a1b1664d27e94cfcdd32d391b0950489cfb"
