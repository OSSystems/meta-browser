# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bad7be0b31ec54ebf702f87c93a2b9f5"
SRC_URI[sha256sum] = "808ef398337f52c82f0c5a5b95f7872323b7773cda7584c13e498995388c2a28"
