# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5815b5e43c13eb84695b44a7271867b6"
SRC_URI[sha256sum] = "f0cb5857facbd64d71ddcbef85d4a74c61bb15f19fbf07590de7619a7bcbaef9"
