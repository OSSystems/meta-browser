# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ab9eec6550de60c0b3930196334bb0ae"
SRC_URI[sha256sum] = "1f7e2fa83929662fd1e2b770e3d9ec7841c282e8c834e8a8062996de9ecc7f6e"
