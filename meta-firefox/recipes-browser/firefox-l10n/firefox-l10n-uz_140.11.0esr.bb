# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "87262a875ba5609fa6f31b0add723ca5e7419308b3ecbd99ffae25d9ad01d746"
