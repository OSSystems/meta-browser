# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2d445a20553600a4eb88fe50f8b2e436"
SRC_URI[sha256sum] = "ff7377c16bd46dfc7a90ce09651957548a8dbade149a9e00bd058f501a7e8624"
