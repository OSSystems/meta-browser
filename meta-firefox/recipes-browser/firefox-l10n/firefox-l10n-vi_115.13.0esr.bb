# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "04ffa82326107b96578f5b9c5005077a"
SRC_URI[sha256sum] = "126662e9a30e14197a8aedb038603a523a120ce0d0cf1b247e1963210d760c24"
