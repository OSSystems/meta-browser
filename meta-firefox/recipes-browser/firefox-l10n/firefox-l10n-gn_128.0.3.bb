# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2e28662db5f205f47afde1b26215362c"
SRC_URI[sha256sum] = "aee846a8c2f31c4f850393b0aa67e6fe62fc431068a859d8149903fca4e7dd2f"
