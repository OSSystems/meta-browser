# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f3bc83f92f9dbc098cb5b2a7a1e81189"
SRC_URI[sha256sum] = "87736a459ff2bde4d456f05ca831729e557094a48bfe65a26fd12bb9dc4852cf"
