# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "72e6007910fdf2b743c858adb51007da"
SRC_URI[sha256sum] = "777ecc2a8ab30d153c69f47e297c8d0861a9d49e842d065565c72a1c72ecdb25"
