# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3bc998e25bf79d309ff506505a98327c"
SRC_URI[sha256sum] = "cf7be1d1c70b2f4db440ade725f08074273e217a2cb58b51c58dd5b7d15083ae"
