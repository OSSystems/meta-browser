# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "41f9595a1e8e90d0a646ddaf8a596964"
SRC_URI[sha256sum] = "9cf2ede2a4985657eb3191cb4ee4579c56c32932f15cea62dc7d905f53d48530"
