# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d5d19756c6bbccee2229622b2d478a9f"
SRC_URI[sha256sum] = "2d029979406588d276fd6b80d9226c978108d13ee098096e5c3c8dfe5961352c"
