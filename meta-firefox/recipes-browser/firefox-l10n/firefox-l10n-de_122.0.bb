# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3817cda1c94ce9995525ea07949dd3b0"
SRC_URI[sha256sum] = "56143364b4ed78d0c845029ec7892ba2de7a6e4a62bb12af1c5423de2ab1bf16"
