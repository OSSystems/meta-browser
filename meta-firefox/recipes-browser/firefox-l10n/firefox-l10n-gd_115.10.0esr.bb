# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f509f8777aab1a2cca4d03a57910071f"
SRC_URI[sha256sum] = "ebbc9bb515bd8a8db30371c105baaa5968b62bae73a151895cfd17d31e262426"
