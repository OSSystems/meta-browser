# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "23ae7bfb999d58b78d8596ae9fabb5f4"
SRC_URI[sha256sum] = "55e52f2fee15cabcb346e250930167ef6e2ceb5072dad2ce40412f0977d17382"
