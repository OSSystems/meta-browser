# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "42151de715c5a3cdb7d0c475ed3c3e55"
SRC_URI[sha256sum] = "6c5d09a23bb4b48ea85855e87983c7a7949416148856d58b9a942691c53501e9"
