# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3586e801f6beb30ecce84b66b647d31f"
SRC_URI[sha256sum] = "cc05388b49936c266ebf38361209a193324aefa01bce04a538b37ab64de2f7cf"
