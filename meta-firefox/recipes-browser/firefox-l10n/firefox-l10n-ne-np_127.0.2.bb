# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8b39690e6d18081d64b7cb62ead2e1d4"
SRC_URI[sha256sum] = "9e14eac71f0ef663c4dc7a953e0dec576e9a3f42b695433e6cf7c27b1a6854c0"
