# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e400bd8b47972b9449899e30b4640b44"
SRC_URI[sha256sum] = "816f5a434a839f3cd63cf057cb528ad878c7beec20275b2aaedc6cbc3fc3bca8"
