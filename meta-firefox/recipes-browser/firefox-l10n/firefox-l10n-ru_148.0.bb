# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "55d5a03f0155be6d9af2999efc9fd62f"
SRC_URI[sha256sum] = "e126299f271531d1381dc2b4263163828d03129eae3f04c5ac04839ad403fc05"
