# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1a1516b51280e9064b808596a98ef91d"
SRC_URI[sha256sum] = "5473a52b39a6cc2866e657c9cdc2e0303b0db2cf534a5ffcfc4ca0dfc66b682a"
