# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "fbe9038746c52ba83508af21b9958da2f0fcf713b4242c0cedb2f314dc7722ec"
