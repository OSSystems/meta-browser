# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2909b54dca3452dbc2260d89f6ed9a79"
SRC_URI[sha256sum] = "ad581abdc7ec3ad04a970a1433e55478a0f107b4492682792031a68db4bb06bf"
