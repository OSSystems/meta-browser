# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cd8433645b4931d5c497e22d634710bc"
SRC_URI[sha256sum] = "9c3bf709dcae1de70c7a31079437ceff1c187c9582fdca59e0730a48187dba69"
