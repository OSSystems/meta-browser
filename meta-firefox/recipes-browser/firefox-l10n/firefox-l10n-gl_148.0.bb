# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c939253fbd679a7e33a3cbe8e88bfc98"
SRC_URI[sha256sum] = "a2676af045c27eae73e9f15e16d5e71af6f54d04140ce07f11d1ed942da5751e"
