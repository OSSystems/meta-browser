# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "32691710c3e4579d8b3050349c710e47"
SRC_URI[sha256sum] = "2166f86ec892cc5679bf558458d468c23cbf2308624cac60a3926f88cf56cab2"
