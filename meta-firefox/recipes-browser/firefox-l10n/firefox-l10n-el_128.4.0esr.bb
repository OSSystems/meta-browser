# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e043d7ac957d33afaec29f6a67a4ae79"
SRC_URI[sha256sum] = "e31bd90fa8db3df5dbcde6887e15957b159883dfa3ae0b408532e7ddec69b058"
