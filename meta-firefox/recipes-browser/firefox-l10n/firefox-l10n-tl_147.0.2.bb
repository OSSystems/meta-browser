# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "89308ba41a37780d5cfd48c2d7bd7047"
SRC_URI[sha256sum] = "276ca2af5b59c9e82675c915d8a7b90a865bd01ec45a9c4ea72e41d4822734c0"
