# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a3e713a89439f8992b2c89657a681647"
SRC_URI[sha256sum] = "ebc22901495bf1d3c93fea2b903fabe132b103ba036448e4e408f066b3a7b713"
