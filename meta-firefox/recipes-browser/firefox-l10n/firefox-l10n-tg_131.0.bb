# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "45d3720282047193bb6a2fbcf4ec304f"
SRC_URI[sha256sum] = "8d05567e7701aa64f08bd6b7e8d4fe57b51c5560af42094b0d7ae1a5b0f146f9"
