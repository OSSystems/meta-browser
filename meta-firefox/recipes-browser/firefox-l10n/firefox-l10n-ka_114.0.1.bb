# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "23da4c0cfa5fa7878c4e490af3468b27"
SRC_URI[sha256sum] = "befe303d16d2bb3a2d948b2a0e902cf844c783a0ac2a5d4cfcce741179b97577"
