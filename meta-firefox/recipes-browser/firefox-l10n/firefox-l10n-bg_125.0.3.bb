# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4c571909e4ae70282ee7a155ecd263e1"
SRC_URI[sha256sum] = "b5bb87e58bd89520739eaf37f9fe3fe8bb84c6ff9a86894427e5fdcb7c9688e5"
