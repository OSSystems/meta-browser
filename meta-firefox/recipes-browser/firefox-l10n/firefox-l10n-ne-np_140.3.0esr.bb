# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "94dc35ab44912e5d0c7c321c58d850eb"
SRC_URI[sha256sum] = "0df43308dfe48483a4168eab38163a0fa3301bb0697f03696bc6d1a9096fd930"
