# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "52fa05f147d5e467e87e73fc0dabb975"
SRC_URI[sha256sum] = "884666c8e347c2170777a7191acb07b3324adfe2fd590784285885cd74a556e1"
