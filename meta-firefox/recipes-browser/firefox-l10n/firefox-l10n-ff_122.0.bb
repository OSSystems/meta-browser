# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5283a3fc2782be70bc17a290ac40f382"
SRC_URI[sha256sum] = "064c1405b47cd84236b62968a0fe387cd0581408e9c0e20fdbd28d18938d77af"
