# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c8fd66caa31deb1b0aaf156809b6e27"
SRC_URI[sha256sum] = "d96f2af37c57c5addbdc62aecff0c49dfadef71d5b3af54dc7ffa8be8352d4c4"
