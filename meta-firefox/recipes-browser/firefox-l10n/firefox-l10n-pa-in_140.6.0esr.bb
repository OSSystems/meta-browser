# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "09f627621521942e1588f7642230042c"
SRC_URI[sha256sum] = "7142354b51520e18cdc620be8b4e125a4b46737155c45481bd6fb5926b0afad8"
