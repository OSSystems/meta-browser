# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c98205877b40e5bf9720f141b05534c4"
SRC_URI[sha256sum] = "fdcb5fb6c2fbf7338b086bebca4cd75b0cced9114c1da256df9436a47e64a9f6"
