# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c0bb365149307d0923349961f1f818a2"
SRC_URI[sha256sum] = "8b7701b6ab00547b31c366a394f9ec4afb15511c2fa4100e8b760999350fca4c"
