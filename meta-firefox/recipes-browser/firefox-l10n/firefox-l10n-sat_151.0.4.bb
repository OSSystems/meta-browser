# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "15815841b5b66b23b0709925c3f37447fa1b2e6be2628b5afb32eae4284ce559"
