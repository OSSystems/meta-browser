# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "16b52c7a19faefcb48da49d717c51c4b"
SRC_URI[sha256sum] = "21fbcbedd6c124a3ec2e29784844dfdc32d6d47e2c1123943c28c3ebce7dc385"
