# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "44cd43e5349fe9ccf122ad7f79d069ae81c724cc6d37797e09a4c437606add1b"
