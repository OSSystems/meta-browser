# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ead1262bd11bac1bc30ca6b09ab9680e"
SRC_URI[sha256sum] = "475e6343013c2d11896f25ff87dfcb6f664db8a390979aa4ca9fcf788a23069f"
