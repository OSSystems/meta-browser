# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5e8ce6db6419a850008ea732e48788cd"
SRC_URI[sha256sum] = "02ec61c46dff40199494d6612efe89d871e2ab16e5bb5bcac819245d5bbefe12"
