# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c4da777fb61596a052202bac1037217883cd58263c9adf344c61faccca392c6c"
