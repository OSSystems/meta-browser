# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "905b65d786a9cc5ae453ef42fad3a996"
SRC_URI[sha256sum] = "9cb70027d5578fdb1039652e87f0fe3a0d7492be225ac79c840f20b787e2ad78"
