# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "966cc2f5f6fd8e7d5af63f5e6a5287ba"
SRC_URI[sha256sum] = "07ba1a5ecf7df1ba5a9af4856e32e229174aea9e0f6fab4e230672ef779aac62"
