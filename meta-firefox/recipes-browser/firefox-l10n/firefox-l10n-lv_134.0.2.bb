# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "25baa8dde979b4eaeaad1d50b2390e05"
SRC_URI[sha256sum] = "5cedb3efbb1ed41660e0790db5d473bf45feb6f1558b8b586f9e67748287b4e8"
