# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5c7573d1b43299e8d151dcba4395dbcd"
SRC_URI[sha256sum] = "028870d9539867315c75718233736ace79bd0e211198970ed0f5117497ce0934"
