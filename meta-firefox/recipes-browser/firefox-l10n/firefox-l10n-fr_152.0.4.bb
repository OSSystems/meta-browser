# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "5fa433309bd994bb83b97730d4eaf59d6b9576c74853bb435aecf739c3080374"
