# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "379efcf42d3741edc289a5ed79640f34"
SRC_URI[sha256sum] = "317c9156d301c849b8592151545b53e5235358a81dd4640f5f91485d827b2cc0"
