# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "f3ed7f07df578dd21ca91b9e5f20d375106fcd037fedfe3809cc105f21c6e09c"
