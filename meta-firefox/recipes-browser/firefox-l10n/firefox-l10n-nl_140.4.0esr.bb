# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a0eaecabd60ad809739db6c5e1fcdb8a"
SRC_URI[sha256sum] = "c63ab22ca28a9c5f96ad9357392ddad5d32583afba05ef59a6ae4c0534349a9e"
