# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aaabe24ddfc2c406703aa10935030b7e"
SRC_URI[sha256sum] = "3bc0923e4d5bc4800d9f4271c9488a01ae4928a09b5f6fa74011b604ca7849b4"
