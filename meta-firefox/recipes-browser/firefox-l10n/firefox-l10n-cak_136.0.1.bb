# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fe3511df7040d92ee4f5ee6e63a33502"
SRC_URI[sha256sum] = "50efd2f0529b0173bf2c01d096c293763431071ca8a25b7a0b92f916b6f15923"
