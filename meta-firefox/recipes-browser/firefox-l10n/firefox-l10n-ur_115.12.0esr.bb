# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5a605793765505f42720a185da7d076e"
SRC_URI[sha256sum] = "143570a4a5b75fa9a6070aac73657301503669d98d0b83dacc4bb1fef008d180"
