# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dafc8cbf3e7aaf1e5f7546bff3fd1ec5"
SRC_URI[sha256sum] = "127bfecb02778423697e79a9363ab07c93ea91dc81f5e709e2ea85187072537a"
