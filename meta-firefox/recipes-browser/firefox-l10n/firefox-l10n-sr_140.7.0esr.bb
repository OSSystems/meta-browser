# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bf194b700b81d54f358547c6ebfb8359"
SRC_URI[sha256sum] = "141318ca1b24321e5511d858219966dcb589365d8a67f5fa98aa8316e8c95e6a"
