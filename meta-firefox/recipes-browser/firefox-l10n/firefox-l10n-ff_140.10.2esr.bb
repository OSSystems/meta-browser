# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "687a7718bde3b6e0b45bbb04399f6828cf7d64b3462f9f07d85792d8a7946577"
