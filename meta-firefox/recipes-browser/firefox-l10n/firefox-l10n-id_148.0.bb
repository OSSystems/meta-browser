# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c5cf6b8b031e74872c075d6ad196eb9"
SRC_URI[sha256sum] = "4a3f35cef773ede3e7871ece82a5a633211798f74dbd25f60744dcb26f7a6b99"
