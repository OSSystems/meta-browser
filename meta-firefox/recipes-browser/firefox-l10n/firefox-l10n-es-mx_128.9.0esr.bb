# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9655d6e6294a37dfc089c93460691589"
SRC_URI[sha256sum] = "5b126bf84cd4a656af3e55b85b20725e756c6d41d6da28d0a58f9f7db8629ee4"
