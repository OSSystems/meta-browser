# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0910af4f471b3ab3110082f8617c04a8"
SRC_URI[sha256sum] = "1ff941d809f67da9d1f524f90e70c84cc363638482675a21ade919293d14224a"
