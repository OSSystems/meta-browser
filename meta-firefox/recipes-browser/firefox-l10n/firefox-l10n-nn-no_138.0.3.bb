# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5bead08080b7094e8b6c216108d92780"
SRC_URI[sha256sum] = "f0a250372a28ee8e78d5bcbeb3eb4490c088737a9a9150b4d93732d719dddba9"
