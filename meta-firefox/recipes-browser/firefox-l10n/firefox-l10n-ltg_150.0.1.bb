# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "a3f46f63cc7e27dd0401df91bf6408f9ac7c8a20c50b44916025af198dce5902"
