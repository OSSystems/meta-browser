# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "8856cfafd39cb0bbb1d704afbf1a9da17748492fd9bda520ac6066538f44b9f6"
