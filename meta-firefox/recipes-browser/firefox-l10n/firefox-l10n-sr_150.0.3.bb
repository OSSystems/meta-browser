# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "a25e589dd832878097f6db2ce35e4225fa944cf94d052c86ccae2681375db79c"
