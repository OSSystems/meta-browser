# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8d29cae156dda24cbb3cfdeac583be9b"
SRC_URI[sha256sum] = "9796064df0331b9f35a2e87fafebc5ab5f018a7bdf21b496e7b5916a47b3a646"
