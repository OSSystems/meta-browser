# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "66db36d939cf99b5affb83803e283c12"
SRC_URI[sha256sum] = "dc009cdbed1e82323bf761045f250601a13fa3812338c467604b808592225ed6"
