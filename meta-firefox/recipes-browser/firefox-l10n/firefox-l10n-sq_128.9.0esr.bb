# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "79188e8db0085f9e874a0dc4b0427374"
SRC_URI[sha256sum] = "0152488da5f3ef2d6d0f0bbba05dc156a1e6fc51fcc4af5121acab68ece4190a"
