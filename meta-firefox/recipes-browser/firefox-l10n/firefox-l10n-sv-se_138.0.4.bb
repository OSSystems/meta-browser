# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ab4b6c8242de8105c233bcc2d4251863"
SRC_URI[sha256sum] = "7aae1e092c212bf35cc439b363aa37b1e4d6bc3166a05f32794956baae7e164b"
