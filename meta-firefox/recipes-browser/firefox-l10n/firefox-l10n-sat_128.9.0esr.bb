# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dedb4188dc7336cf8b18890193d2d47c"
SRC_URI[sha256sum] = "e57f5270afde77e9ca1cb72524b226b3e309cca4fee06d2f93213738aaba6bef"
