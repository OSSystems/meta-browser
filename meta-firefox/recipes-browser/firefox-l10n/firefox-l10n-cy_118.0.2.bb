# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "438f473ca2a43636f9135214bb0aa856"
SRC_URI[sha256sum] = "b7bd6cf7e04a6fa86084d59c79872a6d489b14c30729eb8540230e6ee085afcd"
