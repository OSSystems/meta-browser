# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "edaa1e43b5e2d0b3759096607bff872f"
SRC_URI[sha256sum] = "8e6f9c41bace792824148bfb3b2ee3b92eaf35e73256a210808102c6d671741b"
