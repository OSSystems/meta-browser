# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "31703a4f05a90ebae4cf21b5d8398487"
SRC_URI[sha256sum] = "9abe53d94c9bb73dc3333bc76a612a4dc66c8e559e0b9c5e4e05408a74d49695"
