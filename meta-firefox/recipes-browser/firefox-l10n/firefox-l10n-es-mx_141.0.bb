# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4b1f2ab0fb2396027cf03a2fb06175b2"
SRC_URI[sha256sum] = "077ed10d8280a2ec3c7eda8b1072cbe32a7ff0cf67c0685d14c1a61cc761b9bc"
