# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3bca725d398f3ba6d06c7cadb879dc32"
SRC_URI[sha256sum] = "0e1843cdd1ade58ed20ff14f16e9bbd48a12b489b1713af658b196fd33c79a08"
