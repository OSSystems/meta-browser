# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ce77323937ce751c4416ee31052d6042"
SRC_URI[sha256sum] = "bd469ed569ae5ee840091de9920f1efcd1e902a7940a8ef044cd1bfec6712bb5"
