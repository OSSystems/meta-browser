# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a90c241cc5f44789c1009e0a006d87af"
SRC_URI[sha256sum] = "40c1303d97232b2cfd87c9db15526fe9f207ae290761f48b6fa2a31d12d926d4"
