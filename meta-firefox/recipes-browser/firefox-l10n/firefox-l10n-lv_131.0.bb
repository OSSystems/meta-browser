# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4b6e94c04c8e8e66b2bf87705df2f834"
SRC_URI[sha256sum] = "a76d5fffa75bd629128ef8ad61b7c0b6d3a6cb37b22e61e9580f0cbef05d8736"
