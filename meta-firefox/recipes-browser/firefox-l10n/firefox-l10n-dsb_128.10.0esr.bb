# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eed1c4ab706db00a6a2798b6c7708142"
SRC_URI[sha256sum] = "ada528782f7d59e3644a90878b05df222ec844accf0e4461e5657d9b0dbedb9c"
