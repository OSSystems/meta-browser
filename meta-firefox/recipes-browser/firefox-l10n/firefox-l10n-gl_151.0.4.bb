# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "465abc88a2ac80d3f421e43ad8dbb66f2cf7e159898fab3c0db272360fea55b4"
