# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "086b29d3a41684f371e0d4b9da4bcd03"
SRC_URI[sha256sum] = "4b949a1326939318978f1c9dc8bb71e78e271e054699ff4b23bc86375a4760c3"
