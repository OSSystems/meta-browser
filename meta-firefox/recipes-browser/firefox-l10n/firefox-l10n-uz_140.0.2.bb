# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0e67626d085bb0df37c8bb05f7760c26"
SRC_URI[sha256sum] = "5c50eca20df26fb9835a46d9c3cf23135183efc78010e042cdc7ff41fd7dd66a"
