# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "1a55bb5ff6554902030b9b0a10a45eb4acb76ff50eca27a7400924cd186a74e4"
