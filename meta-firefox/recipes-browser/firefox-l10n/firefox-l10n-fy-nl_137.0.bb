# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c0c78aad3326993dcc77186abe76e684"
SRC_URI[sha256sum] = "36d4bb157fe5bfa6e56df55f6030dd5aa81ea6c73779e400a7bedc29c8ab28b2"
