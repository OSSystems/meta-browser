# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8e68a08ad87abf8a435e66b36cb12a90"
SRC_URI[sha256sum] = "4b700aef5e6b9ecb7a6d6a70ed9c196b6ed77cf73a5c92ac9ea6e7629f00f7a2"
