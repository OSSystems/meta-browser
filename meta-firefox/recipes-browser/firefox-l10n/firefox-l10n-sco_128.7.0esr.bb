# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bde807a81f13827e8032b8624a840b7c"
SRC_URI[sha256sum] = "cd08c0d6e62844c0b5823dcceb7ffce693dc985418e1a245d201c320739f1e60"
