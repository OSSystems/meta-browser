# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "0f01273f93c89eda42b0b9ed3c7abcb906e877179ddafd00961d9a0d7f999224"
