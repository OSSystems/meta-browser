# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "00838119c9e0dd029e820542ae9aa572"
SRC_URI[sha256sum] = "a1c28ca2bc0ddc890f12639999c69858d0e6ea4c62d2d3b92095dfe1dac6c23d"
