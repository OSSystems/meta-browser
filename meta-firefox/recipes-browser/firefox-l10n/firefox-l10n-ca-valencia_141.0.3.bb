# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "65a9a8f57ae7ff3913809aa88cfaf2b6"
SRC_URI[sha256sum] = "80f9fd7da2c8008416f7c1ed96056891406b048273c1db5ab5cf5be787f01e0a"
