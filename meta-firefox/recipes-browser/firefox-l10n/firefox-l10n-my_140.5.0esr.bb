# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a1f70bdbdcb53ffd38aaafa07bac2138"
SRC_URI[sha256sum] = "9c208b60583abf5b0c681ac3e20a935faf1ecc18ee96996a8cfef7d5c8448a34"
