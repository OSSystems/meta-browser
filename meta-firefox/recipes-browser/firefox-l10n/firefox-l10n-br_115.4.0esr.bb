# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "70f7e3f50dd79785f6460b09ea503f2f"
SRC_URI[sha256sum] = "4476f74eaa94f903b3bd72c924e9761f94b84db5a9e63baaccf320e3fd593521"
