# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d95c08f58b9822a6e69c49ec5befa58e"
SRC_URI[sha256sum] = "6ebe7b9de8729e5ba3c91ec92886203e29925d94d0f840ac9ed248c3109ba5f8"
