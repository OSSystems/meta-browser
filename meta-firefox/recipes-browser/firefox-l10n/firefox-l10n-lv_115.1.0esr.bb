# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e39e932e7aea0e64241ceec32237da3b"
SRC_URI[sha256sum] = "439bc5bd29e46af925237620a1017186272729943a8b55f66035f201bbb990dd"
