# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "92dcb639fffb3904e125bb485251320c"
SRC_URI[sha256sum] = "b8a4e1b362f07981e5ad4681b0599b22b9f913aababef26fa8100185affbaada"
