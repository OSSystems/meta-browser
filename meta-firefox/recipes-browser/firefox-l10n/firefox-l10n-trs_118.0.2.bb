# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e2a5ff38a9330ebdaa09f2fa9cb475c5"
SRC_URI[sha256sum] = "1c3de02f4568c58fc972888a9bbdc9d59dfba9dd8b5dcca50a8e8390d662aa62"
