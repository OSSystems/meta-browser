# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "64422c36d37aa36dbf774a5ddc5a98f1"
SRC_URI[sha256sum] = "c38f93ec8c83237df23ac990ae386951d60dad3cf6d1803ab3c701783bf55b0d"
