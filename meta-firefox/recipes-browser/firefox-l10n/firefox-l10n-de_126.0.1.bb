# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "56883746e171cc04a2d9ec4709043065"
SRC_URI[sha256sum] = "945294da6880198807f1c817f2b85bbaa1c86ab9e66ea6bd99ee2247d3c42402"
