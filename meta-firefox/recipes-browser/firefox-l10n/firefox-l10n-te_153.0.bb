# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c7034c9c75913e02479f8c9f56c305853258b0e641233c85ed9abd524718ffd4"
