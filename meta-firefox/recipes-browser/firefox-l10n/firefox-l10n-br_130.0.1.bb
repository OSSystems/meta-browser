# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6e32f36e7cd56195547be05d462407a9"
SRC_URI[sha256sum] = "f26f756f5332f50cbeffaf5d73246f3182e2226b0b3f3a836ab3ac717fb66ee3"
