# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "50c22a250957c58e3470b4570fe5c4f7"
SRC_URI[sha256sum] = "6a93430a0d7f11d3791dbf4fa33745b6858c5d01230d518da66a7aef0843b3c2"
