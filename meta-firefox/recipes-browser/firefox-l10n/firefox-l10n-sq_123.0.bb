# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "127a91dd7c3935ca9f761d1ca4924b9c"
SRC_URI[sha256sum] = "fb682e3e4e149880a70c1602469d092c112a6d1d88fd0a4de04718e590ecbf64"
