# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "03b95399d9e7912137636d24666349f3"
SRC_URI[sha256sum] = "3aaaef11a145d1f5916f2c39c5a7d35e49eadf79903c4befcc1d8f072cd09a43"
