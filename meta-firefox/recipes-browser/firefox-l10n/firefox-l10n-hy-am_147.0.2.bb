# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0b8da21b52ca69eb78505cf853620dc2"
SRC_URI[sha256sum] = "f5eb46deed157e2af142277cbcd198daa908d849b4a5057908b4f069a42b5489"
