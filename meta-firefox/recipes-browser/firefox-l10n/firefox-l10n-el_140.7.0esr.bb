# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1e2a11c8ba27793bf97847667ac470e5"
SRC_URI[sha256sum] = "ef2653fb2354e200cd99354af8995593491031f84f9fc6f131b13335a37e83f0"
