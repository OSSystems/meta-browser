# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "771c42782a9f1c3401cbd19bb74748f2"
SRC_URI[sha256sum] = "294c1397638953e1e7dde5d9ceb21760acdce9052d37af42264fefba5764468d"
