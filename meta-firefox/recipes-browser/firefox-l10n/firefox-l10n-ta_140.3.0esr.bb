# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e0c27c81f8f7d6654dc6aae47fafcf28"
SRC_URI[sha256sum] = "fc3baf21e7708c1be6fde97bb2a106d67357b087367753439ce81b5662b71a50"
