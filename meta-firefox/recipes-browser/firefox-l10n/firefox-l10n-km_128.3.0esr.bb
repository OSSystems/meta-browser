# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "91185713dd8b368c6f427d729a97d008"
SRC_URI[sha256sum] = "5b6a27fbfb9e4c09c09bcffc4ae270b1527b000608953db4481a25a31f5fda7b"
