# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7740f4a47c0a3fd7b29d2f6f0a5f7592"
SRC_URI[sha256sum] = "cf6b9bb55707e7a7fd39680f3022cf69978ba8347ae91d7ae335ca379c8ccb8c"
