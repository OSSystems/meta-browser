# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "92c842b2aa28dcde872476c88572e93e"
SRC_URI[sha256sum] = "e6d44a386fa3030756d200286949fe25ea051d1e8e2b9f605eb189473806dc1d"
