# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1f420a00d2c9a718708c7ffcb1433c0e"
SRC_URI[sha256sum] = "ffde23637c5542b02968bb4536e30cdaf0bbf0c70d7c371cc22ebb2d10c50c4d"
