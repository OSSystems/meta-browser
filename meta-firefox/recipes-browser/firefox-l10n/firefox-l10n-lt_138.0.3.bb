# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d6e5e66482c60438dd7c9e7d8e8dfff0"
SRC_URI[sha256sum] = "d267edb95e412ba88f726e09075b9e31ef2f28c594f97bd35172bbafa780af7b"
