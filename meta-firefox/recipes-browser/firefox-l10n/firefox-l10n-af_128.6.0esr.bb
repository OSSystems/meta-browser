# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "11c3ef2f7d41895d5500482d021651e6"
SRC_URI[sha256sum] = "4543a1e38d5c47f204c3b2851d823e58588fe28029c58b16f399b2f24a1238a8"
