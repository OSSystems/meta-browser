# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fa122589a1da830d6d83fd86c146aa70"
SRC_URI[sha256sum] = "a5fc5257cd790710917fb838ef059370d6fa0ddad35be83da4c166c838e8c3a3"
