# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "684dd1599a3b63db4e7e407540baa191"
SRC_URI[sha256sum] = "420143fe20face9246afc1d02ee4a954ecc175ffeb502a935128d604e3818c15"
