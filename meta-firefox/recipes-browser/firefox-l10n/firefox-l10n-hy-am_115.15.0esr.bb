# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0814345cd2a323f5bcac679ae43c7c8d"
SRC_URI[sha256sum] = "e5309e9c5f7789234d3073311382fd2cc6632792adb0503b18264e999756e2ac"
