# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6ada6c044fc438b7605302e31edda572"
SRC_URI[sha256sum] = "f2a307aff2c8840cd506b6eb02b4ab2b3ed96a3254a5c2ec23e14ef908ccae02"
