# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "74b21c693954478cddb950e83569bc44"
SRC_URI[sha256sum] = "f6a50b8319b6320e4f4f0f53f2b50b845266ca30ecd1f06d6ebb7aa90f113f23"
