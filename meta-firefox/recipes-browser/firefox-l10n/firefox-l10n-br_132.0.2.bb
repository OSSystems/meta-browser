# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "da2f1c26d49f165c14293c094122cf29"
SRC_URI[sha256sum] = "2a911b19ce652faebb878c0032f6194ba730cb31d791f667a93f329ec44f1474"
