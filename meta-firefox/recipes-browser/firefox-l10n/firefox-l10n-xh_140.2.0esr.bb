# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c5c8d3a3737084b82dc8f8d6a65c1946"
SRC_URI[sha256sum] = "0073bfca020b476970240ffea84acc0f779ba37320592a5052d3347f54dba18b"
