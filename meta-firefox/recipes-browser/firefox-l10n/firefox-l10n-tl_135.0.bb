# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a070ecd29b7f409bc18df4107fbe80fd"
SRC_URI[sha256sum] = "cdfd9281e28e327d10f503a7f2c6b7c7c677b4f26368b1efd2862dd8efa2b785"
