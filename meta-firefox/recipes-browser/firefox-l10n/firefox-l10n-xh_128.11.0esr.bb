# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b7b0d617f2df9e723463b9e4d7dda0d8"
SRC_URI[sha256sum] = "6c89dc82e07dd3c6adef2fd49de11759119a321ec231e3e8bdce7fd7fc5a3fde"
