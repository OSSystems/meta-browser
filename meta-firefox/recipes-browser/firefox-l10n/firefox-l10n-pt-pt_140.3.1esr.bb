# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "91f71c2652ae8186eedc3eb18e9c49fa"
SRC_URI[sha256sum] = "ae8e743bec6d4b24198602a68f797821815dc61566b19ff9e6485abf36c9dc75"
