# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f7e99db576aeac2fe63b77a9ce43e6b6"
SRC_URI[sha256sum] = "6b0bfbd8ca49ea37250ca3cd18a85ab6517297437f75fb015c61ecce72c1888c"
