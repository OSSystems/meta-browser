# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ee2be0376687193b436ce0269e112903"
SRC_URI[sha256sum] = "f3d9a9c0a302808ca830aa8af83fb99bd4ae02409150903574b3fe0370844f17"
