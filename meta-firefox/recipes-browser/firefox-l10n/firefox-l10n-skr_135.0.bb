# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0533aef52f279365f264f82b763967ba"
SRC_URI[sha256sum] = "82b10fd1ff32066c086f6ec98c068feed4c9adbc72ecad0efe72c918668e4ba8"
