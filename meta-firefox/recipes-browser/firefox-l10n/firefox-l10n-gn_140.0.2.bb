# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "68768b8d1302d449436588c6b2797d52"
SRC_URI[sha256sum] = "fb4cd43cb54bb8e469d0bff312c52b618ed433afd4c4cf2ab485775377300774"
