# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b6882caf1a4ea75c9ecdb4775f646a68"
SRC_URI[sha256sum] = "435f53faea239c167bfc6f9132c586a2fc289f32faebe2ade8071fe6047f2e85"
