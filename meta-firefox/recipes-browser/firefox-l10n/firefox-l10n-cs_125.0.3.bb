# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "42ff086346d4425e587f22e9081a8823"
SRC_URI[sha256sum] = "43b1c707e083d8ee30abe2f36e772f08c4ca2d8ed6613cfee85a270aa49cf6e0"
