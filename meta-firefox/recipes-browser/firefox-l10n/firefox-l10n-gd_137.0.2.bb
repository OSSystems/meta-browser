# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4a880fb0739c5bbc20f62dc6bf303d8c"
SRC_URI[sha256sum] = "b21a3aa63b1843ee585c2e5972cb0a6fd2eb02de13b6ba3fa888b5f79f8816e0"
