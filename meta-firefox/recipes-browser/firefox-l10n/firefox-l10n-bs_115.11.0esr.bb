# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5a8e55c102b1a362b1ba8a8058c8614b"
SRC_URI[sha256sum] = "88cddc8558277c950f229c8e5632e4c87da3d3645b488fba7988bfd53b7a26d1"
