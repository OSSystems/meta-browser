# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "47c31367ad88c0a9ab6a63e53c4788f0"
SRC_URI[sha256sum] = "aba8acbd83ae74fdeff2996227c68bcd331a268998ed337bf049974b42344fd0"
