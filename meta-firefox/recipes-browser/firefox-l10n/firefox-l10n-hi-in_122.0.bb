# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "39241ce686df0b447c2c491c9590c470"
SRC_URI[sha256sum] = "72aaf0a80a0d213817b27c02df29e872fed4f3a57a34e25d44deff19386479dd"
