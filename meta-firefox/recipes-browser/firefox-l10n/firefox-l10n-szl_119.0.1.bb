# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "18ef2249784032b792b2e5cac4d526a6"
SRC_URI[sha256sum] = "dd16bca20cbd6125a4eef17aab1900bef255d8d72174d8f60153ac13fbd70a52"
