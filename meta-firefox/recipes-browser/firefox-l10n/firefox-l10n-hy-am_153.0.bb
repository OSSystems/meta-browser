# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "caecf2eed17b8cbf929d30025f0ab135126b04455bf9a1a9699a86dcfff62cea"
