# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d22499522695ff474c206ce117dbf972"
SRC_URI[sha256sum] = "1e664db56beac6dda94bfb3eff400dc6eca11249d3a4be88351fbd28f2d4de6f"
