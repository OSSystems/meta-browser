# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e19e1a0b7bfa36eb74ef1f5a12ddc9dc"
SRC_URI[sha256sum] = "aa793b7cdaa20be262a90fc4b97cdcb0a815c298b3133f5b2a05e15efe1ffafb"
