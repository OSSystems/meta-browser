# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "691474ecfedc216e13c02ef255e5ac82"
SRC_URI[sha256sum] = "0f6e2a17f98307ea367e6e5d6e112a47474e664d9ace62f49e7e100ceab393e6"
