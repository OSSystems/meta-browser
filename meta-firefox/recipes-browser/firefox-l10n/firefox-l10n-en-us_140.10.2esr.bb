# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "9b083efae03f06112dafa2f07c6720fe4b10e449521126c97f4ced7a0869dc87"
