# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9417b8084b4c746eec92614cfc55973a"
SRC_URI[sha256sum] = "64090934bdc5d108447f07ac1ecde9ee93d9e2a8c98b00ec7c4bb387d83af019"
