# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e6614cb95146a8b8d6df48fd76da6c2f"
SRC_URI[sha256sum] = "620dc82bfc3e3a65b4e73d77385d63c0bc0830301cbdd48a3149de06e9bfe374"
