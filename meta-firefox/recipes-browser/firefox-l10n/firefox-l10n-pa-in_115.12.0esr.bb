# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2b5029612f0735bba1ef2eb361594add"
SRC_URI[sha256sum] = "14c19fb56a8e597a0c8c661769cf73d9dadffbffe7fd7798367af667783a23fe"
