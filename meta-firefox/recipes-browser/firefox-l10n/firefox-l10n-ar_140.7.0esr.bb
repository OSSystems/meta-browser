# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e2a094ae1c15a8ca41998111fa33a110"
SRC_URI[sha256sum] = "a5d32ba29961b25715575691b83caa7231623e0739f01b57da897fe4160ef4f2"
