# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "df105c6160daea6df6e78eebee573b09"
SRC_URI[sha256sum] = "93803cced7cd216e9a5b9f0cb7f77847df679da67eb213e2e89f3f5f6f60e3b4"
