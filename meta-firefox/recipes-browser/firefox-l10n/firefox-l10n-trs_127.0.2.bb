# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "870571e938d59fe3e858dceb1f84dc80"
SRC_URI[sha256sum] = "8ebfeee13ae12fd666fe5b6eab1f051d3a0fcf911a0390b7722123da4a01725b"
