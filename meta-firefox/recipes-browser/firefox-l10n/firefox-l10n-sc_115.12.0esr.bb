# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dc25ce9d5965693f37c41ef887d3af5a"
SRC_URI[sha256sum] = "9fd05cbaeeb47731beec17ca3b2b49e6a1fc204511043e18ce244223d40f5c5d"
