# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "305259e1858bef5e2f1570cb7db692da"
SRC_URI[sha256sum] = "59464e52d036645518446a9ec7d0005ac32a2ecdbb3d655a16e07a68b4fd611a"
