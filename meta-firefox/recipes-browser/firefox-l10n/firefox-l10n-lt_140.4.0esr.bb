# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c7ec481c90c5c9a746041edfc67fa759"
SRC_URI[sha256sum] = "2b6ef7c2e7be0cea217d0d9ac5d722424b2d6714db7368101c022a8f8fb323aa"
