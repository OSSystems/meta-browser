# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "9cb7e1786e668360e533235a39dc1cb2653c54ff9dbe406999abaea3bcd3f6df"
