# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "034d23bb2dfa3dccf88dfb9042ea905d"
SRC_URI[sha256sum] = "228c37ce7562f8b7119588991ce5e8b9af53ac02817f36b9250a982569f0ffd1"
