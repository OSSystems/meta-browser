# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "07ecbe58f5a0b640926390df8e3846d108b9e0d2a50ef4e7ddea524d1716b48f"
