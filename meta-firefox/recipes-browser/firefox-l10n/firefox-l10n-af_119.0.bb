# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2ef3bd7280b8693e6cdf67c84353bc58"
SRC_URI[sha256sum] = "6b1fa544ab33cb4105eb7d38e577eea8e74adb692c29898f96c1b7752573737d"
