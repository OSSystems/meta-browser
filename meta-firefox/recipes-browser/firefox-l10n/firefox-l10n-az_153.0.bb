# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "a08ee5eef74f1718b7f1c567f80427c601b71056ee2ce6c6f23bbb218f11b718"
