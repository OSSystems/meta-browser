# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "87f44854f6af7b48f4a020b91ea085fd642271989b130e0f4522259009035dc2"
