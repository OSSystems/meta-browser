# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d30c87f3a41e733f57c8d078bbd817828702d89e26e8a2e3c1615b0e935ca0af"
