# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e1227ccaa753fcc7950db07e240cb776"
SRC_URI[sha256sum] = "e7544d2072067117274a8d04f89e84ac2b8fb0a9d04fb234f7d5b57ab017494a"
