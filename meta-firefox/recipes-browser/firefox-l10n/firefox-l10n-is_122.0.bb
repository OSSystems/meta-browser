# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e6b11a66117a49516f4315b76d2d6de7"
SRC_URI[sha256sum] = "309277850e076f5cdbeb55d8a0a7e26b8fa376c9e2bb4d9aacbda79de8fa0f57"
