# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1436c39cf7f4f9f4295848823d8a8658"
SRC_URI[sha256sum] = "c4a9660abf0d2648095255690efddba23cafc652fb900903cda78a79eab04b0b"
