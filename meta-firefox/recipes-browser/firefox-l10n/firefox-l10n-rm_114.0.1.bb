# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a3468ab3c530cf7bb7c0304e39b1c49b"
SRC_URI[sha256sum] = "7d3193f277dba71fa74f9ba188696305552fd7a4abbc6326a816309f3c39a93f"
