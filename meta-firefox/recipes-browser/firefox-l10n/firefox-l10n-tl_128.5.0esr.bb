# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3ae72c18b6ca597ab5fe63a861df272e"
SRC_URI[sha256sum] = "2d16e1d8283aa2305f2cbc07f7933a96f2093e2ac7cb0ed054e69ce1a8826157"
