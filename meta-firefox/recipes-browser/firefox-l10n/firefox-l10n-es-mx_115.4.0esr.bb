# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0a98977db3cbad5c556ffd564d848b2f"
SRC_URI[sha256sum] = "c8cba74a0ec92f0019059527fa5d00656780b81a516a8f86d03e1f21d800ad34"
