# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b30b8c4e7e701a4d63cfbe832c369fbd"
SRC_URI[sha256sum] = "8c2685123616e80c8595ad199fdb2cd37d63f2961ce7f3664fe768a8f9f9aac6"
