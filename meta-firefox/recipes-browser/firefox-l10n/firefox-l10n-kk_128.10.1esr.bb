# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e0cc20ced7fada300af3cbf32618699e"
SRC_URI[sha256sum] = "ed185b6f57a6df24c49d22c72d76598b7119194a121f1f79e0c86f4af3513238"
