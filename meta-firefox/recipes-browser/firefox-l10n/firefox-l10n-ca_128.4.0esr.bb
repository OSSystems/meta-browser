# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "92dede2d97e5d76bf0bb32d76c6be752"
SRC_URI[sha256sum] = "e601fac5e97286c38f9956079b7fd346e3ce3710647046ef9f0ce4969abd8021"
