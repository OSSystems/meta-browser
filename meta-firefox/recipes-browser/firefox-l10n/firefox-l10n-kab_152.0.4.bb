# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "777a9f09105bd7191d74048dcddf1922cdde9002c681f2cb142de832a5d7e685"
