# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b21234f60bf22eae43701220b1d5df69"
SRC_URI[sha256sum] = "1846d8a44cba655886b2a4c4bcd907fcec30f10a6410b12d285ef43b93d9b305"
