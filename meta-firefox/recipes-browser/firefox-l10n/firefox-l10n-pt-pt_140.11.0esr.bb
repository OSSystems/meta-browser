# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "031f1fbc58de67d19af2316ba3281048a67d94fe4c1a85b73d1ac24c592828ac"
