# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "507cd1adde843a22c736a3a86c002d82"
SRC_URI[sha256sum] = "b25369c27f713c99bd5438969e4343d9047948651f0b0840b44ff7e8c3488e9a"
