# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "868d4f76a9321b80699702af6ef17cd1"
SRC_URI[sha256sum] = "64ed9ee9e1f20638cd34adabc6615106d840596d9c33a2b5978f9c226913f964"
