# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ee69c1571aa695beb6cbded5c889eaea"
SRC_URI[sha256sum] = "1a80b5d1dba7c55f1e57eed4a78efa3c18513258bc9dba8a48798e5f8d7471c6"
