# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3c2f7d43ec6410e2b0f5c25bf822865d"
SRC_URI[sha256sum] = "0e977920acb99b58eb829c1497c8007e31ea9c6de0c88d295cc2967bbc95abec"
