# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "efa7c3af4e209a72b4584c7ab0d2c9fb729af3ac5112ef15f2412a486d062a4c"
