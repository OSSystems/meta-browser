# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "07df5312cd1be49b70891320ff44c2e4"
SRC_URI[sha256sum] = "b5b0a91c3086cf9a666d93d05764599f1a5334033df25516d61eab16255775db"
