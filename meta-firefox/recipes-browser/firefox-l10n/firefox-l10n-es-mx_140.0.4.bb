# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c431869f45bfc1c59c038fb2e72b33b6"
SRC_URI[sha256sum] = "48d0d756cefcc77ec9cf07007f77b9b954446838a74a75ce8e371b658dd2427c"
