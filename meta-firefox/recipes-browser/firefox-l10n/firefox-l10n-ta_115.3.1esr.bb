# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e9db14d37e61d2b3989344adaa8be472"
SRC_URI[sha256sum] = "f05a6775485924e7ea8516c442effc01f04f7ffa0d2713a3f7bfe49e7e410c30"
