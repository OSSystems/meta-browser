# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eb934f62c732e2457740df06b6301a93"
SRC_URI[sha256sum] = "23e18e54454dde73c34bcc3eed55e966d2ac64c0509bb4265083a341d3c5bca8"
