# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bca55a7277f3d95d5e6aafba6e1bafb8"
SRC_URI[sha256sum] = "35d7e27f57b19c7bc062f6951e4dd9da3195f3f56d4c7693334fb4e7b9356298"
