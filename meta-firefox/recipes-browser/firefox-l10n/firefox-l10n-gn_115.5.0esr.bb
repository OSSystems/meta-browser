# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "39c4b434837b19e00a35d529e40b4e30"
SRC_URI[sha256sum] = "eba53216a53ed749f1164b9b5664cd04baaca2e0e2035a665298f06853d80007"
