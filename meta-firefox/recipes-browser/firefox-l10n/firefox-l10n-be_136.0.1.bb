# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ea17deda7427ded764a35a9b58435b6f"
SRC_URI[sha256sum] = "78d6252a732403c53f8eaddbaa2b75895e3c61609a060b9314d98ddb8ff3c9a0"
