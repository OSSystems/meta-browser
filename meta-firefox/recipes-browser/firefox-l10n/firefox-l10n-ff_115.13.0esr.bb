# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "44beed5db7395102223cfbee19525402"
SRC_URI[sha256sum] = "3f0d1d7ffe6ad5306dbf8e71476800fa22108dcb8029efa86512609d1394d7d9"
