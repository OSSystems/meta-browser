# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7d9ea627f9cc5d44eb8d0f85b24ca6d7"
SRC_URI[sha256sum] = "f0b317cf83357e5477c422fa428d324cff557c89003708e59f12dab2e2751276"
