# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a78e0bc18fc3a024cc8186a2b550af3b"
SRC_URI[sha256sum] = "1c7c55632768b34e418081690747ba83c672731e77d23351b67fa95d7c2dbfe4"
