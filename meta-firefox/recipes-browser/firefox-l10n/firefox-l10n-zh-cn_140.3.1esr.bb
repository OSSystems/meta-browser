# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c48b63ed6088dc8f717610e702ae56b1"
SRC_URI[sha256sum] = "e79b3403a5927e093be7afff12e29dc249f833da9ecadcae2b56d65f3a499f50"
