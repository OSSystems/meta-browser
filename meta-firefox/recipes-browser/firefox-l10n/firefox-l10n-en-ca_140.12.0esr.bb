# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "9524d7751ecbc60900a2ea6badb75d37d11c19055f8be9594c842f5c6f432567"
