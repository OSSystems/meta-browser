# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "58f9e3a64df78962e927b67ed2586683ddad5d8ad38fe66232446c4b50bf2e72"
