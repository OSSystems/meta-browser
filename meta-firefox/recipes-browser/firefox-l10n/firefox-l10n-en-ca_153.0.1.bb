# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "b842049e26dfaf56682545d9b36e38ee52c86135e14fb630a69039e31b0d0f46"
