# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5c86e1b6adfff7d4eeed1c1928020276"
SRC_URI[sha256sum] = "073cad106fa0343b717f89e8d8ce48626a35dd3204f5e0ea07668995242a732a"
