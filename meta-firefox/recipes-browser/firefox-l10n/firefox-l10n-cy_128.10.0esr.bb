# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5aff67f455ea902e89141621daafaf9c"
SRC_URI[sha256sum] = "05bd8ad4cdf7aff4190ef548d22d4f799e3e365d735549c2b33b18c4e48056b1"
