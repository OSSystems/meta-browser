# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b7b6c368d4cbe89a22ff780aa9b93647"
SRC_URI[sha256sum] = "9d88161e9b5a4da25bbf8f75e83a1bf939af681b180c3dfb289c6d8ad08986a3"
