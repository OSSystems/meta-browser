# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f2faeb61a420f284734ba9d2bcfc08bf"
SRC_URI[sha256sum] = "cd3b348c0776c85c8da54766100633df821c4292343f6904e448aaf3c837aa0b"
