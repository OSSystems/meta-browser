# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0bf490d39c77e2e24bc5047d0e546884"
SRC_URI[sha256sum] = "f7f9f1c0c10b8d1d502c8f04a8afc1baf1e5042e02f1032e874da4769a61d02d"
