# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8a7548abaa1c17e848366d1ff17cbe23"
SRC_URI[sha256sum] = "40c0b42923502a62b685307a886f0ac8db8d116c320835e75c181778a6d77578"
