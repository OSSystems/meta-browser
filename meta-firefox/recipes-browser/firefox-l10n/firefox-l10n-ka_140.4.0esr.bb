# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1e4ca8e9e17ade168bf7fc2cf438d2c3"
SRC_URI[sha256sum] = "88da61bb041ca5538ef969f894949e59c02c10f594fd9aabfe2ca64230b57aac"
