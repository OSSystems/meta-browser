# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "1cb5a679231a6abddd74581d934df6fa61adc75735ce701473f5af7c5c3b9d5d"
