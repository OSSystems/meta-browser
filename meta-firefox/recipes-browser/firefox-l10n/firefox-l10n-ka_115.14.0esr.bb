# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0fe9b704890a3dcbb2958b94e2ff7e06"
SRC_URI[sha256sum] = "9247ee81bf9da72396316b65596425bfe80392f61e55d0b001ccb664c13c35b0"
