# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c1e97cf025bfb0577f1c16c3bf20248f"
SRC_URI[sha256sum] = "1403a73d3b3336b45d6f9191534e338ab8f344f19961aab862efc4691963d140"
