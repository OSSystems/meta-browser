# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "860c68a0e60497185f4fd3c1d417c5d7"
SRC_URI[sha256sum] = "ddcbb55d8a5ec3cf1d84ed2ba6ecb7cd58d2891956431ec530e771246b2f3b39"
