# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d7edef6c6f32af4c4d5e7bc9eb432d2d"
SRC_URI[sha256sum] = "4e8ab79050d1c36ad185dc436333950904610b4c3ea27c5bb3882ebf673400d0"
