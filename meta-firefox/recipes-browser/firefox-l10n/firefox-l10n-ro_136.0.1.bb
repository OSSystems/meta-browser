# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e50650a59f89400367d3ab10cee0054c"
SRC_URI[sha256sum] = "468e6f189c86555acb108de9976dfd4a5eec079a4fb9191d5ba1f3c4865caddf"
