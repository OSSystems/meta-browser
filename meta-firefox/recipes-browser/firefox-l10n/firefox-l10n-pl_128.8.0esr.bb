# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0dfd02084e6c04035cf08400ae573caf"
SRC_URI[sha256sum] = "8705e7e8fdaeb947171044a240d8acc68d749989e494b7e2faae63289e5e10d4"
