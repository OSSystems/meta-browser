# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c5b3e150d7d1f34d4e22b41b1b0fc5f8"
SRC_URI[sha256sum] = "51ad8078840746356dc39572656770fa6c3992922a139d032def0449a77e8f2a"
