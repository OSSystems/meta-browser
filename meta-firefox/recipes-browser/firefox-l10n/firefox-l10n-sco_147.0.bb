# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "87c8420acc3b36e11506e4c866b39c6f"
SRC_URI[sha256sum] = "4f42b759091d08524174665bed153db166fde910a8b53af94e425a46fe73b6f4"
