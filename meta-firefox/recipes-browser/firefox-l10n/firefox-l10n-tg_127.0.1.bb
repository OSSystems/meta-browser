# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f56cb35c8d1969669b33a1d1205d73f8"
SRC_URI[sha256sum] = "1f392ff8ee22d50c0d210d90e18082b1ea9ab7e82d2cdc5c8d35d36575ee325f"
