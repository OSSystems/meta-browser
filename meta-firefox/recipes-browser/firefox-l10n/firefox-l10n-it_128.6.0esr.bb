# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4257a9b93a0549de250bddf77e713666"
SRC_URI[sha256sum] = "d11793197a72d79b2fd94e4fd32f12243c0fa5564247c64c18a551ac36594685"
