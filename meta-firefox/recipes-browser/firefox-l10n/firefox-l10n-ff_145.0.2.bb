# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "daed4b6d6483d6dd609fc3d04f0d6b35"
SRC_URI[sha256sum] = "88644d25175323ad7c1f99e8c75c6c1eefb89091c65b757d1372bf57b0624685"
