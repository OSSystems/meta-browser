# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ad65475e0882176203261a7336ddd43d"
SRC_URI[sha256sum] = "06243b6711ab69f443be6e158007cc5aafefb79070a57fa2e64842698f7b7736"
