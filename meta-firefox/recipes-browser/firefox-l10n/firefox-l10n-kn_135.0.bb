# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6e26f04a2364ce0d6a87deb95929c121"
SRC_URI[sha256sum] = "5f58c003bbb259350c6b8dd9f9bb125dac584df0d29b3810909b2bceeef320b6"
