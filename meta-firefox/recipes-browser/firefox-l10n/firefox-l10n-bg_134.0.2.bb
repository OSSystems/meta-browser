# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aca543443f5bd7cbbfb25c2567562bf4"
SRC_URI[sha256sum] = "e9030764ffd3035d3ab0bf5dee4688898f21ec10fff6776e8db9fc6ade4ba607"
