# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "543600c112c3f470b40a1c69753120e8"
SRC_URI[sha256sum] = "7156cbb607e2f830102ba756d4cf757c3bc4720aa58ab4f0b568e24f626e69a8"
