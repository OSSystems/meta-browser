# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "de487e1796cd4c7e6a23c8e4c4a0240e"
SRC_URI[sha256sum] = "6e334d0b7b29d1f4db2eb42d0e4d335fce614a498c96ce4eab8aa0356aca7e00"
