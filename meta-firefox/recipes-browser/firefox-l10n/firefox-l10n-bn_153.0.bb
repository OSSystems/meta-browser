# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d84f313d8853cd9767ed457bfd50bb44551e2a706540a7cdff6504dba0a10f2c"
