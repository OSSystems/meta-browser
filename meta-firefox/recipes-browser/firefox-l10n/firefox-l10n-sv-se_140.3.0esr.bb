# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cdcda673b24d09af6c1e500411f4e939"
SRC_URI[sha256sum] = "cac8a3327c8764a9cd60c1480f1be6845080c6b36a70c3024184a8adcc3e918d"
