# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b12f118a0c6ef8552ebb158d62dc8fc4"
SRC_URI[sha256sum] = "8bb9f651885c030de8edcc44a8b64ee54978cae38a3995f48b23ff1f5a000b1c"
