# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b20b5adfbd1ca55bfaea48ce300132ca"
SRC_URI[sha256sum] = "11c7cbdff615c6c416ca2cb909d78f610f97489d31dddd93f7063a8d34b47657"
