# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cae533d5c45680b33028a32d40ba1283"
SRC_URI[sha256sum] = "6c57857c6e4a972070d5644ea22ee232d6c289313b5c8a6a9ccbdfb3f18c063c"
