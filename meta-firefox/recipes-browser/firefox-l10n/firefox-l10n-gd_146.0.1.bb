# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7d152db95c7b34311d5412b8c50d2693"
SRC_URI[sha256sum] = "d68ec63c964eb21888de804d875c149a4204324fdfb292f836a3f5983a66fc86"
