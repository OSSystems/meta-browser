# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9eefaf386b6efd27ce3b20b61efc0d43"
SRC_URI[sha256sum] = "1333bd90011d104d0e4f96f8a47535c166e4dddf9a9f80c9eeb6aa3af31bfdb7"
