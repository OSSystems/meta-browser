# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "590b4dfee0bf44046092d5e1773a4a1c"
SRC_URI[sha256sum] = "ec2d121632c8c5f02973c689439a088080f56cf31999ee363bf50a4f6b344ad4"
