# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "516e5fb9fecc4989537a357ef1428cee"
SRC_URI[sha256sum] = "02c162441f393be022a3f75b23268fbaf515864b1eb306af3939ce331a52667f"
