# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "f6da358df77dfed015b6133b2966a7d0c6f555ac5149fa1991095db69187edaa"
