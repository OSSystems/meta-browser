# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "46a51572c0c8881bc3bb3dcae98ac5304c875e08311b0f627b6d9e2148f2d749"
