# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e259ab723af265e947abffca6a696dcce0f1d5c5ea85c6807e5545101ce9a37d"
