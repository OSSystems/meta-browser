# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "f5868b159ebae5fae9f8ba1d8373865cba7d4b7c778fe6aab3b4130e43eef358"
