# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "abb14248fbc3f0016fd83ad0e0967035"
SRC_URI[sha256sum] = "c17b64a307019ec599e55d18d83fc381727d42022f667febe4324b2e30769fe2"
