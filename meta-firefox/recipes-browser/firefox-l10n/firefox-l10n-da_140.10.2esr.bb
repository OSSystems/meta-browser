# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "6330d2e0317fe2c5bb33a41bba9595a85dbc429da814ef433c29f7c5b43502a4"
