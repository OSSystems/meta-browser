# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "11fb538c8ffe23d31090f1f3c3dc5719"
SRC_URI[sha256sum] = "97591154fa7037e687e478837e689f1716741d19ec181a8a579cbe9261fafe9b"
