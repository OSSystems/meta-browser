# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "96d83da2c8b618839181cd46d87c5cb4"
SRC_URI[sha256sum] = "e016f8982d253623f2c4d1afdc7820e2a60eefcbe57c93d5baf01b7d7571a09d"
