# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e6ef65401ab2b0c10ad20dbfbf994bab"
SRC_URI[sha256sum] = "f717afb2d4a2af14b01111d8cdb00704b61731dd647e9715afbf7730753cdcd2"
