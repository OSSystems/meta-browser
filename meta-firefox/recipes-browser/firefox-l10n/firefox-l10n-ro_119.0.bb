# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5f600a88bcdb458aa6c037e0e4f6d12a"
SRC_URI[sha256sum] = "952f0ea69a114d23486537ad18e2a2674e33193dd71bb460770dcc63faad2457"
