# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "978bdb09454a91d400a9560a80759e56"
SRC_URI[sha256sum] = "2a38998b5d92b6fa0e87938fdeadd066fc34e21ebbb74b9171ee4e3e1afb226f"
