# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "719ec41579aadf49de6d2d4381d63552"
SRC_URI[sha256sum] = "666bd953784ef9d0730367f0b0ca5b8c4be1869af16cafce944ae52935e287d7"
