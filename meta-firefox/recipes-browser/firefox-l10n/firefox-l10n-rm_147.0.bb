# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b894a41d842f74cfebda8cb93b55a410"
SRC_URI[sha256sum] = "9285bcc809fae0c27ee2f9b3e74618d6ec0c91bb2cc5de0844e79b33245cb175"
