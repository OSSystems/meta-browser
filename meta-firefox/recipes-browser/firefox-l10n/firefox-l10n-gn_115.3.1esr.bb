# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ad656ad853f307dd03a6a2bfb3219e65"
SRC_URI[sha256sum] = "f6d87825c0145bb44e181fc72edc19bcbab56752613b326632053e7ae11867c8"
