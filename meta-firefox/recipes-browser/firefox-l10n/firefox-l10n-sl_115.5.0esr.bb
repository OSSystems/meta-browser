# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "655972509bb12f8ea83aecbbc127dbf5"
SRC_URI[sha256sum] = "3ba230918d156e3cbb0eb8daaaa43f7cd9494e12e97c81c4f3ebf863b4f1e58a"
