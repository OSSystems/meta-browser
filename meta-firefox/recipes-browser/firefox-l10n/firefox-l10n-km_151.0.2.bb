# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "69b5a64be15fbbcfdd19d384441450a2da0876110335b30a221cc96defb78afc"
