# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "256b39a56f415e91df9229d850072b35"
SRC_URI[sha256sum] = "df125b514d6ae9cea804c76d86d6c108d61c82b2df85a88726ede731d8a44b69"
