# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5cd3b2448fae994afaf9a0f739608b6c"
SRC_URI[sha256sum] = "b70147c00fda49b65b931cabcaf58ea25cb0e0bf09caef27f1944fa6d41c2a42"
