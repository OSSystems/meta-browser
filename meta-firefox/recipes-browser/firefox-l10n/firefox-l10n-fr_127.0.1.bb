# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "23c2f77e1bd19a4e91207c22365a4913"
SRC_URI[sha256sum] = "acba5daa9f2d76f9bcd82b32655267ae071746fbf6e001db8cd98f1569aca349"
