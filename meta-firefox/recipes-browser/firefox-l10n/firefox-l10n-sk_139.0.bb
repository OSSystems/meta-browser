# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d2d0fbf85101e48102e639b003aab3c2"
SRC_URI[sha256sum] = "d3f022a1dfb7cf70077c5c9890b1f7561199a790ac5a474b6e4f974da9cd1109"
