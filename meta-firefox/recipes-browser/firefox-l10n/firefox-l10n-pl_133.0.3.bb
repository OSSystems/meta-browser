# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f9eabf4ba58305cb2cad877cb3b182ee"
SRC_URI[sha256sum] = "60d18357a988839a3d7f45d32a8fd7943703fe957fed0c4b9ee56e49295c051b"
