# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0baba53af367467ca7cb3384049bacfe"
SRC_URI[sha256sum] = "8f5e62557bb1b57292cf6c690c8f3441438613090813bc2394658fca659a2953"
