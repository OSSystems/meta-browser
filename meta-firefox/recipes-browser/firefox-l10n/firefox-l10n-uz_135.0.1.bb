# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "faca4537639d8065b4857a1ab2f19b8f"
SRC_URI[sha256sum] = "2973f6b387b50a8f3e0261313ba861e7ff685b059517c4f45de3380978f4f216"
