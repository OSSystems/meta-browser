# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b5cc791d1e3c41faafc32541d5d02b0d"
SRC_URI[sha256sum] = "21157f2f9e45789ae36218eb2ae22b3d70c28d5872412369d64e8e48c54db672"
