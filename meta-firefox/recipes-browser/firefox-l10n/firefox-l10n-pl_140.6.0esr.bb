# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2ae651329cf5deb7460cb58adc48a40b"
SRC_URI[sha256sum] = "0e32cddca3c62f2c30a7ca25fd6526917c02ab69620c033527c35dbf0395f20b"
