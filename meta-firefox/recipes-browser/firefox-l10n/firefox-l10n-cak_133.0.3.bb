# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bec60c5c13b04908ea6b566e66af979f"
SRC_URI[sha256sum] = "ab00b2448827b82a344a0a72e9000d3894bb1a9e2f12a78b0baf45e1273f07d1"
