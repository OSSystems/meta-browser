# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8595548051655a3695dca616f6c0d867"
SRC_URI[sha256sum] = "2a06c7021a92464c96cbbfdc7c46344f86339d968dc533be55c1c6e45aba6a3d"
