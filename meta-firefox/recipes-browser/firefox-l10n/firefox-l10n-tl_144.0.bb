# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c58792e06bb3c1286f7e889bb0f61a0"
SRC_URI[sha256sum] = "fc9d406b56755b52e29a9a830213a175a15c989ef8d57d49004370d1e0bc418a"
