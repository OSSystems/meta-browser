# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "65bf0fbefe201570fe5006f53509cd10"
SRC_URI[sha256sum] = "d3902ed7f65077d7571d83f2c251da63fca93c90ef9eed82b5bc55eea5358a26"
