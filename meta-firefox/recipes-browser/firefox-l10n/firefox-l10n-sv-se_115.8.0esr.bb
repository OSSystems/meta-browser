# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "68872c28361a895b6d7f32a4f6f16b33"
SRC_URI[sha256sum] = "dcd8c3eaa6cce0da0a0a24b1435ec28f3cfa9feafefb5172389b26351db9f18a"
