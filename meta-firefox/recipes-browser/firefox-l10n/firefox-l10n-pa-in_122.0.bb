# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4f4529a51d5a14228be052ee626dcc28"
SRC_URI[sha256sum] = "2ce14b314d926d0b402cca18612bbe30965042b360bb296b27d95f20c654132b"
