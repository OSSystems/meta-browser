# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b79a8b65390274e9ea0232f34ae4dbd1"
SRC_URI[sha256sum] = "23698cb95a57b8782e78aa7c0f78e6ad903a395563470106729c9167fbc14d22"
