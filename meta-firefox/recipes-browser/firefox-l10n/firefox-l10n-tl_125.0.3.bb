# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "69147427f4db9472d7b85de0b04af9f1"
SRC_URI[sha256sum] = "fc60298b7fcd2c4e2a6e4d80d44cf573ed4ad5e200208f9eed25d4936664a0c1"
