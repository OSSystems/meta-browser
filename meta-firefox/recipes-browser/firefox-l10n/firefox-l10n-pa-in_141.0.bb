# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6c1233967da1b352f10aa8adbf965c61"
SRC_URI[sha256sum] = "8261333f6be1ab5d2ae0094429106069cf60f7fecdc744530eea3aee891c436a"
