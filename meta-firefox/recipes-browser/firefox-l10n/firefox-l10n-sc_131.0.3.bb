# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "11872fe135ff793fdb0b955e90f6b5c5"
SRC_URI[sha256sum] = "8fff3163f4bc9fca2ad9b4c448b5495a0293f313149f26e11807a6d882d50558"
