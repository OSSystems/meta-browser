# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "da11e619e30cbe198a032bdf7b04cbee"
SRC_URI[sha256sum] = "a03a4beb4cb5abbedf97f6b2a754f2f0fbca8d9ca1eacbd357245d2ab29a0c81"
