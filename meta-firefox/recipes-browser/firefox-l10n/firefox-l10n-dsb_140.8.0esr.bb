# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3cddb8c787cbcc39cdbf7d40168e2f88"
SRC_URI[sha256sum] = "9acae17db75e2cab3363e98de1a13d1db690bf37878ed1e7fd917b326caac694"
