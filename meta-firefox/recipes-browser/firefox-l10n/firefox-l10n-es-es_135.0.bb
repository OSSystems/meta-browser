# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5434c998b1501cc3b0bf2d70ac277eeb"
SRC_URI[sha256sum] = "1b949d425d015d0a62ce0a958be6d03e144bec2605b079343c7a005fcbfab30b"
