# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2763dbf7a66c9c0597b040f186712c30"
SRC_URI[sha256sum] = "5ae24b1df6a1c0f516699282928b176c1f0deb312984f212fc0afd8c4819420e"
