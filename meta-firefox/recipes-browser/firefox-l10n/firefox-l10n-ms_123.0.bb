# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4c7d0ee1f5505f2ca2732d304c2cd160"
SRC_URI[sha256sum] = "0adacd984921fe990a9bbc4e1fd45a0dc7dd7f7112da9bb2ea3248b8cdc7e158"
