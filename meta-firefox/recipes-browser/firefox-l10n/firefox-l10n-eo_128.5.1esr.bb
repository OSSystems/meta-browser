# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3ec0b5c82325c6318b1d8376efa9499b"
SRC_URI[sha256sum] = "f253dab4ad82ba3acb4b58f240b984b00e50455d69b6772e63135471e839c450"
