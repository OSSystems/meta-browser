# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "85d1dcaee2f918986fa32cbc7a32494ce8157b64abbe4560c4b14b922c487ce1"
