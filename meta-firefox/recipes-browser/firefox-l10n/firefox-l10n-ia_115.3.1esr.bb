# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "023458326e05c65afb95377c059b174d"
SRC_URI[sha256sum] = "a4e2cdeefe33033071e1f8e4bfbf3252f7a626368cd341bec34c09be7907f650"
