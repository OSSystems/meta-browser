# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3c5092cbfbfc4389e9e89f519c44cd23"
SRC_URI[sha256sum] = "2f04683ccdc9a315e78b5e0ea093cad02cc23ef007b88c7a9fd2a080c0fb0228"
