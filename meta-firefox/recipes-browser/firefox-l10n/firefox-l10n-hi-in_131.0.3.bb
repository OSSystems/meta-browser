# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "49d9d1ccbb432d6205351bda575497d2"
SRC_URI[sha256sum] = "f7ad4b26b3b2403fe2310cada47114878519abb5c68e2969bedf3be2053c2fd6"
