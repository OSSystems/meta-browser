# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "97632a6ce1ae7765cd8026dba68f83de"
SRC_URI[sha256sum] = "aace86b953ae45773d501f608666a9fe2d609323bed58d7aad49ed1056055596"
