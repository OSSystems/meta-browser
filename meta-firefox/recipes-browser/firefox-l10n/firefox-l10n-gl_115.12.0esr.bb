# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6d749597c5928874d34e8607420dee55"
SRC_URI[sha256sum] = "6253aa5c4becfb6a6e839fae16a72337b13e650867539c17c1563c996d5c76fa"
