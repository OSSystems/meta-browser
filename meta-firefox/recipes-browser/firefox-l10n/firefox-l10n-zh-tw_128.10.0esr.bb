# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1a7d1f64f4339ea2cfe94e549365ebbd"
SRC_URI[sha256sum] = "e1863070b65fb6caaf5c31bd7c4f70409445ff02444083da0b7364228c1a0fec"
