# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "298d96cfb6dbf7d439797102c144b8cc"
SRC_URI[sha256sum] = "41100715b15e512b21fe122ed4e890a78ad61e7d588feb7f7d847b29b328a17e"
