# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "29556a946555bd9cab837b46a8557078"
SRC_URI[sha256sum] = "4fb69101172d1015954c05ff85d3e1ad4c3407d85c41721ecf78d8354d5f474d"
