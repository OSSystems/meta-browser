# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5d791cc0ab8e5da03b867de3096f64c6"
SRC_URI[sha256sum] = "92826ac62b8f3308a31e87f8cd3cf8ba88da6134b72b990a35a7d9682c42d484"
