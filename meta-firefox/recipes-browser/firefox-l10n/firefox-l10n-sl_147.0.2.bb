# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "25030c66ffb1bce7e9fcba39d3463353"
SRC_URI[sha256sum] = "ab61fbe8ccb7aba5455651c49053409987606fbba345eb853d6249582fac6442"
