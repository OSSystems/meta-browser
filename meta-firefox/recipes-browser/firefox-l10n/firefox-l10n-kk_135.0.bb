# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0691a2be73e96cc6afc6e89ed86b4ffd"
SRC_URI[sha256sum] = "18a8c092190535c49821c3f6a938e3fd617066bed78989e512910f9a98592ff6"
