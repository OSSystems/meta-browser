# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d8a22b252acf5b363dbba8633b9a34bd"
SRC_URI[sha256sum] = "2d3a13124db0f178ee86775d2b0123cffe63d93a646477122f3ac8b24fb6b1e2"
