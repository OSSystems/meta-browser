# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9d46989b92a48d8b85cbd9a754ff9c69"
SRC_URI[sha256sum] = "17d9e18c36c41463ea44f6c3aaf9f6b0fa5d195827ca8b629efe76e294b865ed"
