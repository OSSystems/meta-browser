# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fec1ec8515071aa7773f66ce13abdbf4"
SRC_URI[sha256sum] = "664b996f34f4f51ba54d9f026a642de5b1862b521388f529e14dbcc0b6fd5ae9"
