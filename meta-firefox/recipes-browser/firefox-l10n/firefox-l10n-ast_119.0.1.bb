# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5464629bcbf526587fb9e87099cf413a"
SRC_URI[sha256sum] = "1dbf30140805168028f8bc8fd5c3ab19c6c5fd8af6f415a86dc1e0ad642b9d02"
