# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "93f61a45c3b76a803b28159484a905d55078893431d7f8d5500de1e44d8d0395"
