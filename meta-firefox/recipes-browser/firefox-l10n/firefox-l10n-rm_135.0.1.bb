# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e0e190f299cd3921df552cd2c01c9f76"
SRC_URI[sha256sum] = "4382d2ffc4d05e7f12df8b5bc3ac0b30c04be7ac430a725004273cd4cdf08bfe"
