# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c77af0e38b30f6a163ffab4b9ab89381"
SRC_URI[sha256sum] = "27e4329e73e11cfc37044c68eb6927e100217b144b6fea0ac24c4c775184fee4"
