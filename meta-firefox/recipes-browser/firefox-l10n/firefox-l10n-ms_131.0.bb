# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b7f8b557e4d04c044abdc84a460a3467"
SRC_URI[sha256sum] = "bd541452a29fa10188ca2004c5aba5b880fea5398ca92d5a0857d435d3bc489a"
