# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2a0e0e641a1d260fe2760e642d8a1ba2"
SRC_URI[sha256sum] = "00726d29ecf0243f823c1646b58a951d4e8c168c1fd1040a1b6f338eeacbfb8e"
