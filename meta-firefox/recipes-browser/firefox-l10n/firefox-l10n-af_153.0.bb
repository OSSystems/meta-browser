# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ac3af424b9b19da281a49936feccf4fa03d03223575ba7e86e071fce8b06ce87"
