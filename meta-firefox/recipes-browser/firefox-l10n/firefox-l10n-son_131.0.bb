# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5c062e227d1224ffa8e48aed1eb4795d"
SRC_URI[sha256sum] = "340736924bdbf825ab7c6e8180047034c4e3a1de2c89c16946f63e5145d13a0c"
