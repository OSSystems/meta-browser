# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "504f21dd280e25694cd73ede4efffdd6"
SRC_URI[sha256sum] = "185e54660295d0ea252b32a1dbd2272ed1dbf2feaba78d8f024bcd71f2a2aa81"
