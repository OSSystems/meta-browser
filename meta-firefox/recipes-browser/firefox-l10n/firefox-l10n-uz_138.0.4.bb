# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "df83e3c4c731094c71c53ff363067181"
SRC_URI[sha256sum] = "14d62b0cdd89638071c9aa3c9d3cbbd3e3f2654749e637153891b54c62acb624"
