# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e4d220b61fea7c08f0b28298d620982c"
SRC_URI[sha256sum] = "70dc16180bc6cc0447dabb2b9a4b64146ef80ff664ab3b2a2b934d718ed6dfef"
