# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a1ec1aaa0155b0546b8f3b1dce0f4cb4"
SRC_URI[sha256sum] = "13ca4e64c2dda4c874f89fbcab18731b5556a8bb9eda50a3b5a7fb3b19e525c1"
