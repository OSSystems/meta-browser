# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "14ab314f4bffac1ca7e0a54adba1077d"
SRC_URI[sha256sum] = "a703bac0ae1024ce06da75094a52f5f3825a675f64c1d262d83bbe7d7247b58b"
