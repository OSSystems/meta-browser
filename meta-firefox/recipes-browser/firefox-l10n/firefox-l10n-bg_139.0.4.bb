# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c4b397aefd06e37b30c66d985d9cac92"
SRC_URI[sha256sum] = "148a3d5c556c853fe9e5cab4703d9d95f87c706c18002625f558775044c0ca8d"
