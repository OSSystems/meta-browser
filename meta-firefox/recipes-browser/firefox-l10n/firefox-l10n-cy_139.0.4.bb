# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9209afd884b31d3d888c0b624367b2d7"
SRC_URI[sha256sum] = "41631d30fc843117bb0abc5c895a49a0fd1579ca64c75d3f93d108b89b60cdd9"
