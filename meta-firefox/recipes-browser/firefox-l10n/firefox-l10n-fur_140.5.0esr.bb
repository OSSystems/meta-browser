# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0e2876793e2176600c3a3005a1aaec5e"
SRC_URI[sha256sum] = "45c55edaa949519c8f65df098afb01d2b63778a412a3cf9181c5e8c2ed87bf9b"
