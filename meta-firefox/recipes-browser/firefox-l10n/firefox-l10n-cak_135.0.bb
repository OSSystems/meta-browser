# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a7013e1e799dc47af235cff01333eefc"
SRC_URI[sha256sum] = "e23ab2f663be37b36da193d1b25710ea7593bc91601361784d1d7cc391358ddd"
