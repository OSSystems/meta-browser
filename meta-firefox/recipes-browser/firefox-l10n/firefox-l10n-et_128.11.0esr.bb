# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bc331cbb27349a068c6ec889cd58b9b4"
SRC_URI[sha256sum] = "d12956b7de685e91e406cb977515ef889fd55c1fe99370d2cf9329dbee5e6a60"
