# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "350b5c213e9b1f63dc5ad203148390b9"
SRC_URI[sha256sum] = "ec76f62f40db2ce27ce81d1175a5468143064a58049c52f8a210c1ca5206d7e1"
