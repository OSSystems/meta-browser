# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "268065cd280e9a4e223ee671f99aea0d"
SRC_URI[sha256sum] = "cf114d8165a27fa31e6be422eb7bb4eaff3ec1148db86296deed125a46b80267"
