# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3e2000b4ba92dde0813e8f85e317cf38"
SRC_URI[sha256sum] = "9020e8f6444a10520211e3fd8e85f6da7d1e2f631e10309e77d4e7eed7a6622f"
