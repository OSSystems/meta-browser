# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "393aa714c72505b109159e24b54f0a90"
SRC_URI[sha256sum] = "5b43fe0f2ec9125eb02ae65d1f806571aed79240e7ee91582e24620065f43ec5"
