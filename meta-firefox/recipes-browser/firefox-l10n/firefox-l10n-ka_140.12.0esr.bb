# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "749ffe02236f480a5d604f72b1712bad0535dbbaed91d60db31fc0ed632da375"
