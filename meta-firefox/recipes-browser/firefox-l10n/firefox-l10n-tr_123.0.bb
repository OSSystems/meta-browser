# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "86eb2dd1ff8cae0c091590190e47b2be"
SRC_URI[sha256sum] = "55ff888b2edd4e6b294d81e99769f98aeddef06154b2dc8fa7142b2212834c58"
