# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d7d315930ace675382f992f6f200086a"
SRC_URI[sha256sum] = "ccbb94eb7d3d63fafe7afdfaaa8d74481e6a782923e775398d3b31abea1a8846"
