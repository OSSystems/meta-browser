# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1dac0f562f08f18721b17fa9f8f3f0aa"
SRC_URI[sha256sum] = "ed08e5d8c087f9e5a4bf0576c3e94603cb49bfcb17fac5baa412ee35ed342403"
