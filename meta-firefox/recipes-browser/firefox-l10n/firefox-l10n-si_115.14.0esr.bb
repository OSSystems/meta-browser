# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "90fda76c7b193e31bc0593e88ab2d3b0"
SRC_URI[sha256sum] = "36c786911837dbf2229674e8a3f9a9882fa5ec23ce1713910cfadf9f1b0eab4a"
