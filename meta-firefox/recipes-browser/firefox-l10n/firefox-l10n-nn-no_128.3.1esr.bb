# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "79562d10149f1e3f2ca3ee64c7031ec9"
SRC_URI[sha256sum] = "7540f7af3d08a073116625834af1dfe874c47fe6994dc3b8b7d4dca12523b390"
