# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "35f6c7cda4215fc0156147ca840aece0"
SRC_URI[sha256sum] = "ebc37553087054cd3ddaea7fa1b5514ab7eb7a3e06c33676f399f2892a0cf1b8"
