# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "97554016cb79d66b4e5d5be0cb87e29e"
SRC_URI[sha256sum] = "986023175c27352527fe9033abf9a8c1499c950bf5f5927ed102e7e703a3991c"
