# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0562185ad79d2858e6b790f916141b7b"
SRC_URI[sha256sum] = "37fd1eea391340a0449dd739b6032c50f4370f1c608ff823328cb35aa9e47667"
