# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c81c30e443031de0f35f88525282a77a"
SRC_URI[sha256sum] = "8aadc41292e1b2ca85323af5e76640a214e11b8dd213a18302c5c204c8803f24"
