# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6000591a0291c1a36b145afd9b76be6f"
SRC_URI[sha256sum] = "68854f403559164f5017d2f5020c54b2e870a8f4d0d0506c2a19ef7c25fc1d36"
