# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "983462f39c6c81c03bfe5a580da48fc86dca32fdce89cc309b6238c38930ee78"
