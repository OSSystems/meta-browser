# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b02fa4e9e1d0bd73021148e0b5175e35"
SRC_URI[sha256sum] = "93a3d63c1d4096bdf7e8cd0393c869ffd435f4ff36dce554eced7f057b5a73be"
