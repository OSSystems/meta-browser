# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "71b530369f16f8eb68661f9a40aaf907d7190571ecf46722244ddcf10f7158d4"
