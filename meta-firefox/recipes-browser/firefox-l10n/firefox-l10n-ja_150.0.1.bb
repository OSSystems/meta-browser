# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "5348628a99d6cd56edd49b876ecd843fb0d1ee5ccff91c32c3ddf57d719fd820"
