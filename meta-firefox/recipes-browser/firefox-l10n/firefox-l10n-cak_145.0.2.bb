# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c0da8752957bfcde1ed9b98109a94742"
SRC_URI[sha256sum] = "4c5a1d8e959405faf1411c7f01de1d8c9fc5c99700ff9764001734a0ac6becc1"
