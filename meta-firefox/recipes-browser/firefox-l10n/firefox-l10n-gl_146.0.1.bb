# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "282e3bd728d7fefaf9cb471eec7ceccf"
SRC_URI[sha256sum] = "86ae29e16e5db4a8642cdd281b20762bc6d267cdbc5f1dc58765c5c610d8b0ae"
