# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7cee6f492d5dd9156c85cdc0d8fd3ed8"
SRC_URI[sha256sum] = "8253d4b3199fa2adfe8eb5ee48a1745a9419cdd05aef3b5e15c7a50ee0c16798"
