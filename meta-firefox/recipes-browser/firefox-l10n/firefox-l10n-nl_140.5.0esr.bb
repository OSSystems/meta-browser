# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7159172db2c6e7fde93c5539c44d5e3f"
SRC_URI[sha256sum] = "eb907eb80a2977bd935b67ecf56d5074f739dc560af8d7eac3a3a76756518091"
