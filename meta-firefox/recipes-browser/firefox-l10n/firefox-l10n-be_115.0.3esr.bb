# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "995abc917d094fb50c8a42a584b93bd6"
SRC_URI[sha256sum] = "38b56559fbace4fa8e4f533abab331720cac9448c15cd8fb307ce14365e4662f"
