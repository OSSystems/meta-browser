# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "07e8ef52626ae4248b063efc34a17d70"
SRC_URI[sha256sum] = "4cde24d859344d386f1f52e393ae0d3bc139b6e80f521bda590b443a965e3425"
