# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "114410724e2250726d3ff351d81ddcd7"
SRC_URI[sha256sum] = "2677f63e13969c37687b39ccd10f48084ad95692033e727e98b12649f98e130d"
