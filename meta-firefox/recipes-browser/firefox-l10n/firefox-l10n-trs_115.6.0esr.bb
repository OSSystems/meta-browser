# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bab3fb28edc4ff12b2cf0819b3a1470e"
SRC_URI[sha256sum] = "1a6cecdb89309e816ba357afec7e854b1ced6575e433043c0382b99a3fcc9700"
