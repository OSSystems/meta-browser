# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2b5be5b27f901ffbeb48cb94ff9bc2a5"
SRC_URI[sha256sum] = "facb25de6e083c2dcc59526873e71706e8b5728313dcedb58efb221b8d1ec86c"
