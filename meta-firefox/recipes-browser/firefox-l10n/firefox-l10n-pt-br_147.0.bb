# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "83e40ff076477a6e9f157993c27a4d7a"
SRC_URI[sha256sum] = "54edb973b3beee3736883f4e285b5a76a6897631ad858f93e8e4d082e4178478"
