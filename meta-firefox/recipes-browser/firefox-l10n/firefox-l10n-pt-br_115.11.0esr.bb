# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "819d8efcbc29885cb984a14cae0c74cb"
SRC_URI[sha256sum] = "7be87d933b28f30257ad7c0cd3102d6f7d33b836d7ec19442578abb3efa32e64"
