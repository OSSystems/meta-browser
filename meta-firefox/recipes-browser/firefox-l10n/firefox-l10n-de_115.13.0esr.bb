# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c2174aedb0fd565709e27ed7e17c899e"
SRC_URI[sha256sum] = "c539e0a1d354ea270f5b86d253937d4d29571bcf0eccc2367d7d03b589f69df7"
