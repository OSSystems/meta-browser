# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b52aa0f0a92431a1570c5a9b08f4f677"
SRC_URI[sha256sum] = "97c2913e8d258aa1b0967db7a7e68afeebbdb04155820a7f2b28a415bd7488d2"
