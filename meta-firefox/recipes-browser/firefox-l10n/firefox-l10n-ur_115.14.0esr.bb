# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ff813c15c25ec5bfe3fc294c5787f29d"
SRC_URI[sha256sum] = "b9825967c9bebe36daa55ec52538f057d3109a7e3a28760ff8dbc0f91e724b5b"
