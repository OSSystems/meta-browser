# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a455d09c2084e52822b1adf78ff220fb"
SRC_URI[sha256sum] = "10c7c62a68904e971bcf9995aa4d0d3c3ab0c4cf4d0165a51d2083de9f7e46a8"
