# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dfdb1c1fedd57feaca4158da4b090a95"
SRC_URI[sha256sum] = "e1c78cf5144f28b56ba921b79d614366da729560051fafb82edea643eb42a8ff"
