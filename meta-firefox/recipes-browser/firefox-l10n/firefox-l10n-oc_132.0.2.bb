# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ca7f49df27a0e8d185b3f4835bc5ebee"
SRC_URI[sha256sum] = "9aedf9badfa38c255f52dfe0d2e02309907cdd923ab7040942ed9b07f71d1105"
