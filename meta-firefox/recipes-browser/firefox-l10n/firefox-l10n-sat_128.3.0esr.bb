# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9eb15e119ba71cac80f60b0ee9c5f31c"
SRC_URI[sha256sum] = "f03b7d8ec2d7ef3855ad893da555b3a5866bf86cb9effc13830aa5e57060c4c6"
