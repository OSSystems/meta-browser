# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7cf7934b28796d81764f381fb8d1879f"
SRC_URI[sha256sum] = "56d5ad49d49b540fd5d8efaed721fba263d7756f0864f53271f27aed8917a3b6"
