# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6e3a7dc6efbb2b1df124ebb1742140fc"
SRC_URI[sha256sum] = "f6de2421676378d148409458e5fb337824f838fb6606b63064dab50a882e1cee"
