# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8697bfd073cdc5d5b6599cec13d39b12"
SRC_URI[sha256sum] = "2f163c6ed7224f69f650982d31045a78f4889b333520161dbbfcca3abf6640fd"
