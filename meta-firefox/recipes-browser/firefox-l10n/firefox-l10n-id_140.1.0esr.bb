# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "77196ce6c5ca6bb789006d85907e8d09"
SRC_URI[sha256sum] = "e777ba30f68bc0c66c920fc142833281e61599ff83a9985c0346ce56543a50d3"
