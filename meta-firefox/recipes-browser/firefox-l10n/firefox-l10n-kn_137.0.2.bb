# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "add9c3165852d169e0e683dc236eaab9"
SRC_URI[sha256sum] = "2d5bd7fe1ae9f0f6fda04e8511199d98431d5199c0771b83fe68692aac90b806"
