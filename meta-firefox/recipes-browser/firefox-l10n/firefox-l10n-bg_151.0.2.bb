# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "39c25afbe9bce0f8a06783008f65e3373ac9fa35136e676c2aefa73c47a33a70"
