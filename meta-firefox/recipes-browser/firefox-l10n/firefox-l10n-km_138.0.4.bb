# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e807e5f3b673fac861b0b053f3ec53e3"
SRC_URI[sha256sum] = "3e05b2a25b0cbd31c6ae7d422dcc4fea2d09fab04832267311f946e79d6d1507"
