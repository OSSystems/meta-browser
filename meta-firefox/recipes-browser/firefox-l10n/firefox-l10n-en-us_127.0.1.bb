# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7ba0019996c9f1be6fd350e51b513d9f"
SRC_URI[sha256sum] = "3385bf937c2d0b594715c86cc0dbbb3fc37ca33ab964fab6ec4d81b529a283f8"
