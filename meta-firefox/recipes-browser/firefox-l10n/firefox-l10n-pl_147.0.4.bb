# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fd377e4aa069ca511e2c6ec2f92727ff"
SRC_URI[sha256sum] = "20d57477aab1481d8abc25a71fcda6eb1db0abc6158dc87f7d748c819c5fd3d5"
