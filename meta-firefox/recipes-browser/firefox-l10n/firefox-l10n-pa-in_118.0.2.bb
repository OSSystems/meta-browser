# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "00752722866aa6f99785f76c84b9d013"
SRC_URI[sha256sum] = "d86ea5149a0249bf06c3d4341b7f833052e00c9a8120971a5ac0f40d83e97521"
