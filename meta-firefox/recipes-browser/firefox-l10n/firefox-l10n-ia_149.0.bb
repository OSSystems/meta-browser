# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7e86c6f086abe425215c9ad1084e4e82"
SRC_URI[sha256sum] = "438ad493c7190c4f65e5ade6ee7ad5d8f04cd026a21aaf35a637da78beeecbf4"
