# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "75cb97e623a30788b2ce07251b6af69a"
SRC_URI[sha256sum] = "d3952bbe0d9e3d949ef6e026bc73d659aa924af6ef28ff391a79770583276257"
