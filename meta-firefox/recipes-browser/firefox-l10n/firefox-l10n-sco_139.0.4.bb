# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8b0f3d1ae279bb20ffe7cd6ea2b6efab"
SRC_URI[sha256sum] = "df56cf0ad45aab521b981a0d4f8c7bc128efd95cce387022728abf29f8555f40"
