# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0a948ddc0f19a54a9729277b1bad7665"
SRC_URI[sha256sum] = "17f65beb065771e93778430cbe7ca4f634d55254dbfdfab68a22a1eb091d2290"
