# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c8801607ff0389a495c6a5914d33edc"
SRC_URI[sha256sum] = "1eeda5d8b798f0b6197a3177e4cb07df8fd1f5dc1c454f594d48e4b526c81309"
