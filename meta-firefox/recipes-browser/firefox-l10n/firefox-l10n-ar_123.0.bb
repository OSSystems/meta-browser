# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4004e4953ee7d9a120e71cb6dc0a6fb6"
SRC_URI[sha256sum] = "5c6e624d9b2874346e75a19821848023f9a3e7ae4ff8ab8559de8961341fa446"
