# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "defdca72b4eb6aa954b5b26408c2f8cd"
SRC_URI[sha256sum] = "b3ed9d07ff7b3ae531e3367656f5a5205a3ac54fb890bbb8741583178d9dae09"
