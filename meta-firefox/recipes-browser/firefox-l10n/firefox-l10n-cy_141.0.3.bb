# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "de5fe0eb47e3d1862406a0585ecf91fa"
SRC_URI[sha256sum] = "4ef050d02b0fc53862b8048f9a19eca979507c412328c5b733207a4d4651738c"
