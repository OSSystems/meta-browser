# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d411ab2c4c6d6a03bb7747104b810e5874e9f5db8d5c19708fe45e495093ca8b"
