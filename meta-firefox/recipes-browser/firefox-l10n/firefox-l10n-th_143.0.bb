# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3148b7d4c92093455af0e9fe9292b70a"
SRC_URI[sha256sum] = "c9eb101a5892cecf24dc56f32f1c6692adc3ee9b5903f1c308e18c5520fb241a"
