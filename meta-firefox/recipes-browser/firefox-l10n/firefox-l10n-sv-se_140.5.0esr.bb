# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7fb439cc6147e266074f0baa57825b9d"
SRC_URI[sha256sum] = "b3d740246ee01b61979b96a59c1828b7585ce1cfaf46831b90d2e93e35acba77"
