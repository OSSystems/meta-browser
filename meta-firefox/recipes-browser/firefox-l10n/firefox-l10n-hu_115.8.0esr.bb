# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "76a53cf564d8412caf6dcb3b8f614dd0"
SRC_URI[sha256sum] = "550c0dee74ddb42d407b4ddbccd26675c3626eb675774fde3e3c8cc6daf0e86b"
