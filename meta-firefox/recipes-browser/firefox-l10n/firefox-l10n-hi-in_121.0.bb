# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "70198f5a7cd628c1575530bc3c84cb9e"
SRC_URI[sha256sum] = "b8d3bd91a6d9ee94a6721e2643cc2f24412b19f3d47efc1d850ea3e2368dd88f"
