# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "43b096206ac3a4f52af324cb12128cb6"
SRC_URI[sha256sum] = "eaa95f7b3cea2d339ad1ab1221ae5cf0dda2f26d72631fc8d737cc9da1d69790"
