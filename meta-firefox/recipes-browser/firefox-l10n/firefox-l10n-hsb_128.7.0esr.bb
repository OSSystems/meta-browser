# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6066d8e3a1dc92580bbdc6e8fa91d799"
SRC_URI[sha256sum] = "935127e40dfa33fc75e4796ef57b693b549e0926532270645f4639206dd34bd3"
