# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2e271e7c0a423d755ab7342a9a125fb3"
SRC_URI[sha256sum] = "658dd0ad8909789ec997f32ea39eb905b3a83dd0a70a4e8711a3d0844d6140b8"
