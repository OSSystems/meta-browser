# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a047dbac479b648fdffe79beb5bc1616"
SRC_URI[sha256sum] = "a42a0c3e93d2c916a593d146da48fdaa75bfe70da3508d4572958a7c9d4ee789"
