# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2aff1119b52940d7e8ca6c138d73ff39"
SRC_URI[sha256sum] = "197cde72442186df56116dd180fec7fe9c37638a4d7aeb3448d4f1ba6cc0f3c3"
