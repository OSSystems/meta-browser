# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8d333bc1c25a2d8a539a252046bf8e75"
SRC_URI[sha256sum] = "a1b415a2323db7a4195a7960d8ddcdf5b65548af283f1bfc6cc43ca3b659bdbf"
