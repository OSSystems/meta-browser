# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4930ad298b1bf6a7a0105061497a2cee"
SRC_URI[sha256sum] = "600f981ce50883b0a9dd9c9dc9832a88978941a71a31a8a7c22a0a838581dea6"
