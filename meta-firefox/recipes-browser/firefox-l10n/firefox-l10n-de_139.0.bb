# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "66a5f00d45deae08774edbbd62b04feb"
SRC_URI[sha256sum] = "faec21aa9d0daff4e333069de9caf2fb9948a3f6b6e08445545001dcf1a4a728"
