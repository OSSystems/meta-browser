# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6f034fbc2893b022fe43991c1884a573"
SRC_URI[sha256sum] = "59cf421b9d93cc9a0bb77e22b5f96e5d18e998f707a6d7ea8bc2cbd2b7d45650"
