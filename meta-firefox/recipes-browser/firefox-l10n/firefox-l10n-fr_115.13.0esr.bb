# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2a5dc7a9242106cb34b6f73c29ce7238"
SRC_URI[sha256sum] = "25b1dc607a6fab489734bc80b6bf7248e0c2a136694fe0ddca6b7e68df1f723a"
