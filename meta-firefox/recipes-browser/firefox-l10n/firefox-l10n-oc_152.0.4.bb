# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "8d1d910df0fc0ae7fe00d6bd9be875133e7374a10c9709b905846b1bb3a03786"
