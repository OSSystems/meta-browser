# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "61a4d433f71a7a71eb67b0de466b7599"
SRC_URI[sha256sum] = "664da5c4ccee1399428c8c53cb97916eec4eaf4672697b53c49233616de136c5"
