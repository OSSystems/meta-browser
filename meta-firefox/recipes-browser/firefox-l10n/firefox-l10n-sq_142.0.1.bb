# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "672f6162e5c1c8cf40b3d02f3bc040a4"
SRC_URI[sha256sum] = "e19ef23c2e46915a2494ce7a96a01249aced66aabdfb2006e75c802b89a2a9e7"
