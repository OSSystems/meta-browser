# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "31c70bbf411432e9b3c9dd4c07b804e9"
SRC_URI[sha256sum] = "fc28c614384641add6742c94bcd4af7a26064c349cd2a5f02bbb1b567f4edcb8"
