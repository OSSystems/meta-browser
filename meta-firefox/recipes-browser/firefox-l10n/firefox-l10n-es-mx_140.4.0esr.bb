# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ceb7ba51cf1e923abf9ba99b29c3b854"
SRC_URI[sha256sum] = "dfcb91724c0f195962ca57ce840fc84d31de404c85c0838ec08271ebcfdb8827"
