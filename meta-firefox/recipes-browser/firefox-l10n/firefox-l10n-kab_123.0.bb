# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "38ffa756d84fc176ecf1556d5bd13201"
SRC_URI[sha256sum] = "8da51f87aa7c3358d3368f03d9cf117a53e44d2ad30b3436651a8b0d6f8c9ea4"
