# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f7a674fe233e1d52d072a82768cbeb43"
SRC_URI[sha256sum] = "a9dd2ccf635cf6fc3161d3ef83e379cc2d3f9f530656f8b0d9578151e88f71ac"
