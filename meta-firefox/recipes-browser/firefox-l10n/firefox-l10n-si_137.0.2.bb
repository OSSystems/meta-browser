# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eda747872c7861518c1cc4c528ce8ec8"
SRC_URI[sha256sum] = "1ecf7c4d6497d73a844d74262b4e490ea2c55db0021f582129266ff796487574"
