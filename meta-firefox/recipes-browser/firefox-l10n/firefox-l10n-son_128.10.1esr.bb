# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aecb85b901529aa15bdd207e0cbe9e6a"
SRC_URI[sha256sum] = "d931ede927dd4a7643c2595a390d10c499e82a11d837c004dd5a16554429a6d3"
