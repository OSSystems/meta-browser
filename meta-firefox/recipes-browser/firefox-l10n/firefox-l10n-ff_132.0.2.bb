# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f4ecf9cbf5ff3972b553c5f06eb80400"
SRC_URI[sha256sum] = "4438da28f6cc9f19f4292191ea963068a26a376e3512fdd7b68637cc9db8badd"
