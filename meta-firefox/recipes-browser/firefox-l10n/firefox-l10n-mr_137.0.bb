# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "be944926ee8f1175f715e6e74e517e58"
SRC_URI[sha256sum] = "2d109042cb875ef514cbea28de2632febe11970d824899cc9cd4c298bd5041f7"
