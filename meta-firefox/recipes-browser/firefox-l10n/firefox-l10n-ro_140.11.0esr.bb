# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "53330be7053455de37f50866db80927e098f976d537dbbcb991f3fb761d5e387"
