# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e44fc5da7c3beb44eab1f96e7e0dcae7"
SRC_URI[sha256sum] = "efa495964e86cf9e5f256d90af8b8e1ff16bd58ffb3212b70bdd46a85597ca1b"
