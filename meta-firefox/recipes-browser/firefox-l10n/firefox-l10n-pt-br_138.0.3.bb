# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f3e645a9d18daac37799e52b0d48c106"
SRC_URI[sha256sum] = "7c90d3b627de5a323399e579ebef83cfea2348ef2aa0d7cbfb3d21363d3fbc0d"
