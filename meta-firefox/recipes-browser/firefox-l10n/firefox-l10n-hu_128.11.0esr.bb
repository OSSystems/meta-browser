# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0b9c3462e633e111c3e34d653d3eb17b"
SRC_URI[sha256sum] = "95fa79f3488904dc950b4e59cb08ae238a763d01e17a6a8493cacedf485e8cf2"
