# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "10012d8e07ee985b9bde1fbd6de1291c"
SRC_URI[sha256sum] = "801f73750a8d05b9c891541f2a3175b7d2d553d60239cc4edb0c262e6e236435"
