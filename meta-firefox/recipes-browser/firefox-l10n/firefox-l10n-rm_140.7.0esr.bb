# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ef47f8c34301bd4f8f47c8967b06f6d8"
SRC_URI[sha256sum] = "13a74c5c7c12e7e90803a36994d75ad9d9a8a1d42cbf4524c21103d87b75a1ad"
