# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "294977a3c9580f5581217fbaf3e59369"
SRC_URI[sha256sum] = "88631376e47c894c27ac75c70f50eda490959971682a178282cdf6c19d209660"
