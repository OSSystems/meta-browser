# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f6be69cc53f840d081b265e972f4ce46"
SRC_URI[sha256sum] = "10fde1cd808e679ef08259d82411b10727e366787f43bf6d35db0f046fb4ac79"
