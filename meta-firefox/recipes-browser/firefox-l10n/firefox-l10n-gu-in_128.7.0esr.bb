# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "871b01e1b68d9b2f867f0262126a6637"
SRC_URI[sha256sum] = "35a01d18e6fc3ef87011f4168333a0155cd88f1042a6df30f9d576d219caf182"
