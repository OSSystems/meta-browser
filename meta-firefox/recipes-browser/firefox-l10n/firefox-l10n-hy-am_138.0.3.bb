# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6a4d973246b2fb67ac5122b859bba857"
SRC_URI[sha256sum] = "e22a2275adda99fd6ab30747ad829a26cc2ed5eff63cd302f86cc2c5b1d2b2fb"
