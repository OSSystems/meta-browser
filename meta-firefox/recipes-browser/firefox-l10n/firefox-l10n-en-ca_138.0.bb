# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "244a31938fddb9a6bb285e8800e79fa2"
SRC_URI[sha256sum] = "990307f4b8b35d9776cd465d8aafe195c531357f46df7947b6c8befe9fc962c3"
