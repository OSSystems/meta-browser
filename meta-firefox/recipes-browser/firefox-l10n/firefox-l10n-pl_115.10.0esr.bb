# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9d4ad8339b7d1bf8d1f7b3c492a8b1fa"
SRC_URI[sha256sum] = "27e123bb7741639a4ae5463224c01ab1d37f3e7cec593c4bfa218d435c09392c"
