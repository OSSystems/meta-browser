# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b14f1165e891f18fb8b5b2522910df91"
SRC_URI[sha256sum] = "863a8bb72f863e66043db4f184b50759af7d9cd965de87ec9644a85b792093a5"
