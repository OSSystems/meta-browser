# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d4e8b54ead283e130b4af0a03c4875c1"
SRC_URI[sha256sum] = "04821c278e5cb8399d20dd2379e9cb64b0c82376542a1ba8bb6ab1caae87eb5d"
