# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "440f71b7af91cd791441b605e6a2939c"
SRC_URI[sha256sum] = "441fa0ec4f76303990278a9d688c4582cd176799e2962f688b88456afcf845cc"
