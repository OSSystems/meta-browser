# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6de03fd2f1f6b30eaf85be7db022d71d"
SRC_URI[sha256sum] = "a51f98ea49de6edfe86e7605c8b092d3f1d191e9e68b64fabc4365314bf6f965"
