# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c8e5325ed33c689700c828d6d50eb4bc"
SRC_URI[sha256sum] = "4190a54476bd5eba54f40512f47ed82b86234a280a85b016ec67cec86ad9fc72"
