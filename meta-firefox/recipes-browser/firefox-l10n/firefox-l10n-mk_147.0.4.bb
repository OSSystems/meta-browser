# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fa6112e251211587beb5dc130fdc318e"
SRC_URI[sha256sum] = "8c8da0f7840ca690d7c4675dcfe109f4ec82dee66111312c098473841ec69851"
