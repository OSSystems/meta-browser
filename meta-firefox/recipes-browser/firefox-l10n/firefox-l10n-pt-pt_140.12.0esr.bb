# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "1ed6701aa2efe6aab35df211db45fb633aac744497bb4fdfddc3f5ed4b067019"
