# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f4388a4532d6e46bcd8d91a028850cdb"
SRC_URI[sha256sum] = "d99a1ef93cbcec1bb461b08b9c004cdfc3c64ce665acb70802609a070ce83c8b"
