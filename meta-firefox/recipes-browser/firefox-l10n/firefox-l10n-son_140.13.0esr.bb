# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "bcab6ac1571a29f0a6aa2886f77c0ff4098dad21feffd7c5ff342a514d4558c4"
