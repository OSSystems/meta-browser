# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a55ebafda89b9daa683744651ad12b0b"
SRC_URI[sha256sum] = "26df44058910c4ff7632401001d39fff7211b685ab4fc4429a163233d8b6e0c3"
