# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "474e12d9d9ffd6dd908be303b7d251d3"
SRC_URI[sha256sum] = "c1508d2ebd3e20bf5adcbe3fd269a452a38fb5cec5df3086e4b29e5fabe41890"
