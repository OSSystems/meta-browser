# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c64786229526d1c368deebf7ebf28ae5"
SRC_URI[sha256sum] = "733afd3b657ced9009cd927e23fa35a96643905b398e7a02407468ef15b41e98"
