# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9573c14dbc2cd1e70128f50100c63e79"
SRC_URI[sha256sum] = "07987fa36ea1bdfee34cacf17e67874754daa08cc8d5d11ac47556118738e6e2"
