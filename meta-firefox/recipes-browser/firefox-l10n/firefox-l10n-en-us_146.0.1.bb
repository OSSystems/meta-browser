# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7660abd02de14ac42bab2412bb10ec35"
SRC_URI[sha256sum] = "84056830392ac70577e5d326707223e5a8a79d20a5e832da5edd03d5d30dd0ef"
