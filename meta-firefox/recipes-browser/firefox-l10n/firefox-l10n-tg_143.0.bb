# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "67caa4b5f3ec359dacc4b698e4b6b450"
SRC_URI[sha256sum] = "d639f782e85f6568d4abf691c399961af4469d9ca1fff0323de1024cf9787365"
