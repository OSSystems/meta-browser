# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "0a6b6e87016f2baa465d0a96fbd2f2cad390ab52f835a756c96d123b6036d9ba"
