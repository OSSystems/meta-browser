# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "661a59fbde8ece8e15529f39bbb4be49"
SRC_URI[sha256sum] = "9f6ee47b3c7fb59208d1f05ed861271edfbdd109881aa04fcee3e82bb242488f"
