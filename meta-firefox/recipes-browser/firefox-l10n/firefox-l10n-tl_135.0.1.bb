# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "69882a8a046d0391efd6493d4ed80ae1"
SRC_URI[sha256sum] = "4ee045ac6d2b1f1e797162f6a98bf3d470c167d575bc5a61ae74f02972f69aa9"
