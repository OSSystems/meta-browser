# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6d9413978e7d7e168948e4688f40c95c"
SRC_URI[sha256sum] = "c6d9b76683ccbfa28c66234d39c89d76106536faa4465a935ba53da47e40cc4d"
