# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "37e5230a5e1d4cb568c5b8e3c860a563"
SRC_URI[sha256sum] = "41568b786eabdeb89f3a529d54241b49e6de445a0cfb5679c484a5b67a230b64"
