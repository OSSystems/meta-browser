# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "67d850b3088b643f10bc51136f65fd57"
SRC_URI[sha256sum] = "4568e543d93549156f187b917189b6222c53285e1a37323b6f6cb353cb0be6f8"
