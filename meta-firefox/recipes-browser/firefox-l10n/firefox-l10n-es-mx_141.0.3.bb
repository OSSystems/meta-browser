# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5420fba22026a776dc0e1614d317313b"
SRC_URI[sha256sum] = "e242b00985af3f0b888e227587ad096c3b3817cd8427d3558c8896d2dda58b6a"
