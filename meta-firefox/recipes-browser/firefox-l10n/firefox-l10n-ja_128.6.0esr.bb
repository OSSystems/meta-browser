# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "48d870b84bcf7c44be4705f14ca10c51"
SRC_URI[sha256sum] = "89f21992dff3425d378b01a1dcaaa1cd1722e9664cd4ffd4dad334d9c8133c54"
