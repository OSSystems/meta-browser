# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "027cbd9bfe4866f539425e5d51e16189"
SRC_URI[sha256sum] = "390ee138d2678a06cb77edc1edfe4d4d49827114d0b8b72acfaf65c714347c4f"
