# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "def2c3289e73a69fa12762fd5f75511e"
SRC_URI[sha256sum] = "ead2de5da88781fd871b9a5c5e079812418bb7dc39e88b825afc94ba0a7278d1"
