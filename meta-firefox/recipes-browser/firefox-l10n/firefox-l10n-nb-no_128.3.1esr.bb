# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d501bc1c75b65d78b2465afc3796e627"
SRC_URI[sha256sum] = "7ef7952637c91bf9637655eaa02cb13e2ca474ef56bb5550c57ca810b9e86ebe"
