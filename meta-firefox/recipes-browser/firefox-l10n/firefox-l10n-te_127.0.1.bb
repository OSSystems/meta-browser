# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3c23eec04c1eb7256fac2b22b3c53b60"
SRC_URI[sha256sum] = "4c3c82b1bfc27124709ba94a7b9d6f5b05f94374a301f7b9daeec4a6e536bb3d"
