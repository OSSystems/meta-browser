# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4a104c81626062cf8500c6c44bbfc488"
SRC_URI[sha256sum] = "f32a2e2e7333d3f4e83f2217c713f5158d5806e64421ca99e42bf5b710dc196d"
