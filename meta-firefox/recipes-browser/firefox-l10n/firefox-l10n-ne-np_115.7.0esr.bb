# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "72de38cf9babc1e6a3bfb2838a4cf3fc"
SRC_URI[sha256sum] = "b823278a2b22ce1bf9b24863fb9db4de420f6595bf71e9e62854f1ac54acf395"
