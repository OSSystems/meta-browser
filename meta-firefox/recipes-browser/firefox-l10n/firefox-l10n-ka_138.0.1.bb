# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a525dcc77598e93ac86364bbfbd05476"
SRC_URI[sha256sum] = "758ee7f8be7d228b7274a0d07917a2b1baa9e67133eee6ae43d5320ee6b197f7"
