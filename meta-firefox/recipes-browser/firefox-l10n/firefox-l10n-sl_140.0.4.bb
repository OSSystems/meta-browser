# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4deb48dfc3e49e4bad3072c9462dbd60"
SRC_URI[sha256sum] = "4b8dfada32e6ba6736c056de226dd4534649cd75d70f5b74769738987cb4e132"
