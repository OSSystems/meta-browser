# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "579defb2219931e15781e5d013bc7432"
SRC_URI[sha256sum] = "22d3fcb026ce75ebbd2b686a4b8f13c734d5e75a447982c9299946b199e08ed2"
