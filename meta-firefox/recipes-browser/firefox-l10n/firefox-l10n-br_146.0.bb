# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e4e72e54342b8137dbf6843591b2e542"
SRC_URI[sha256sum] = "106f05e5999f4a8077b5a01594d100dc93e3de0b7ca9fe75bb74179d0bfca3ac"
