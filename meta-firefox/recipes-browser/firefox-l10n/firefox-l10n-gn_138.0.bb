# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2e74f04c4f48c350067de4365b982d25"
SRC_URI[sha256sum] = "d1ace668e6a2ceeafb844aab22cfb926d6ac7d68ed1d5f324a84c9d2f444fdf7"
