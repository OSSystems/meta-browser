# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e96461a7d0f66c3432805eaa3d1bd874"
SRC_URI[sha256sum] = "b875ac72153e199ffff7ec9b8706e827931262e62ba1302745d0b7d4781e4687"
