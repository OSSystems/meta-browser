# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "72d5576c60ae14ec25f42fe94fd8eb02"
SRC_URI[sha256sum] = "8b8d6920dd835356448a79f85eb542a7784807d9770943b9bda40b15a2bdf4c0"
