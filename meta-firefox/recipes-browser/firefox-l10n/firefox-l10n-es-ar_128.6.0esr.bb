# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e7dc758268bafd4420fdf9201c0d3bed"
SRC_URI[sha256sum] = "9e0d8e07dd1c0f6bc4c1d185c273ef270e03b1289c76361e9b1ba46425cd47b2"
