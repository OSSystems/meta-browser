# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "17090246ca4494a953ac3a56575c4adf"
SRC_URI[sha256sum] = "cbdf529c4cb131f714e37ced462b5e62d3180def73eef0132d0e79fc4d9ba421"
