# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bb0964df0ef761c4af9213b277469c57"
SRC_URI[sha256sum] = "506bd8b0b4eb41113dc851ea95d9eee9a7ecc11c380c7848db289faae542712a"
