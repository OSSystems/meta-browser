# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c13beda1ad0b5e62860650960aebed28"
SRC_URI[sha256sum] = "bef4ca02eebdf30e20308b601f068178e87eae01fee577ec71435a4f565012d9"
