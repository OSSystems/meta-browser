# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8089a4bce9a6750928a585254f185f3d"
SRC_URI[sha256sum] = "a9c24bbb328c91f1a16c04aab6d0c6ec8a26df48ef9287d3a3d137a0b03c37c8"
