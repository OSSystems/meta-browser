# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "221c28a4df1e1c1d71c100fe72def25a"
SRC_URI[sha256sum] = "2885174b1b525b942983ef1996261bd738574264678e2fe6ef4fb3c5ebfdae1e"
