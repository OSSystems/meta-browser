# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "55963369d382a2dc46712724a53f5ac8"
SRC_URI[sha256sum] = "79fb705489c0165eccc78738f9c8e9c3e340f79e5e2dc722cdee243e0222c8b5"
