# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "96abcfedc2d53c159e83fe3b804baa64"
SRC_URI[sha256sum] = "3972a9f7411c9262c3c7acd150804d941c372fc5a4f58bdd7a452426ee945a3c"
