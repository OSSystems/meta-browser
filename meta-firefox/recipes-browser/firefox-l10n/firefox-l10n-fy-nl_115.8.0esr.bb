# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9134fc681b5f1f2243bc59e3d16432c4"
SRC_URI[sha256sum] = "b9ea54ca000a66081f11975356252d1ea147dfe879b8218367ab74a90c3a82f5"
