# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "99f06058d957ba11033b45fd82ac9105"
SRC_URI[sha256sum] = "5c2eb7ec19fab53ba504918eb2e64d0599e3b70ac027ae1284fb0d21f9342474"
