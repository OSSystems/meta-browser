# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "a26563e5bc94b9e681aab1facf3fe27152d2bc3750b8bc4ded4f14c9b16d7480"
