# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e6b4a0e61e0a0c93805a0f9d2ba0a989"
SRC_URI[sha256sum] = "5cd281c6565c57081744838bc7ec0c0021a6d94301e108d9b8f730c2eaa3dea9"
