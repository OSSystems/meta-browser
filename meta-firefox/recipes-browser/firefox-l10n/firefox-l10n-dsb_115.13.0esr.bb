# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4d5c2ce8503e3ca84918bf9f9f9615f3"
SRC_URI[sha256sum] = "0536bccbc9ac339c5940b274a22ec61b3c7d3a8db154fbef7d692068ccc082e9"
