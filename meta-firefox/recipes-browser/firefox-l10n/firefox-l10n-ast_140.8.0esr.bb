# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fa1ac15c28a20cc2d16c7e87754ed613"
SRC_URI[sha256sum] = "71405ef9cd29680b9c839e873ec995f3c88d203e51b36bada600f64d18c24609"
