# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ab83c5e3fa93e4965b2bed541972a128"
SRC_URI[sha256sum] = "8a3e6de099dbb323760b136641a627830658f3ba021876d83da8c996ffcacfb6"
