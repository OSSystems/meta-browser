# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e70c90d86c8721a29d982c474c981ea3"
SRC_URI[sha256sum] = "341a2377f2e2c0ca601d32aa368aa3c451c06c0af6178d632849e6cd401e7960"
