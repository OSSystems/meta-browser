# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7a290428a5965bdf401a5dfe8bc8f74a"
SRC_URI[sha256sum] = "904db012f9fe32e1f2d63588f87ea352da5e7cb61fa8b4fa5c6b5bc8d35abe1f"
