# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "98e4376d6ad30c1f9efc08667cf8efc1"
SRC_URI[sha256sum] = "1606786a7767480cb9b902efd95e5cdef4181b6fdf5d1e31d1d6936296a09bd0"
