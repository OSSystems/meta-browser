# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "79d680e436e71ecef5eaad65fe490693"
SRC_URI[sha256sum] = "6c82295848cb83d7f94148fb05410292c2f335b35bd31bf9890b8b8226910871"
