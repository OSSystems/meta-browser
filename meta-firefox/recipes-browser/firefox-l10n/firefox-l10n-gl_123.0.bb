# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "293de95c585657dba66b20431a2f373b"
SRC_URI[sha256sum] = "5e16dc1b317b109187cc05ca5864c321439f813f0cdaff7aedce9bd37cdea8af"
