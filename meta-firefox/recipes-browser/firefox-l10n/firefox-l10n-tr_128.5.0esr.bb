# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "af14cce1fce5ba4e0ca3fbb8fd03f586"
SRC_URI[sha256sum] = "7d94ed08563481dd8e19b32d0b5d93c35c41825eaf78e6ef4d14afeb056c9634"
