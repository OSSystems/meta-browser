# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8f0112292611a3d052d47fd660b9ccff"
SRC_URI[sha256sum] = "c2b788d93aa9f115180509ad91697663eaa7f90ebe8aab5126e90a55a9a76aa7"
