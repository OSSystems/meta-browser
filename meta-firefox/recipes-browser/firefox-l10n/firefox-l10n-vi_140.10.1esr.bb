# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c15f16520e805a815391981ba5b99bd18152151e5bc73f7aa4d2d04622ac837e"
