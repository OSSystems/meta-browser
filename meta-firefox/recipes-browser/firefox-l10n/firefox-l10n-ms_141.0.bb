# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0d5a298772b23abf98fc02a6d75eb39e"
SRC_URI[sha256sum] = "3a0b5f961e80fd5ba2adafb57d132cf940fb431a943709f60d4794fdf83e308c"
