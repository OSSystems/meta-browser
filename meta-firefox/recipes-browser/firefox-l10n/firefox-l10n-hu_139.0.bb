# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e7df59b65711cd38f2dd688f01744594"
SRC_URI[sha256sum] = "47afbe9c5195ec591663509e8eb532cfce608b1a54a08880164fbc0f228a0eff"
