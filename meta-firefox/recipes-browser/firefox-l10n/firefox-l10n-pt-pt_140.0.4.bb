# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "80f348a503f425ab3c98c911685a2767"
SRC_URI[sha256sum] = "9225a155a23b26a78780662a26bf49ebe546a379d50c0c27c5c0a93c72d77e5c"
