# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4b9a70093798275c483dd7893b6577b8"
SRC_URI[sha256sum] = "270992eb2be45ad73c76f9084f35cb4c729efbd891cb7381d4f02540b62445d5"
