# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6ab796bb748b759b328a8b2a8af3b1bb"
SRC_URI[sha256sum] = "5b26eccbefac17d861bb1d6ef324446b6abe6f56efcd0f8bdbe072bbcdf7666f"
