# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ee0b12cce9830f93e3c8445ce5547631"
SRC_URI[sha256sum] = "fda05b18423be231cb27a6d2350c41c6541f403ec135c6e07418ad09ed037c5d"
