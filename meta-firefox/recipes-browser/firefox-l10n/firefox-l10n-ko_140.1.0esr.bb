# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "185a2b8cecb1e1a7cd08222fd76f80aa"
SRC_URI[sha256sum] = "41485571c8c54f988df0a8829c262db70f9141508fc1fd06c4e766fa79210468"
