# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3827a98a5bbcca6048c3e85d7ceb6b99"
SRC_URI[sha256sum] = "6e0ee75ffc5c3f9908a7c457126424696033ee92ed73f5dae5c77a03b1d2e605"
