# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "43d41fb34314e5e9e909948d39cea9a0"
SRC_URI[sha256sum] = "2010ca177f191f8eec324b2949e3aad44a49f014c2fd75375be5a12ceacbb46d"
