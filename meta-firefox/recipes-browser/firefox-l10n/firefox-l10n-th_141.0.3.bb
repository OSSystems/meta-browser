# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aad9a211346e2164984a59377e1e18e4"
SRC_URI[sha256sum] = "bc43f584f71f7c5f20abf73f9d636c04597475da6925d1f3d720ae92c7cbf091"
