# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3873aa82ad3d149322b6e8a5e0c4e1dc"
SRC_URI[sha256sum] = "18cd07621f116f037c38e4efe6b7ccdb30e051e0ce8df35cd225002b8602778d"
