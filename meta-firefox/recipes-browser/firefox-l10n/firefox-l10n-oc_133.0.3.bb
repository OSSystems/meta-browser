# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fd0d1e82c809496b114fd34ecee0e287"
SRC_URI[sha256sum] = "03a0a93bd26e92870037bedf52b9e7846a3d57f53f7ab38e69a5ce5743f0ab1d"
