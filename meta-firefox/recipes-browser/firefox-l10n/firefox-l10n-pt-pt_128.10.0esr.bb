# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f3112d3d3551b68ba9094178b9508280"
SRC_URI[sha256sum] = "e03c76960cf09583c45366221efde397ae2c6151f9db97cd540001aa5c0ccb44"
