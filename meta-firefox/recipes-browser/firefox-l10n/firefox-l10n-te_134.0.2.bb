# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b1a8d919dc5458fee43ed203d02fd7b2"
SRC_URI[sha256sum] = "457fc00bfc314aefbfa685cb68e6cc9daa0999df6a0660d3295160c1a82a96ad"
