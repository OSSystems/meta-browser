# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aca8ce60bbbe22e4a5e8ce63cec58c01"
SRC_URI[sha256sum] = "b2570e8ce60dc83c3a91bca80cd2de534325efbefebd60e90b1fbef95cb42eff"
