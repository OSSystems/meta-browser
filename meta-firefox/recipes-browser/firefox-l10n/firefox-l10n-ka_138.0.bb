# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cf1f36db0ba580edb4b37585652d6207"
SRC_URI[sha256sum] = "e1359502f1036a6c1a48c99f6c4ac2c1d0555a5ed91939218b4965e1f2d4ac89"
