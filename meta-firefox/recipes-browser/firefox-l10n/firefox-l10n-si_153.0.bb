# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7158bd3b71f12440de80cf86d1e2f3554e877e1a8230f1535df1caa91a6bf439"
