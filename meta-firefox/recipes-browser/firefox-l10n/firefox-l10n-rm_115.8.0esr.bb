# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "157e93a05244dad360dd42c77d26437f"
SRC_URI[sha256sum] = "658fe5e23bda44e7d64556723b8efe26f6126839a84c22f28cd53938ae47389c"
