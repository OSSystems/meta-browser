# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0e90dcbe366ddbb0a0b4504994d2c180"
SRC_URI[sha256sum] = "42e72f1a37304c784b6349e0f00e684246e9ff2c71944247abc4801e61250d38"
