# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1047bb0752d175e55e46b756ea80d35b"
SRC_URI[sha256sum] = "fb0715122ea0530aa3939f51497ce1fa30010d54f87c00f778791a6ce28ef3aa"
