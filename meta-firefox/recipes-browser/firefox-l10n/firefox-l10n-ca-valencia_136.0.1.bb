# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "01e6ae9b6d813daee07bbc3484b0447c"
SRC_URI[sha256sum] = "8120192eb06e3f0c7c5a69150aa4a6ae2e991bcf1ccb07b8c245145db0a77cbf"
