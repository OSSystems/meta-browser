# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3fe33ebae248881d5cf976f7fa2e39ed"
SRC_URI[sha256sum] = "4ad02707ad14e6faad02fa578e14b14c34d2f91b4a032ab663123057748ee894"
