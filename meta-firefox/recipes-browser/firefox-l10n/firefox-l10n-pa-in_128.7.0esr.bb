# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fd9289a5f9c3d8e07944319583e1c435"
SRC_URI[sha256sum] = "15b71c76e21e0610f89542b4ec25cfb4c785d90121db46aed290b79bd0a3f2cb"
