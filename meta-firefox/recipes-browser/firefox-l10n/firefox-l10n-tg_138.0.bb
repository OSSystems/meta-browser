# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "633fa84800f6b20448cade8e6ce849d8"
SRC_URI[sha256sum] = "8ed3311ca2954b89d35c866b0e55a1c4848ea725c77f8f810d6c7a2bc14ed32d"
