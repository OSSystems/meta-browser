# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b69cbf23c2d27a5f91901626e71ea419"
SRC_URI[sha256sum] = "651d5130a205e079949756bd9ab1ab256afbce3070dbfb34c81a0383297c1683"
