# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "db23fa26b7ad4ab037f0e743e7b8bf84004571a9032975b6acd3e4e2a71be889"
