# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7aacb3600b9b692b34497b64808863f0"
SRC_URI[sha256sum] = "e8b13161dae82ae40222b65f95ce92694f07c91c89af4b99e142531baadc88a2"
