# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ba29cb9ddcb92a9910302aa04cd00d5a"
SRC_URI[sha256sum] = "fba1815fe0d316cd963b58b9a27d8674a1a666fbdb83e0db913358ee78fc8efc"
