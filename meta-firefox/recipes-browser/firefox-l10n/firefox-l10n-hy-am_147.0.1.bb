# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1fc750323f04145a18b374e8ab93d0db"
SRC_URI[sha256sum] = "464825638a200bfc3ff8b38f233a51466a486b159e9361bee637fe68a0f7e338"
