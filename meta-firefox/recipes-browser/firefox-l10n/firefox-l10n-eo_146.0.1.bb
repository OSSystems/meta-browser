# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e9fd7ba76b901cc9a7ce5a27ce9a4ed6"
SRC_URI[sha256sum] = "77e9f8ef194b6e073691f0fff36d11cfab4dd4db8baee773f9e53665f3dc2781"
