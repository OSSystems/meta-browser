# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b9a53f2855db1576df47318bc4b37ad7"
SRC_URI[sha256sum] = "020d29dd25b88e83e5eccd7d831dd1a4d8591b6dc3466071bdcab0c8b8d0ef6e"
