# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "32202bb6cdf7641ec8f02dd87c78f073"
SRC_URI[sha256sum] = "bf89f30714dc3f201cc69aac04ca359a2a9e71ccbfcb250991dd8dd5647a6e1d"
