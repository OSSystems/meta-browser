# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7034bfd22c5bdec36127c3149b1f1c72"
SRC_URI[sha256sum] = "93175872415b4e32b5e7d61b521e8efc8cee25aa328264fc4f18d5418203b81e"
