# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9cff0b81077a03cddf152b7f0070679e"
SRC_URI[sha256sum] = "70dde8b2ae0ed10a37687ba547a838b8e77fdb5546742ac8629f8942a8ffed39"
