# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c116ccd8c86be5ebac9192b6a166faf"
SRC_URI[sha256sum] = "bcf4019942172cc0994ea630262e84667e6ad307337498e94fd27e17e00fc358"
