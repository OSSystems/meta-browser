# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e1901daaf1fc4d27178693275b618c91"
SRC_URI[sha256sum] = "e975588f37603a2114090cb39093d7fe8871ed9fd5768e5af083a3f608f7dff2"
