# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0f0079c9c166420e7668294beffb9bad"
SRC_URI[sha256sum] = "b6db85750d92e0f5ee06d62b46e9e140ff54630d9e82850cf89f1d7e15e04d90"
