# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e822736937847e17c5fd2a3566194a0e"
SRC_URI[sha256sum] = "29dd15e8e3b1d4aba257ae6da993835011007eb86cc7771d2ac7b5601cbff9fb"
