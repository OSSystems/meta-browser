# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "735f5228e3155eb05d58ee40e7f59365"
SRC_URI[sha256sum] = "5a92f3d685755eb399cbaf46c0f15af7a4d15baa9695dde3ee1eb593584f0f78"
