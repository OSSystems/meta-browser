# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "430b382292ff222e1eea6e5137af79ae"
SRC_URI[sha256sum] = "1184fb6ec4173e8662755c9be5aca03a88af2ff1f5b10a3a0e03f3de713593f2"
