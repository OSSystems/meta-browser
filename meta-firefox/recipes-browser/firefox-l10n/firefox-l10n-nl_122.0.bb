# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8e3b10442180f3eb637151b61ed79cf4"
SRC_URI[sha256sum] = "b7c511db99ee2c8bb65f444f0dc511f665750850e7bf4ac1d6a220a6e6bd9d3d"
