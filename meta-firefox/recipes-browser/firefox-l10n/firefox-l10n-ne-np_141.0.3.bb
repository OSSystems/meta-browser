# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a2b34463a3ccc59f5b1a18943712d19a"
SRC_URI[sha256sum] = "8df53d9d1fab092fe80a42c62f31119390947f4a5dcb0f1f1fc848f43d1f0e05"
