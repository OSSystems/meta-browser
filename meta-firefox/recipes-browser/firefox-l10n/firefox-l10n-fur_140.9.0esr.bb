# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "86b186bd8cceb43047b045083e7ba8ff"
SRC_URI[sha256sum] = "c633afcc328f687be4b4639152f2e1e6abe4c9802095bcc714c7b358dcef7f72"
