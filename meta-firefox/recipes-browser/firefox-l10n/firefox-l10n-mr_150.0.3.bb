# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "a09aa5c494858e723c03cf287d49487bb514b9a69057b3806a2cb6fd2f01f7ac"
