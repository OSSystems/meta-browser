# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "75977b2bdbd38720ed29df1504a568fb"
SRC_URI[sha256sum] = "a4c373a6108524113725754fed13522246c543f9dfd146f9236fff727bd4bf31"
