# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "78efa1ea6f2b0315f15df550ad92f1fd"
SRC_URI[sha256sum] = "00fbf8d891f9a71db1ac21033ffc1d81ffe2ee59e0f7b80a634d1121fdb2604f"
