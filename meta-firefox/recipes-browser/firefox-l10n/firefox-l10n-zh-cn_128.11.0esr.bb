# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5769746eb80b03aa6a6e2f176e787e30"
SRC_URI[sha256sum] = "a7d1a744f3cfce8aa88043bf5a25dab80bc67726b81cf1aad000b0f71fb51205"
