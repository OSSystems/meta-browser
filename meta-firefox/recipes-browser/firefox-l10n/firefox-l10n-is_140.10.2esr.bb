# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7a4813a372be39e2dd6aa12b367243a9d88206c70f9a040354c2f6e3bbc4b220"
