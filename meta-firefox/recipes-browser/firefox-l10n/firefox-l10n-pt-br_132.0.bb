# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "79d47a39519d2dad230925a0f2de4b6e"
SRC_URI[sha256sum] = "c2a2fa4d8c440c56816961e36ed5c990bdd2aa4f2d870c574f4be7d54272f46e"
