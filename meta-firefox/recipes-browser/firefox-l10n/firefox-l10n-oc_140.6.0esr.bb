# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9544682f9dd092918d54276a7a51c2a1"
SRC_URI[sha256sum] = "28e3ddea39aae28fc5d06cd8fb1df67d20beb978f241847895667f70e4b5bdd0"
