# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "152e9fe3751b857f590c301500c0ba7eebe8ee454fe9849ccf46809559976b2c"
