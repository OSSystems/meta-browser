# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5bd2a3e66dea4575166d27d402abf6e9"
SRC_URI[sha256sum] = "afc1923e859a6048c63eeb8d865597eaef9644c11ccc9ac989207b0302544b72"
