# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6d109f3f55d20921a92e1806d0b13f77"
SRC_URI[sha256sum] = "1db9670597fdc174c250f37193ad6cdd26e69769fba5ccc5407e35190e2624b8"
