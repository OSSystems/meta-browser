# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c6c91af761eb69c73c6e45a9b9f152a1"
SRC_URI[sha256sum] = "3232be65ddb81bf6d95729d25d0978fb9d6601e5634e23edd3124b8ecadc21a1"
