# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "560c37565e235f5753fc0540ed74d1ae"
SRC_URI[sha256sum] = "899ae64798c516088f724c6e561043823310d2cd8d617e08c9766d500f625932"
