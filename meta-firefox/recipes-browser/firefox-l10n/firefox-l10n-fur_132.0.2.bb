# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "30ee6bd306b6bba13ec680ea8a1da9a3"
SRC_URI[sha256sum] = "8dcc2781f094a4ddc8ec01d1ad607146a252eb29d30f964184f651763964cd8a"
