# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f2e96834a66eb33eb9c6a656f416f580"
SRC_URI[sha256sum] = "dcaa298949e343836041366b2e498061889a361016c7cb2592b85587323d81e6"
