# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7075c173567ce3ba4a09cf8349b560e9"
SRC_URI[sha256sum] = "feefc3eaca2369d0c1de4993b58a0a7613ad33d8fb0ba3d43de97d165c375c10"
