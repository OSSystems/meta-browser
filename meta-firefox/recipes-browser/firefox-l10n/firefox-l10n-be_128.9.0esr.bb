# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "17ffb4ace3a4885ba1101b924278804f"
SRC_URI[sha256sum] = "d527bf9223e27bc3102330d94988cc2f93c15146854d7baad6f05857c8398e27"
