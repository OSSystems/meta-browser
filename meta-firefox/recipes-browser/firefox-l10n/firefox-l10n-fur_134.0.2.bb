# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a6070e4a345abab5e2a0f2c535e5fe40"
SRC_URI[sha256sum] = "4f2dde00910fe86475cc4ab7fef104f1be39da7ed78f1e16ce5ad8f64d98675c"
