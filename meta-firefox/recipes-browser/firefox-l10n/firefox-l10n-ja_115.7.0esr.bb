# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8f23ee060999533aa404244e0c9bdacd"
SRC_URI[sha256sum] = "554895f416b03547d868eb41ecf2dea700d6d384503b7902546f8412b2022dcf"
