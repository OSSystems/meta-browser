# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7c9ded6cc4b881ed4030a89a52dfd89d5d7a60f3b6394edfb7219b29981ccd37"
