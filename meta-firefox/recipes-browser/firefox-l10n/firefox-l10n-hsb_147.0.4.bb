# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "49e7bf03ce46c168fcab5634c8f1d8db"
SRC_URI[sha256sum] = "1e1ca45971fef2032d7bc193f6355e36705a1916ffd72e1698a112998c88bd6a"
