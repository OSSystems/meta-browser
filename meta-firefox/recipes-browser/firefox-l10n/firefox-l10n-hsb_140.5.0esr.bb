# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d147fcd52d766aa741d38860b18c554b"
SRC_URI[sha256sum] = "55fe8dbe3c4045da0ad919f88bebd31bd936cd63ec2962b09ce720cdb4014dc9"
