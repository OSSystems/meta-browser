# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7b4742ea0e9e9e082a9c469bd20c65b3"
SRC_URI[sha256sum] = "0ca96474f9d60940b64c43863b6fa7ea3cb6d2c7153e921cdf7526bedaa9a632"
