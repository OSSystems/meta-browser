# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fd1daf67140313af3c3eec800874f920"
SRC_URI[sha256sum] = "6c59d06911327ba6f1efc9b08fd099b080fac1b87e4f1c0d4393c811200b4110"
