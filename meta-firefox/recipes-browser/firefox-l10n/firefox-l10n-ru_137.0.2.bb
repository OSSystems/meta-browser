# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a94fe6abb88eb1a00a729c7f3446f2c9"
SRC_URI[sha256sum] = "ae46dc2c5d0be9bbc2d6ad1a4bc4eafff89d61cd79d65f37e1326457835f98b7"
