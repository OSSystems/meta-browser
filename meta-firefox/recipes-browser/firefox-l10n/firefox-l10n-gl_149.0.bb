# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d1ff70f2f2423e3f99ea44505155d13a"
SRC_URI[sha256sum] = "9a55812158627e00565b79b40ca58d1d32902e681982d5e18953bed50dc3175f"
