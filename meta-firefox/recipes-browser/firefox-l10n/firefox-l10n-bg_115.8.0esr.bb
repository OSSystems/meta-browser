# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "467ee3a1de10a9d2d26c726b4883d52c"
SRC_URI[sha256sum] = "c821005a41602647837da286f519e6833e41b892588961b6ae5cb0a215b104c0"
