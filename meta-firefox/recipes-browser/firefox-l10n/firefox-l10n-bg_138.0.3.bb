# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "60402c6a6afe0e59f6e1b5f0da51457e"
SRC_URI[sha256sum] = "facb7ee07f4e98810224bf5395dabe87302defc9942f46c191f834b01e755f6b"
