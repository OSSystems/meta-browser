# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ef171fa8c755202020da003f220f1b48"
SRC_URI[sha256sum] = "8107e233ec28c1cdf664b9a6061074baf97fb9cda12a12f47469d053d990c1ea"
