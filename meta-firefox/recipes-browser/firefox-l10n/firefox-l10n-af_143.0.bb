# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b8765b14762f6aed1fe57bf30ae6e3d4"
SRC_URI[sha256sum] = "01dd86d9e00453cc64124903a82e889b76a1b2f13e6b037d9906507d10f43395"
