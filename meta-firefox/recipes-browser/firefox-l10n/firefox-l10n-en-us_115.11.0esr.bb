# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "46d2bc575414962911fc34cb37cd0abd"
SRC_URI[sha256sum] = "ab534d0dc24f4f4974380084dee9ac08176e9aee6b34a79c76b98429d1a5edd1"
