# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "624c597c395c31bdab6400c0e2be150e"
SRC_URI[sha256sum] = "b3d2a83c430d5161b2b28f0ce8ed1451b49795383c5f4fec2759eaed1a121120"
