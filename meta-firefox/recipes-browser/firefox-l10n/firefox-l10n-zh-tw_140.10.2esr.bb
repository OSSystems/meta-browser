# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c56fd8722f00d0cbbdc7dd1c1dc90a0522a47f9eac8cce48b78055cecf297df8"
