# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "b679a7caa826c9270c48cadca96fb9c490ecb61f4022cf993c27c2211baf9ce5"
