# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "37463bb0ede3f2a8829f2b47e303f54b1a13d5a0285559ecad138a90e91cbab4"
