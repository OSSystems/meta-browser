# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "017cfdbdd55c69e611e811bd386b2490"
SRC_URI[sha256sum] = "a105127dde31c39ad8f342ba9af9d601897c9339bf7c4fe19afd80f8d1202e09"
