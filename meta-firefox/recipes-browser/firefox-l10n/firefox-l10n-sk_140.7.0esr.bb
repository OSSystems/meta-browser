# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ff6de1984386cc064ce8139e3fddffe2"
SRC_URI[sha256sum] = "9728e2243976c9b22191745597cbbd526452bb1d859fa38f4c13bba73961058a"
