# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d9114ea221b85e71870b0931ccfde497"
SRC_URI[sha256sum] = "e44b8bddc00ca8fa46313b798f264f2ed8e5faf45b35582fd75d61f5556ce9cc"
