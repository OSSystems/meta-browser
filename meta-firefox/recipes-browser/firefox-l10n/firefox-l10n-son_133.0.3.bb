# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "be8d1eae6b73d3a372a6c3cf9c1cd8ae"
SRC_URI[sha256sum] = "b1dc524b6b03f9caf79afed2d53164ff658ab631638d0f334aed9753e8bc058b"
