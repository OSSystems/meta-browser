# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e13ad4bef1a21de8bffd176f94747405"
SRC_URI[sha256sum] = "6c889aa79570afe2cc0bdbdb44cca8f2be5ad68dc33cade736d10b004f0ef34a"
