# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db454c2508743bbba3014ea0aa767869"
SRC_URI[sha256sum] = "eb025b6bbcfbfd8f8c3b8124dd3316dcbfa845e2b46e2a145869ab29ebf4586d"
