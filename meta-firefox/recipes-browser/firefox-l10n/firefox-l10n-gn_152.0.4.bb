# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "b3de429ddba2c5e934762e1016f73cf5fd229af9aa1da51915ad32211daee26b"
