# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bc6ad1b37c4bd0a0ec80840ea9101216"
SRC_URI[sha256sum] = "009897b3dff49bd5e3f6b140cbd731b3953bec9c8c89da9cb56abe6423d7b070"
