# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5295a43d50fb528ac874ed01b8324ab0"
SRC_URI[sha256sum] = "5aff11548afff8b33989245a21221f7a1bd4054cabe8f922ee403e89b17b7ca5"
