# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "425d6f06248e8d31e6d26286c7a1c6b89299fe2580f2f2afa13388c0a34ace28"
