# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e7f0c6805147bcae61daeb68552b3224"
SRC_URI[sha256sum] = "4522b003f9c84292ce0c5e02cc2ca7895f1bd4bf1f7c06f262115b5b87995c0b"
