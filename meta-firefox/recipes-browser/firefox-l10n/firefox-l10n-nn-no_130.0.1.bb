# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5b90c9d11081e0b5f954f8f9c6087a6c"
SRC_URI[sha256sum] = "817304a71b9a2b0a40c3abe986552e4785bee596728d36112486bfe956b67d5c"
