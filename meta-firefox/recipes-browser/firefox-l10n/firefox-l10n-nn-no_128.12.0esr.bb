# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e53b377a856b99a918eaad056b3f34ed"
SRC_URI[sha256sum] = "d0211a48aa468068dd071bdeeee0052bcaa72c81d7621d0c60e9b00f8acb70f7"
