# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "62a8aa79d5388429687172ae3683cc58"
SRC_URI[sha256sum] = "3cee7c406b84e3a4731e2a880b31f5f1cb29f442a0e0490085e31161b8928bec"
