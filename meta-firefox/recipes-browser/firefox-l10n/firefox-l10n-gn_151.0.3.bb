# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "83f16428d384ccad6a63fc1f8db4cb7d9195ff6ff443b32dd040a0231adcd273"
