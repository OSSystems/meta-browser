# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "80b123d66de865fb457e30bc1eb970e8"
SRC_URI[sha256sum] = "2aa66f278a7bc4175f1eb575751721329344e8015364c365c7dd20484af1a32c"
