# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "821599598800dd6e2e780ee9d52c8827"
SRC_URI[sha256sum] = "671ecb67ec83f6a2cf62bdf6836a8078fb97984b1c6894929a37da4b7def1fd5"
