# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fa8906582828b82ac0f9ff14ce82eba4"
SRC_URI[sha256sum] = "6cd7544e5699afa0f842c0f41eeccad39943e2c0e14958012dd4c24caf886c1a"
