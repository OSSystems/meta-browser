# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0ff0d84b5da64f8f25dbfe4a793e8a62"
SRC_URI[sha256sum] = "be1554700d2307a513a20cada88580cf6a58425728e0a42ff9ab95030f05c10b"
