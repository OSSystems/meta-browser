# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "31e4d6833d71d134f42b9ccc88f22cd8ead7eb026dc5ac531a6e40415b2cc39e"
