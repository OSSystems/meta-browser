# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "f4e8b33ceadc9b68e19bf0a14abcb0bf8cd436b921d3563393edc4c03bf12e9c"
