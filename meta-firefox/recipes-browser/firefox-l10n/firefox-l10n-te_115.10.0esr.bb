# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "83a6f44b498bacb81345773a85c1754e"
SRC_URI[sha256sum] = "43fae34bf54d72d71ae3abe62fda2e1bda108c3ded563ad7b8b3566549e205fd"
