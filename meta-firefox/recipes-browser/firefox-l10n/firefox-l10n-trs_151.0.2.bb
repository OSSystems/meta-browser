# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "bbb67bd0e7c6bdf3e6130ca7fd08e79255da9b736aa35486424296d348340657"
