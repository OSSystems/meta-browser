# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9fcd7af23497e5562eacaf16bc50b1be"
SRC_URI[sha256sum] = "26559dc56c548c261a8b23f7387cf22d9803a7a70c1629ebc1c9cb9dcfe308a4"
