# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "90347695829ef8d25a5c01f7c19e26a9"
SRC_URI[sha256sum] = "dd7d492522dc641f8160fc8a165df90e5122e7170ff2616dc9f7900fe266c292"
