# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9b28427a063329ddfff0ea3f1e64cac2"
SRC_URI[sha256sum] = "03fed6835449df57b16c428646c5090de1efa870e22e7427142dcb9eeec46204"
