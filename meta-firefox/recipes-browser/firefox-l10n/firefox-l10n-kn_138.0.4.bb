# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "28fe59847908be394701665e0e9c2dc7"
SRC_URI[sha256sum] = "d70b5870eabccad213f80f2434c2c200fb7ca14b120e9bb08dd5c88a69101c6e"
