# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "750d1a21ef4934a3194668d75699278105791b0dc752ff1670adf2c07fd44113"
