# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "774c89e93e59c085f8e710e03091e994"
SRC_URI[sha256sum] = "1d7c385baba22acc6ef32ec45c7b57c122d62877380d5eb7d5c2f9a5bfc992aa"
