# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "346f19af74c22fd4bf1ecd57fcb3114d"
SRC_URI[sha256sum] = "1082a8959b0f28ec4b50b0c8ec287f5af7f9ca053e1ff562a484b1d014815d50"
