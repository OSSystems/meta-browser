# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2412c0a6453b661dd8186a71209f854a"
SRC_URI[sha256sum] = "00682c619898777ae86a62e1b08df6a0f50c4c1b8e572490b6606fb666f86830"
