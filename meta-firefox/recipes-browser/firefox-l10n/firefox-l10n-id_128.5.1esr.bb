# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "951be67c3cd3b729817115f1ac0ddb97"
SRC_URI[sha256sum] = "305a5ff629c92252f3f9479ee9cc0f71f9e13d4ca4ea95abdf376eed8544b0a5"
