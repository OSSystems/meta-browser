# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c745db2d311221e492346144a697b722"
SRC_URI[sha256sum] = "d8d062efd912f57e05a68c4bb596f34a802fe4b2cb51bfac9b52b04feed12208"
