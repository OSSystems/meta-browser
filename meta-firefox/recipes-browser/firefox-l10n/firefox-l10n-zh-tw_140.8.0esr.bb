# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ed35c146e031549b99bf7334b7f41aea"
SRC_URI[sha256sum] = "bb1101a47f423bc10e51de29e957ba8abb5cdb88d3a98d8ac4b39531dcadeab5"
