# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8f30d655f5f7425baad2bb4e4c0e69ae"
SRC_URI[sha256sum] = "3483285f725a24c9b19356194982149b38edbcee28e0b959329dac7fd628a526"
