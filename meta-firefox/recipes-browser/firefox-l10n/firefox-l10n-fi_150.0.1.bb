# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "394177d84c4ba3c3a73298513c1d8832631934b397a8e7a0dfddc0610ead9007"
