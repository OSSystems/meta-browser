# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3572c5c267d3fb3fd9ba4e820d2e6742"
SRC_URI[sha256sum] = "9575ee66bf2327ad87302a6262deef8a3b8ef0522c390e2c3d2bdec5308ab247"
