# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "30e721ba8c5b1f2e27236246d70a0204"
SRC_URI[sha256sum] = "29d91ed9707fae3a3c1d29fc3a9bbd40f5457fdcff2fd2456ee72e6e704f1a78"
