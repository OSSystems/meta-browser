# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7ad1b45bec5d0e2bc854a39c77825a0f30255aeb38929e41e3a24d15be7acdcc"
