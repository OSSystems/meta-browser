# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d70f40a1d1faed50d90b5915b3b89907"
SRC_URI[sha256sum] = "ed957ebcb68d3534ea5c27e31f07c022c6fe83ff7c1d51f2e18d4f270a1a30cc"
