# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8dc871c182a091f9657c6caf8d12ca39"
SRC_URI[sha256sum] = "6cb796465fd458017f75ace8927cd5a7b0ac28bb896b1b5dc1c804e29b88c2bd"
