# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b1632f7a2e29df3e2100e0b3fce07bf0"
SRC_URI[sha256sum] = "d4b929b705cd15c01a722987a8139cbc7799efa8cc3edb978e3a42872c0eb5d7"
