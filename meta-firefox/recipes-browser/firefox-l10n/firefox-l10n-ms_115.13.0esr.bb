# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "44b1f0657bd44edfa7f156bb5e55f1a0"
SRC_URI[sha256sum] = "fb75f584d709e60e684311f2135654115fe46e9c4064bae6cb3ebb90b550db82"
