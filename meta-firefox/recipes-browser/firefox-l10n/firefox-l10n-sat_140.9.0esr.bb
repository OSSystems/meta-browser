# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8816ddf3948af6fcc946238aeb5812d4"
SRC_URI[sha256sum] = "eb55bbad60cced0d0ad38ef5bb341ad795182bef3d55239b3a1e421fa440faf2"
