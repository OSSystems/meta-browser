# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "af6e0b9f7ec4dab53cefd80f2caa510e"
SRC_URI[sha256sum] = "49680bebd75b5543317d1be1b14cc0d63e9a915acad9f95bd2ab80286e42e9f7"
