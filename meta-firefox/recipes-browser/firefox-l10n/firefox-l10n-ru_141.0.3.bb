# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b078f04f9781a72174891d68ee31e7d7"
SRC_URI[sha256sum] = "57fc8e1f5f46fa5d183e43710056676b71a9c49dad67ce03ecd487f98761f7be"
