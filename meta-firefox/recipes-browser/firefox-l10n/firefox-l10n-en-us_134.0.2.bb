# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ab0c3d7939d9baf3e22d02e86b1fa384"
SRC_URI[sha256sum] = "adc2d9c0485110947ce308d2a75395dbee744668a5be5732dfcdb4bfab5ccc1b"
