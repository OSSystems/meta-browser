# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9724e175c0156eb8544222c755d5b28c"
SRC_URI[sha256sum] = "e7aea8f6e52e1c62e9e88773b71faff9cfb7f7fe46e77efdae7a84763aaaef69"
