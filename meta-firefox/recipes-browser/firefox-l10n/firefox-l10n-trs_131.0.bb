# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "98000db65535ff76351a26e00a61a82a"
SRC_URI[sha256sum] = "bcb2a920598f2b2fc21f7d731f929526b89424a267d2b150a436b2f775cbb97e"
