# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8d6b31ea096157b92eb8cf758ed5a0d5"
SRC_URI[sha256sum] = "d45fb5be553ec3d7b9459bf946f5d357279fe676d86831a8a4b72707e583a394"
