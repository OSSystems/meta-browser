# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "652c2c35e5c708199a2d2cb28abe60b3"
SRC_URI[sha256sum] = "0b7a76e0097c04cbb97d6321e5bf097072cf6ca00c82f279ff394db077cc8acc"
