# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d2acc49f4b32f97c74325b5053cdc0fc"
SRC_URI[sha256sum] = "2e6d3a94dca3a4290fb3615b7e3c6c4fdbf06366fa411bcd2c803ccbeea90230"
