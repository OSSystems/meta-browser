# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "14827b12ecae70d349ca9dc89c99a2532360f3cf4c36e1516e71898904267d51"
