# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "eaf1d938e67c18d976116c085c25738eb8d4cdb9e15435dfbb4ca4130039237a"
