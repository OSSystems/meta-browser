# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d75ca0147a93549e5712f1edf1166a201b2747ff7f19db17db2ed81894078e41"
