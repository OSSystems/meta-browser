# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fbc6c2037fda79c69521ceca3ba77412"
SRC_URI[sha256sum] = "08569555ffbc1351f3c067846c701d9d221178fca92ed18b8cf631a8715bf17a"
