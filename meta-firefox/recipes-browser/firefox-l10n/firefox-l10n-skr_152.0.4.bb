# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3a1951df34bcc427bd03b97db79e13a96714a44a697ae2c937c1263b3ddb4e39"
