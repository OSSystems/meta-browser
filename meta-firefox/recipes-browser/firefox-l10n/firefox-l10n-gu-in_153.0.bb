# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "6b8eda30f722a6f1360009486c4a1dc50fc56e925557de152cc8199613870d83"
