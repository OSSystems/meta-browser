# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a1f9b478ea99787bf8a45749f88cb514"
SRC_URI[sha256sum] = "b95594ad62a2d3f3a156b69dbe9336c3b533cf53e57dc2963823426f7d268610"
