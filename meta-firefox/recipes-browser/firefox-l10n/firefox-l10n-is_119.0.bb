# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d8863285699a90f0f4270f3da015de50"
SRC_URI[sha256sum] = "877097848237369c9db337c641b5c6fd904d235c6547c9cf1f20a6335dde4b3c"
