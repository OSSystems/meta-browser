# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "00a52de4ba368b410e92dacb939f2ede"
SRC_URI[sha256sum] = "b71182ea71cc36eb1a4099b81b75c643eac15a5062787ce2771607600864068e"
