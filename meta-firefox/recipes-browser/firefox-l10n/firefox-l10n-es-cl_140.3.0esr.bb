# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "26fcf3037263f30836729b54f7fe7c10"
SRC_URI[sha256sum] = "6d20106050ac22efcface3bbca22035e61bf8368a55f699ce373d8a8db0b4611"
