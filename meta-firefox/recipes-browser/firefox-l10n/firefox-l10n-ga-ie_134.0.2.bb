# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7b4f8cc71b27d336230b35b1a1d112c9"
SRC_URI[sha256sum] = "0f4a404b416fc58bc0e6547023b2ecfbcc26240ae414dbf7106d7d28ef5735b3"
