# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4acd80453195f52794fdec7171d877f4"
SRC_URI[sha256sum] = "001e30c7ad8b3765c81a2ac02dbbb8cd09a33671958c7e7e7d599bcc64108f3f"
