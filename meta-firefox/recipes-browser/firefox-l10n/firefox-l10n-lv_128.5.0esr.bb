# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "52a072557263d05ec4c9fb2593119312"
SRC_URI[sha256sum] = "68cb708e0b96ef2aace390dd341fad62fe58a591f681c7c0ad52374a5e542822"
