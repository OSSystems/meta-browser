# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "29b8402538c196d8eb886456d6bd332c"
SRC_URI[sha256sum] = "5064b1d42b8c0b6196d1653de50e8018965126ac720bb863dbb06aea4d9e4753"
