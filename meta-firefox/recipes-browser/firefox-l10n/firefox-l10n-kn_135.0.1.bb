# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "399e1646e4a63df4acb89fa020fb6128"
SRC_URI[sha256sum] = "8d5309905474e24d581f5fc100b0a9773dbfd4505ec88bb60f547051b20d5834"
