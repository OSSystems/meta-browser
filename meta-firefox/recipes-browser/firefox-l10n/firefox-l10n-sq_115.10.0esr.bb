# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f57b7e272976854e6bf042a513f03024"
SRC_URI[sha256sum] = "abd09772e324a3bdb96841fe0706673edfc4d80ed3276317d531e1d4466e0c45"
