# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1601bbcacdb5ebf39c0af26cbaa12456"
SRC_URI[sha256sum] = "0a78bb051ffc60321fabd0d2f124bb6e5e0f5675ea011e0677417eb00a01547b"
