# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "710fd46018b2478c54c22f7db71a666e"
SRC_URI[sha256sum] = "b2e52c5c0ac9c311612070c5f2f444c17511ad5cc5f8a3b9c1aa4690c44770f1"
