# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e843ecd781c92a5582afea5173371d93"
SRC_URI[sha256sum] = "38781e6a8fa34ca4c91535cebf127ce8ab57aaff6f049127e49cf5e1e781bbaa"
