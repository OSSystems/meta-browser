# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cc05e522dc680f223ac2d7e34ed1a90a"
SRC_URI[sha256sum] = "0d6348d794c242c9d61985d159be1f579487cd47ad2ae34cc657dedc27f487d2"
