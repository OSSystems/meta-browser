# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "54c2f371e76a4735e0329c7a397e5f8f"
SRC_URI[sha256sum] = "3eb8db07eca0aee62fe403f9eef4b83e359a63ffd5fe4081cfb032db9c8ed628"
