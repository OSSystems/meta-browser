# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5dae956f4980bcc0811db5a4f91dc952"
SRC_URI[sha256sum] = "7489f4e5047eebcfd73ba40c95ca5ca614dea8115b01d46aaf15b142222e3f92"
