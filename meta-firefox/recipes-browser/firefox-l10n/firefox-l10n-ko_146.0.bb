# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5500c1b142c2641ad50ce0c9ce89caed"
SRC_URI[sha256sum] = "a7f69448560322a44bbde9b186e23c3f1c5bf34c98007c79aa8b37214373b8e6"
