# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d61bd656a9e477d9ee7a049c691b51f4"
SRC_URI[sha256sum] = "a8d7f2eec16a8fd957c40064bf461ba5fb1c7f1a3d8e45fcdb590271b40a5aa7"
