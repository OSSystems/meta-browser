# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6ed9af1399d0dd8bcc62af210f1669a1"
SRC_URI[sha256sum] = "a758af59d389db49e4e009ca8257659452227aee42bd9651e115f7c25a5dc17e"
