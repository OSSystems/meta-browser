# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b089546a947646a9e67ab7253f02de53"
SRC_URI[sha256sum] = "3968e2ac2af761a6e87bf2befcddcc9597d8c66753a3e0fac2a437a2640f82dc"
