# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b5882929b3cd0628dcc312d36a7208af"
SRC_URI[sha256sum] = "c39a7733ed900ce8c77b7bb9319dac503536dfe195c67e904e94eee1bdbe9f78"
