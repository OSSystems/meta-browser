# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "cc1be5443de39ad478214e35959ff0ba464b9bc887026ee9523be3e7205d2d09"
