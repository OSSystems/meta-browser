# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dcfdee2a77d6b530d850511d4b7707f9"
SRC_URI[sha256sum] = "89d25750b8da69c937f261ed4273f900d3780eedf301ea118c8abbbc58f85639"
