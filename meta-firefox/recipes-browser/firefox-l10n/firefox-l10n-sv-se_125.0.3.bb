# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d1b8113f98fd297fc56b8ec2970288c4"
SRC_URI[sha256sum] = "cf90558f95f02f54c6c2756335130840522d723f67d5c2e006e313e26e54dfd6"
