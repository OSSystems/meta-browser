# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c47407ccf360e5e9d8b23fb786fa076"
SRC_URI[sha256sum] = "c130b96462270d45d6618cd80f8b62e0f699f649a466f4168937f5e7edce328e"
