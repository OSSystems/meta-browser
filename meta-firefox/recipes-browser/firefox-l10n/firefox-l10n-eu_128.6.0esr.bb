# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b46f8b70c834cf9b5475533da55c2ca3"
SRC_URI[sha256sum] = "f8a97a959b9ce31d4d9627a26fdb04c0a6441a435a3644eeccc8e7e02a69774b"
