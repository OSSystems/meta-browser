# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "16629097991ed23b1532bbd0b40c6f8f855d87589c300f4461ba1260005770fc"
