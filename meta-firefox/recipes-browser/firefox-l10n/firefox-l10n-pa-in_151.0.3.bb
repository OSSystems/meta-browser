# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "34ef3843c4cfd3f0c2acc7acc28538a96fc7a22312255d64416729e432497c8f"
