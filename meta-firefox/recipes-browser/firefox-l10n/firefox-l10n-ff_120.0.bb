# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6e80abf364ba3a0cfc1a3d729db94f1e"
SRC_URI[sha256sum] = "c8fd97d55db241d9ad3b96e428a328cf9ca3ba0dbe9b7431185346308e4c9a56"
