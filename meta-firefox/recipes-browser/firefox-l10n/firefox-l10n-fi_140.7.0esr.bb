# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c5af27a01ba0138ea32ab6ec8a27bb6f"
SRC_URI[sha256sum] = "f92514d4bff984a391d05e19cc09747c34593b78e106efd984894180e360b2bc"
