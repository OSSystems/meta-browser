# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d9d7c5a26923e364743df57d1e1e4d22"
SRC_URI[sha256sum] = "25ababe3f7525b904fcae8911def917f2605b8d9b769d6be61f3222d7f7046dd"
