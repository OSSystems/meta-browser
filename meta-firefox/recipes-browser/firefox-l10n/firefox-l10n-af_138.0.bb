# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fe1a929b19a52b0c77da22e8c855d836"
SRC_URI[sha256sum] = "7156d6747e4a97016bc4abe5fc7c3f2333ceab3ed1e4a75177d14b688acda55f"
