# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "547c5d4f6d08bf44362aacad3b631aef"
SRC_URI[sha256sum] = "fdaca6689cf836a36262a1301b6820ad918d30b454f30cd05a6223a1e23d9e38"
