# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fb7c595d21e325293727d1d33209b0fe"
SRC_URI[sha256sum] = "0b0eef726e1ddb335ce4ff2db8f272768afb7c4c279d9905578cac561d084a38"
