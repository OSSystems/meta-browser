# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "983025c9d817ba743eaf24350d26f4cf"
SRC_URI[sha256sum] = "5970759bfbbaf26992fed95a88cf49624c726d78abbc9512848252f3e667f1ad"
