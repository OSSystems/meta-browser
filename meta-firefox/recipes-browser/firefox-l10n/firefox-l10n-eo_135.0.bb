# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ec1d029f3bdb23dd6e3631c98e0c3735"
SRC_URI[sha256sum] = "25bc0bb64e005e9c6f375efd9dcbb0c239d116c702d8368d3c5af8a68e236e71"
