# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "61f9afdadaf3e9cdc9b190ac9f39ff90d15a1a1b9949f0950d783f4dc8014e48"
