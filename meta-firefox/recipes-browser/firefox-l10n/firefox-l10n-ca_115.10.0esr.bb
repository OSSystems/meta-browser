# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b1a0a976eb835ae9f55aedc24000a7bb"
SRC_URI[sha256sum] = "56474d248158693deb7a7b30eaf82558e4ba825ebd0b362cb39f272c6dcd5532"
