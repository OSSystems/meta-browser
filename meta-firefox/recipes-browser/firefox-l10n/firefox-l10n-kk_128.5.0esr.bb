# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "21e4678f87bebedc0a424f051748d2bb"
SRC_URI[sha256sum] = "02e61eaa35298db2bd713baa89a4f20cca6d248ecd0f06c5a0b434b16af51a5c"
