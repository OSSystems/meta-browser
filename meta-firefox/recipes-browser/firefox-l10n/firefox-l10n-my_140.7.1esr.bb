# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f3336b078a842be98046cec00761a234"
SRC_URI[sha256sum] = "0114affde940a388f3f5ee9fda2a41468fb73cb8df702796f58f1fa2865b51b2"
