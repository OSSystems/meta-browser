# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "af8cf7ad97362cce0b279ba3893fb709"
SRC_URI[sha256sum] = "ad886129333ef74cf672dc5317bd3e810c0e28a15e33b16c3e2fa37c625015ae"
