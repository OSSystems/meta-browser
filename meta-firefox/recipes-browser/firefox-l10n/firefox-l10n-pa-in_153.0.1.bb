# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "8e19ac8b32ca0b0886ec9f79a586f6f30b5d9a0317bd78f0af9b1ad6a82ff9c0"
