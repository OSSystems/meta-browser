# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "40b608bb6ee2f6714498d21ececeb49ba1a2d9f328eb13f375d6786b750e3a85"
