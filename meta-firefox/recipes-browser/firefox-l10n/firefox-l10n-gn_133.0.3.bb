# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d5542b997837a96304360ef376a374c2"
SRC_URI[sha256sum] = "b60b5952cc4be7694831fb73c64a5b18589d311d7e6641ffb5ed49d1096a6d8e"
