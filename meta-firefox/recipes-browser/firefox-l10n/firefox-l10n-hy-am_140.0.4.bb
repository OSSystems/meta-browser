# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bacbb3a25ea52d29b5434d96dd4ed5e8"
SRC_URI[sha256sum] = "bc5820326f4ab3d6d07a42b1fede47ec0360a8bf8d8aae7eb38b5e9fa6a0cee2"
