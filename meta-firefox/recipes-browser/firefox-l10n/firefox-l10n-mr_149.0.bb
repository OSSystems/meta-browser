# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6355acbf386f00a0b50fdf580d5012b9"
SRC_URI[sha256sum] = "3b5c56030b1f93f288b2065fc397578968f25ad4aa423ce85262956b1136147c"
