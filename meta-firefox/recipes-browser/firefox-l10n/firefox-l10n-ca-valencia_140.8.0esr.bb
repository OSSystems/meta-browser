# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "428b58077686ae0e91b84992456d6a31"
SRC_URI[sha256sum] = "71b5d2a1320c73dfb03958077db95d7b7606c95a35f92bd12c5cee26ba73c9bd"
