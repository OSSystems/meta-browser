# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "6daf7e5f1b4562e0ee45544349e2125a9cef6aae7f6200400a44a565e039958e"
