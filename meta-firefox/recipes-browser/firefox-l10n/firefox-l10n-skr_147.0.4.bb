# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d046be943123e1b6bd9d4eb60807525e"
SRC_URI[sha256sum] = "ba4f771067e7c296a9cc3240c769d56889b502c89b375c93bd002c3adee5b3c3"
