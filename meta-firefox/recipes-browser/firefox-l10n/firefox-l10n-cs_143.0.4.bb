# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "55de679c5c3f759b4fab85f913043f02"
SRC_URI[sha256sum] = "33399ea98e6b91b573194d68e170bfb494a1fc4fc0b3ca1b024daece85c75310"
