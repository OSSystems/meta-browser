# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fb53440ba749d71f165ce5f88b1d2823"
SRC_URI[sha256sum] = "a36f19674115463038867058cbc899f6c903ee57366e9a0ab2707ae85517d62d"
