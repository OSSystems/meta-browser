# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e10e820035873c74632a464a59f324ff"
SRC_URI[sha256sum] = "9f48f57e8f154a2856e9056958374fa05b30f7e632e7b1f192253322df98cf20"
