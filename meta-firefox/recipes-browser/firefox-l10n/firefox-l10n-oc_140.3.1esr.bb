# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8941c6139e1fa0ac5d7006a5a9589eb5"
SRC_URI[sha256sum] = "5eebbbf35439e03d4d074712abd750f9f3dc40a67e8394045938def43cf320f0"
