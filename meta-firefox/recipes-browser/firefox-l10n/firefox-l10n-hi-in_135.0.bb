# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4bec013e4f60e5566978ba6b2818371c"
SRC_URI[sha256sum] = "986316ee1b41e0f69616a9b6be5753da15dfcb91081d1eaa906ed48c728054f6"
