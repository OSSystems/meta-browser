# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "74f774219dc9c07e79a63af4e0c89827"
SRC_URI[sha256sum] = "91fb367359fd03f1ebdbaf46ffd710c521852878a88b241c214d160dcdf6aba1"
