# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f139a2ee9e0409a8758a9ae4848eb229"
SRC_URI[sha256sum] = "c8b17ca2776142ccf55e08aef8b37801f18ff7bbfdbbe3e06368e2ec5ef5698c"
