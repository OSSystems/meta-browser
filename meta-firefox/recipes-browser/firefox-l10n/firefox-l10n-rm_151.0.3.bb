# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7e03ba3c1f50e2740f499f5e2ae814d4394ea387e02cc1339f0775ad26c00a39"
