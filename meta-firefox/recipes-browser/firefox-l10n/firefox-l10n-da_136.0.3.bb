# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "63b145934e2f95d2c4d7387f39027763"
SRC_URI[sha256sum] = "ec21eca0c653e0f7bcef9d726e292a3662ae2f3126450c08925d9ab2103146bf"
