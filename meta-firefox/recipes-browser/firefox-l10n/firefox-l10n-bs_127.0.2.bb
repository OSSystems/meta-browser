# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4fdba1593453b83fb32d4069092c740a"
SRC_URI[sha256sum] = "e335e429324c2a3b4f5e73e7a3f094fd857664889eca035dae030e13b602f44b"
