# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "52d0486a7b9e83a1f6c36385d83118c4"
SRC_URI[sha256sum] = "3001badb420d44f0ea227a973c4ca5bbb7f0fd4bd85c1ed12454cc8b78c5abf6"
