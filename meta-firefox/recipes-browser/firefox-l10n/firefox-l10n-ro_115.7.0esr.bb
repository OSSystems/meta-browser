# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1b152783702c647549a4c413fee2f289"
SRC_URI[sha256sum] = "8f626d0a63ba419bd67da57b7eadafbbb9eff1b943e1ce728428c27cff6fd7e2"
