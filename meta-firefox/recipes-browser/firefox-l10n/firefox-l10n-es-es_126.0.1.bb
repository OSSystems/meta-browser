# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fb957e3a734429d2b69811ad30a598e0"
SRC_URI[sha256sum] = "de3e05f141076a49bd3a828f11098a20736b9960b9cdb254ccfabae345528311"
