# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9591aa4914c364b378227ec193aeec46"
SRC_URI[sha256sum] = "58c02aa582814f606d74b26b733294294310d0c62373617dd2ba0affd3455bd8"
