# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "41a683557bcab9287aae4ea8f86909c5"
SRC_URI[sha256sum] = "ad3caea0de7921bfece00272818259eeb2672487fb4f8afd9dbda32b96d5b94e"
