# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7d90d991621bc325ea429eb42533a059"
SRC_URI[sha256sum] = "2072a112dcbc62374391906d7ed982ab22f64fec38655abb024a92bf892c00de"
