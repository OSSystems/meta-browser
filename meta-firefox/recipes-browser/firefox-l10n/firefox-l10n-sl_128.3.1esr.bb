# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8eb769f8922a66b4aa8a6b3dda27f766"
SRC_URI[sha256sum] = "2044ecc1f7b9a5e3cc1882ec0b65c73148de8f662c14c0314abb56533c7d68d2"
