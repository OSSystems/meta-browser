# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3dad61e50abd96b9be9ac88afaf0fa9ac2f7435659eeee61571e5d69e0551fd4"
