# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "21bbc288b8c9db8c499d770550cffd60"
SRC_URI[sha256sum] = "3719baf9fdbead282bd6220a55e864560903efa1c936dd8bb5f58f50f29adeb2"
