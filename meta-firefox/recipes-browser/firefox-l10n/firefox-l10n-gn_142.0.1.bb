# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9a37a05b86a655e455e4dd56a21d0200"
SRC_URI[sha256sum] = "46b9e7adf5f9e18f851596e18704d98e70c707e43f5f251544e9a8651fb352de"
