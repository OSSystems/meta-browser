# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9542ea51fdb4618e34c7218844353105"
SRC_URI[sha256sum] = "c2ba919823d3df9bf967eb64960cd733254f54fd66239f7733ebd30359a32b5e"
