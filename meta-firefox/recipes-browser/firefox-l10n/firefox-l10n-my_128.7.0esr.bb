# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "917328fcf4a8e31686520dca4cc66613"
SRC_URI[sha256sum] = "c368bdcb1230a05daf65203780906cb0c685b89c1f34ba2f6ba72db5cfa9346a"
