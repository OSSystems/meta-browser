# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d96b2bbb97918181c48265485bba1b23"
SRC_URI[sha256sum] = "a7cd519029e00c730920428dfb2d95243d06acef10439891bf81838b3fa1a809"
