# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2e13e1ffe5f415e1099c5e8d9d13594e"
SRC_URI[sha256sum] = "543e12ee1fa3a0c42695363576a4a3d89b1a6907b9efeefcd9f15ba78af90e86"
