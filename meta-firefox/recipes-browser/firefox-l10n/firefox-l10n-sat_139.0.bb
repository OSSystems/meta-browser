# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d5bec19f4fcaa0a2df848c79a54020cf"
SRC_URI[sha256sum] = "1a8b65daafcd62ed74f17e4fab081bb70bdc1ec9fc0f83f8f553a516e44b0f3f"
