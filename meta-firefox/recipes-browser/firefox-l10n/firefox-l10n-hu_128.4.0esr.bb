# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9d8222686304a5de1eb5c12b0bd10f33"
SRC_URI[sha256sum] = "e59529d2f87e446127e04e69e723cce157217970d86a8c8c6a20c7ab8631f4fd"
