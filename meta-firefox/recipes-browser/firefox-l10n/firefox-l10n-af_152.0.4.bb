# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3d83d13c7365a298fcf010fd89db24eac130c3f1cb2deed57d497d6709cd9007"
