# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "76b30b93ce3481212838f5c294730e9e"
SRC_URI[sha256sum] = "4db3f51d94d11056d7692775c083f0173c2783908ad90e7cc377256ad4789e67"
