# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f55ca60337d31cff2428d7c68bf155f4"
SRC_URI[sha256sum] = "01b85b55f70da43338bb176bb8f0fbeb2afa6080d01eb40b120f56e96b4cc45b"
