# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1be4c2821fdb68dff06aecdf353e4f43"
SRC_URI[sha256sum] = "905eae4ae0907a1c93039a3f115940a7bdd2b9767e623267928232d365d2eae6"
