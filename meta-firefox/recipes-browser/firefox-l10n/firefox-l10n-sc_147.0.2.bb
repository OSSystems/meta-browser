# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e0f15bf9e5bbb0888aab50919700c5d8"
SRC_URI[sha256sum] = "a419d1b684854b8bb5c9a2925f99b8ae361ff5d27abe0845c49972eb69d752a4"
