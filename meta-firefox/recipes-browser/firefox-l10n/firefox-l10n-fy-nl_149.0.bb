# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "56c78a1a14dbde2c0788173ede42d928"
SRC_URI[sha256sum] = "53472634760974ac5ddc25a2d0a7ac654de5e641d05ea55ab301fa41a4f6799d"
