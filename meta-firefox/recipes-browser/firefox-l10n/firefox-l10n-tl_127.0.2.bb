# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "575ec717b886a459380a1398c52fa124"
SRC_URI[sha256sum] = "d60d0e99c074aa5c101fd75da66219465faab043c3967030d8cae0b8e74afa79"
