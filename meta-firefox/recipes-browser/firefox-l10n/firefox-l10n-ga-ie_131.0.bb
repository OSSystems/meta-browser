# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "383da8b060205ec583e787ad12aabdf6"
SRC_URI[sha256sum] = "63050b796a59601ac30656ec827aa87d0da5434976661fcec9f55e9c5d60d2a2"
