# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "b459581f5ef983b56c79f8b5ed0f9664682115495fa00c15d75e14275a53d70e"
