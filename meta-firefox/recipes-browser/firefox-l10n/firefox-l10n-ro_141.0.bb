# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5f81320ccaef1dc17dcdad2ac46fb456"
SRC_URI[sha256sum] = "ac5e021946de8d7493d933e346792f0030f9c3e446df1854e0651fdd2b10473e"
