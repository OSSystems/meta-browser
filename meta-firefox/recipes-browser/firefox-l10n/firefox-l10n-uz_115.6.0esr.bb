# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bbb00a4814671f86c831d8fc270bec92"
SRC_URI[sha256sum] = "dddad384cbd040144f501bc55ac29864018a84e65654824500e0ba7514b81de1"
