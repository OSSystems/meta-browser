# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6dc8ecdadc3034e77b42baa56fdeecf6"
SRC_URI[sha256sum] = "cfd478cceb17292c922bae3710736a24db793860102834ca308f5b50c4e88b6e"
