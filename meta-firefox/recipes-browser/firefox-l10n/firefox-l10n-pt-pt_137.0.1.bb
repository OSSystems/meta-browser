# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "edc6a21bdb6dbae367654fa765116a96"
SRC_URI[sha256sum] = "61ded72874356892527ff39ef604d5c964b89a4ba992d6134c65b51d508b5d35"
