# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "95f49e9ee3bd36f5c30a32ac585cfe87"
SRC_URI[sha256sum] = "0eb6c3cc90a343c8e4f93ca0b3439eff3c9911422c1b989a695aecf8e6f45a86"
