# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d7b1dd660729cef03d351ed937819e3f"
SRC_URI[sha256sum] = "6e6ba4206d7a6cf001dc6be9363d5882b0249273ad01ad0b0f039aa882fd0da0"
