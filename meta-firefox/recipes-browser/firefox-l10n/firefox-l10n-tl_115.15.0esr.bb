# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0b36c8976b4ab993228f22c526547fdf"
SRC_URI[sha256sum] = "184312b2d75fe0aee3ec7e7f774693972cd300b92f59128c2337b8b4902f5dcd"
