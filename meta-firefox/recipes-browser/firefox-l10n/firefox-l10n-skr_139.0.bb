# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5b408cd343c2eb15c5224a9d4f87a413"
SRC_URI[sha256sum] = "862b669c895c1be9d89c3d8cb875f266db9ea8210e6ac6f461746acfc4244e05"
