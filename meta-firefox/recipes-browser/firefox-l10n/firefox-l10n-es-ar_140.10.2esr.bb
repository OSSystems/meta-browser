# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c202cd5b51a246c266459a1496b3552c8f095ecdef1af53f468d64b04d294657"
