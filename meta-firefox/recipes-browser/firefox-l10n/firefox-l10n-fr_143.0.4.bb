# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "937e0861ba100d50f5cc1302e2416d38"
SRC_URI[sha256sum] = "3f74e499ac3bb744539cf141fda825bb4240285320cda429c4d6e88fbe17156e"
