# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "b35cb23cc3d988998030c0a043556e93161094fa003c9be5a353f73e69871eb9"
