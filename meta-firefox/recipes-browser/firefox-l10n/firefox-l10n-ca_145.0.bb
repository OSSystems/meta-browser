# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7ad72c547ae48ff4b6edf803119c981f"
SRC_URI[sha256sum] = "d7b5bdacfd46a201a8006a854e8b8942c5f01667778f834d3ee873053b77069b"
