# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c813fa95c09b45caad511d44972da05"
SRC_URI[sha256sum] = "6a791c36c429a60d782aafb6d604e605e4154b644b205a5fb7a3d91dfde98da1"
