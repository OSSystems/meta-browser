# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6a4016d4f47a75e7acde6d7901278ce3"
SRC_URI[sha256sum] = "106d3bbdb0ed4f1eb0aa18b96e7b32f18e615a6fe4c1b7a5d1f02737a9c22e60"
