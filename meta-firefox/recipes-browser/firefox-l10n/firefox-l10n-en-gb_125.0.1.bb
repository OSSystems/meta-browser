# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ceb8c81bbf733f9c01e00ece61675424"
SRC_URI[sha256sum] = "852ad9cff70e71b57863cf3cf1b8464ac5ac0db1da6f1c81b1777b8c62e61c91"
