# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "11075e655157cc7a8762fd9973fd70ee"
SRC_URI[sha256sum] = "bc47da82d47001e1a5e48ebab1ac609f306cfee61a714e51052053c96d9b7139"
