# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3606181abca7a7892c9a8df18bee2109"
SRC_URI[sha256sum] = "b6d253fd839ff73262f3b75dcd4c45da1d4b52f20634d814af8b5a332fd3916b"
