# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e52d7f9e09433c91e0b01b18acf49c9a"
SRC_URI[sha256sum] = "431804c8667bfec8e44114e9af766db15d80317b16fe6b5e6a3a08a6b97c0aa4"
