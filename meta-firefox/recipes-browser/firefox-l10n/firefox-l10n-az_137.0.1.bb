# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3dc6078525adaaf8c90465c3131c27f2"
SRC_URI[sha256sum] = "d3a79e3381426152115d64612915713fea8020dbf68ec9bfd8195b3720df862d"
