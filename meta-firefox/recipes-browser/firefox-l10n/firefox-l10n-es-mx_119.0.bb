# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7ebf8af6130c60733bb9e089ac167a1c"
SRC_URI[sha256sum] = "01066c8c01004983a6f517ed5aec5ef235890623b4c3d9c885a2cb260057bced"
