# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4ac8a1808cbf4e8d16a8e7478384368a"
SRC_URI[sha256sum] = "8cb589849df46349c48236d4c56b03f8b07f6fa8b4bf0c28d2b40a8ef7d5cd8c"
