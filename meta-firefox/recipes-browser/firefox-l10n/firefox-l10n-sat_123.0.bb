# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9f961205ec656953a59219d66361f6d2"
SRC_URI[sha256sum] = "5d980d33b17b6f19c6d36fa26f563639c685ea89add8fa8f9070f2b5caf007be"
