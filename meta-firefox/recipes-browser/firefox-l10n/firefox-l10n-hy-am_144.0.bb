# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1c37885499ad3320be18ed11652de72b"
SRC_URI[sha256sum] = "0944c5f78e60c4d9c7b5f5be62804d328cfed18cd3eadfafed61e0415271b8a7"
