# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "759bd37ec58ea288fe76142d831084251c334bf7501eba2dbc03521622aa7010"
