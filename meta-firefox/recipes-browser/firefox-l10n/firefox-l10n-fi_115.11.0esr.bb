# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2b23bdaef0466b477b1fb9fd50304edc"
SRC_URI[sha256sum] = "c31554c8a1a7ba867866f1cf42854e789b1da6e5e8d2fdcaa97bbffce7debf8f"
