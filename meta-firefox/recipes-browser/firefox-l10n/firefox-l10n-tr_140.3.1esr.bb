# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "826dfd9332a15604a51c42c0c52c014f"
SRC_URI[sha256sum] = "de77962c823af6642d67cb1b6fdf06f6984bbbd37d5353a354a65f7bde52cd58"
