# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fd6074536641ef62dd441326f6a8b630"
SRC_URI[sha256sum] = "876c02aa2ff38e0cc0128c0a7e19d3a12e8b15ba5e3a90d24d0dd5af690d4eed"
