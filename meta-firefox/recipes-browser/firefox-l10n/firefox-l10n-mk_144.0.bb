# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "62f8715bdfee0b5501259c005fe559a7"
SRC_URI[sha256sum] = "112fa344f32aceaf330368522acfb31022e4a269ae3c78b48604ea590ff09a7b"
