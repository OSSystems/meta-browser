# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cd71f710007e3c5808b60857350e2352"
SRC_URI[sha256sum] = "e86a419818ddc0be6088726d78ca0d32054cbfcac864964e49b8234236f6a3b4"
