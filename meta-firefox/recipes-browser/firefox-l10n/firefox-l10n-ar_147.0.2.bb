# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "26a294861548fbfb141d5c737c0a028b"
SRC_URI[sha256sum] = "852dfe97a246983a81116ffb9684551a0d48be742e9f4f1dd34f428f8dcdbdac"
