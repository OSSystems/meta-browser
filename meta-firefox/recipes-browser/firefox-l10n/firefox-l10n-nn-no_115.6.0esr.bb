# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8d3c81d773940782a3f441a577d8bff1"
SRC_URI[sha256sum] = "1d27c40a9aa95881a6d088d4cdd07da8708569a0dde3fd80d3c7514624b1676a"
