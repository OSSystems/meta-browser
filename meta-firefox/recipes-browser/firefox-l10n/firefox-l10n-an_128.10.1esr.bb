# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "92fb5f6ca10a8a1ef3bb078a30f4c876"
SRC_URI[sha256sum] = "b26f3da7277c0cd966cff92953155c910436b963dc3525905f6e51a15f7a8867"
