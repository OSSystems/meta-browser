# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "70efbcd44f78884785ffd2c9f4ea001d"
SRC_URI[sha256sum] = "b2c43de99a93fcee11a6de0e1a868b3c760a35b5d384accfd6242e19633882b9"
