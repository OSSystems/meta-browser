# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e001b325f21079aab2bbb27a2d17a5ef"
SRC_URI[sha256sum] = "0d7b3cbe9fd1974115db60ba280e81b11db2a63323aff505017926d593225a2b"
