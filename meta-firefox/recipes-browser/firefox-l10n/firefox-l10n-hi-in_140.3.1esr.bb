# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0f8e362d69db1ee69974d20953e5e667"
SRC_URI[sha256sum] = "b89eb32061fc571b6fbf74f615faac391ed7d8a57d487827aa6504e56ae1e350"
