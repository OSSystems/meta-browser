# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "afb90632c43833bb07adfc217bc2434d"
SRC_URI[sha256sum] = "2f40b734cf33176d5c526c31160a614cefdec645afa266f124e5cb4b9c315259"
