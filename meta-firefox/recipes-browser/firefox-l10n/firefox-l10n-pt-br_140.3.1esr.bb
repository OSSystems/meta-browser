# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bb44ce2f3ae5e382be0a4e5da9e11cff"
SRC_URI[sha256sum] = "a19ca2d383eaa3aac799705761b66c6e59f7707652a15f4d608a1d48f6bae901"
