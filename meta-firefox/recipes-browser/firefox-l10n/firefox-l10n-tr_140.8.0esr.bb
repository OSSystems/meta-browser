# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5c658ba6f4882e0aec7d47b0fd3bcb5f"
SRC_URI[sha256sum] = "25b6fba1fd1a58f9732056042bfb79448470b4a80b524e8fc1530bcfec4eac5a"
