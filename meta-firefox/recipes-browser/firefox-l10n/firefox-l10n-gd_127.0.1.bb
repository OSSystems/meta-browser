# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ac95226dd99cb01000108d35b817d46d"
SRC_URI[sha256sum] = "a0d6e55b7efa41c1434d9e279c1986cb193063d873897e9f347f8848d8546518"
