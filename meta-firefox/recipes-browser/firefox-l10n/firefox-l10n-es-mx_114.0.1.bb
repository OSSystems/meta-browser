# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "be88ae81c47ccb2773cb52f98ead4323"
SRC_URI[sha256sum] = "f6574920280a70b24f74ad9c33018f5da680807c9d1aaf64499f16d9c3820eb9"
