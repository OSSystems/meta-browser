# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "19828ba442499a6136d2a522e7c48acd"
SRC_URI[sha256sum] = "d258751e20cd03038ef5532736000f139e92a78ff9276ac1088c6f548ef5588d"
