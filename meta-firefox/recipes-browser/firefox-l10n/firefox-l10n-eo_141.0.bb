# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bb3e98ebef0ef99c16540558a4214255"
SRC_URI[sha256sum] = "84d321c95b5bddec8a9e3b74d1aad7b28a2e9f5cfac27668327173530f74bc9a"
