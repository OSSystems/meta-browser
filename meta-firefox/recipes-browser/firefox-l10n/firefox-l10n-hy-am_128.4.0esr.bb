# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "82ca6d7360accb95dab6f18b832a710e"
SRC_URI[sha256sum] = "0329779758cff26ed3f88acd8a49a50cdb54c872414b43c079fbe1373188ceac"
