# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "065d8c950a499a241897a303428cd1ba"
SRC_URI[sha256sum] = "1b4a79c7d660fafe2ef5ab89a829a5ab8faee23c9a14b291af7bd064b45689b1"
