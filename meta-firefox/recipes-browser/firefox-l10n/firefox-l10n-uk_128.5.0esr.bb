# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8426f9ab5339cdf83ffe6663583630d6"
SRC_URI[sha256sum] = "ab79e8c83ad201720ea98d96e76921cd86b87eb01d9a610e2d0d5af602987a92"
