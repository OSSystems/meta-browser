# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9f83c4c816fc65179f775f4083dcbe21"
SRC_URI[sha256sum] = "bc6c56f88eb78e38c597ce0d9d841773ea89f6fedbdbee24ebbeb66dc1e10389"
