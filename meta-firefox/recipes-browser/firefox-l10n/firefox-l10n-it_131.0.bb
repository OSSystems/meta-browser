# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ed5137779b0b1ef1bd54580e72eead5d"
SRC_URI[sha256sum] = "64f7be6c5b9d379e5da0646a941a9dfa0c4a377f9981cce572d8596f3b685ce8"
