# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6f128ca2ce43b3069b27e393995292dc"
SRC_URI[sha256sum] = "135a5bdc68fa49017c74d1952ae15206b3894066b1e1ff834298224775dd9ff6"
