# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3f515bf42a4e0eec515ae5212444312c"
SRC_URI[sha256sum] = "e97871295dc1d243801e32d822ecc6d558b5d95c27fff6e2fdde70e4f9bc6e33"
