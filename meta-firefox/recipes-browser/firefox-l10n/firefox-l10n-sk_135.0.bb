# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "167e95d71d119ca49729e654bc920e46"
SRC_URI[sha256sum] = "ffeae211ed6efc624e867ce1985cc707fdc5a6376dc635e9b4fb090bf3464e31"
