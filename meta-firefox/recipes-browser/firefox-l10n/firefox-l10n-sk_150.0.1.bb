# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "13541f174fcfcdc9cf7c596cf2f9d8fc9c2b2cead2dbf20ef5786892000f47cb"
