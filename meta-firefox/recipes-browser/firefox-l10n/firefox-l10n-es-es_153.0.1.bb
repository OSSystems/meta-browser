# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e8b02eb0180e5acdd6ca2437645b872c873d3a7b756e90a5f5539cb0030173f1"
