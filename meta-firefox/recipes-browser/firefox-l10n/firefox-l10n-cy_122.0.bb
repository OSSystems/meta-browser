# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "77433232ac1ad69f88ad0c9fc7c271d3"
SRC_URI[sha256sum] = "ae7150d67cf950286cfbb63d145b125b9faed23e93ac37ffc074b76642253d00"
