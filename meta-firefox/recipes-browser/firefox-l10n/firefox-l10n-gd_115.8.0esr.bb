# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7e6819766a9deb7dc30b8c223f985db2"
SRC_URI[sha256sum] = "12ba7a2e24061a90738b832fb858f2ec203179474b7853651276e28a54f55f36"
