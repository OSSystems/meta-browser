# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f9d673a1b579ae84b8bc553427af1c0c"
SRC_URI[sha256sum] = "0faae606225ebcb827befd35335f6ab9e48b492c1eb53934055a7cac2846eac8"
