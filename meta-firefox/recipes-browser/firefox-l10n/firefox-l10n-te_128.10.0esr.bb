# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c06c5cc468480b9fe63d23a5b9c875ac"
SRC_URI[sha256sum] = "3ad43b373b8c4dea04d234454d9214718bbda9c24c683c8eac1c8efadc43d7d4"
