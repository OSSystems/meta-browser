# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "26e0a81f74d0e4b8852139b1d89f5543"
SRC_URI[sha256sum] = "5db51b64c39baa20c3156f7050cf5bc320b0738c5c8e5a00b898edc25a7576b2"
