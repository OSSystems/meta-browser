# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a3b3be473e49a25ad38e3d047d96f067"
SRC_URI[sha256sum] = "614586cf20de431b631bc2d6705303440708e45f5e64c08e3b95a71e4a153d54"
