# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5c22117ada66055d567795075c44bd10"
SRC_URI[sha256sum] = "641ab297473bda3452b0c71b83974d46c0056cfc89c27a3a7bf63a5cfb476d99"
