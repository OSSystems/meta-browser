# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4306f4dacafc5293088ded86afc1a188"
SRC_URI[sha256sum] = "a8f79c4c8b4f9441069baa05c7032f5c23e42f539970bee799a4114ddb1cf706"
