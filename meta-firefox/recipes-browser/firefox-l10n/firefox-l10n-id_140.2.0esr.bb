# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c76b8e8bc56a2b96544725aaa8f895b"
SRC_URI[sha256sum] = "fce35387dee46fe389749356411814f59262cd5e8f1c2b052ea55163f958cb01"
