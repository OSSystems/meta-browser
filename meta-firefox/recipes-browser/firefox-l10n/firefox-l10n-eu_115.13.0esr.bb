# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "17243cb7193097aa102c99cbf0c0e449"
SRC_URI[sha256sum] = "51616235926e0691e563a5a0457562ce6ee54f44121c138a22e34a0379104680"
