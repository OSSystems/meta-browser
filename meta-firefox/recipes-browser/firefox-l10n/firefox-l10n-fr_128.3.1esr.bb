# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "08ec25367b3c1223907ee21bff364eb2"
SRC_URI[sha256sum] = "4f27a9ae529578a3fee1c83140466574e968df0104ac49ad895de7905ac95583"
