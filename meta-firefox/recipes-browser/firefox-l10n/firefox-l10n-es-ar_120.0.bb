# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8e26017fac6ed5f2bf06c17057106952"
SRC_URI[sha256sum] = "3832b8a871cc33dd94fa10d633086387353fb9c2e3ee26bf9b774d6ca4690451"
