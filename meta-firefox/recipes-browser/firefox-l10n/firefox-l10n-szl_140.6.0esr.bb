# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "97fd001f14716be6511ecfa19ac687e9"
SRC_URI[sha256sum] = "d6fa80c5640734b4d4ec07827949973817879878c3cad163feb32aa7a6cb65b9"
