# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bf7f0c46400ae9fae29db84e707d0489"
SRC_URI[sha256sum] = "93291ca86ea7b6ecfeb77e8f0a0e0b17b5f71d4559af0bb26bd080d1fbccd4b1"
