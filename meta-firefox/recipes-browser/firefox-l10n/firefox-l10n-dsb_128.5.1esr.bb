# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "48c0f38aeac72a3205739246119b5466"
SRC_URI[sha256sum] = "11e68f4327e0857138f86924dba7fd0bd729a2253ecbcdea95e580d3a09a9c63"
