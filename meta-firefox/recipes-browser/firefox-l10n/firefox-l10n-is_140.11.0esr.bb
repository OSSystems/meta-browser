# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "a4ba6cd7edf9e1b770ca52e6bb0d7c9e97055f99d1e5dcb258151d1f6e580df2"
