# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b428b5ddcf81143430e8f1768b038240"
SRC_URI[sha256sum] = "0b06a94b07cb8fc21e505d4ca46bc18e87923cf4074bb7dbd694021aa0c65666"
