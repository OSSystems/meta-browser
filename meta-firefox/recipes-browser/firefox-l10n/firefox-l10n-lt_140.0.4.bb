# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8194169fc4c7e0f8bbfb415efa0b94f0"
SRC_URI[sha256sum] = "98f74ea0daa23f1543598cb3ee681b282d513835ea8281002daf39ed3187dc67"
