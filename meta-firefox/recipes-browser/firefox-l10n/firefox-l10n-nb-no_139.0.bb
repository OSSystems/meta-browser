# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "037f34a870a4ad89fb303333a0f9ca90"
SRC_URI[sha256sum] = "5816a30084e33f8d45b8faf1ae5bdc04ab77e2797c464adef9574dd80b4c18e1"
