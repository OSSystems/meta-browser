# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "08d30faba7580202921f42547a759109"
SRC_URI[sha256sum] = "773f46c49fb05107f1da9f38fbba11718465947dc0c635dd534bc1bf02554e49"
