# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5d1bd58f8df60b4baf77a1c9ff87f81d"
SRC_URI[sha256sum] = "765bc69c1a62c30e14cb90f943fd786fdee4e8e23820dd1ef14918d27baa93ec"
