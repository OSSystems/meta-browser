# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dd73c10af337b0c851cc59bb06f83a96"
SRC_URI[sha256sum] = "7b892b06b2cbd9bff2252d93ac5df0bff7748dd36faa9ca80f99e77a78b536cc"
