# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4642e7751a5d4d57a8e2f47596f47fc9"
SRC_URI[sha256sum] = "4b415df26a35f500432fc365d73923229304761ff85c5b8961ca82eaf2405faf"
