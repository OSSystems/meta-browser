# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5046bc4e3ef07d9cbcd55611afb99aad"
SRC_URI[sha256sum] = "e59bf11860e17c3fdcb8e10d8e19c1ad4781785d857591f9ae5dbe7fe0d1f0ec"
