# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0344b6fe4d0c97e50916399d1ddcccb9"
SRC_URI[sha256sum] = "cd3ca341dc5885b86abe862cf4645c90f4d301ce31bb4d5ab190364be2d80a5b"
