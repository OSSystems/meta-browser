# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ec24ed87eef891aaa679ed0d810529ac"
SRC_URI[sha256sum] = "b7155497f1a76e877d4411a9b2558b7e7e85c327e6f4dfd143b795c304633753"
