# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a3c3443510ac171748aebdfe86a70246"
SRC_URI[sha256sum] = "f5e4482f82c3166c2d180edf612c1345a7751c0157b13ba1a8e4013d898e30d7"
