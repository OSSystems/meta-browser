# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "62845724e1e05ce2228fe3e8b4f6b29f"
SRC_URI[sha256sum] = "ce7fcf1923c79d572ff5f2ee53f228630a96ebe7b346315c0267a9a87f87e578"
