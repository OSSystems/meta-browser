# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ce0850efa08321deec5fa69f14808b6550b170de51333eb5e446448ab59fbbfc"
