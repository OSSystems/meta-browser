# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "53dd1d2824eca86e0bac06f625b53955"
SRC_URI[sha256sum] = "4ceeca21bbff18af20438390f716ec39178dc52e5761621f4e123712f548b0e1"
