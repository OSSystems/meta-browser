# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2246f280014c9b9e3140b2a1f59d3cf6"
SRC_URI[sha256sum] = "4f4d0e8bfae9b3ad5e3ce55a37e516e9c2edb85eed2f6ff3b2dc2022a765cf47"
