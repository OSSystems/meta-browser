# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "34b3e3a6874f8cb7987be4bee8626f16"
SRC_URI[sha256sum] = "960a32591c8b8e6dad6c0d1aacbb62a2438371a2d85c1ae437be3441e4115e0d"
