# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b0f983b96c37a6a7fbc7b863aa2f7909"
SRC_URI[sha256sum] = "8a19df3995dca42b2d679549402d73793ce31dcf2bfe958cc2ee24134d9cdb1d"
