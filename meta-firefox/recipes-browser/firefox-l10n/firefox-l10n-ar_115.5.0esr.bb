# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d8dff340b2e043247e688302b7c64d81"
SRC_URI[sha256sum] = "c911958dfa62fc35a5fb352d6376b622a1bcdc9108372f030519c6cb6c1a25c8"
