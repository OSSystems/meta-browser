# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "696dd5e7682abaa59ef4734448722b5f"
SRC_URI[sha256sum] = "a22b98c594261dc795bba165f4af55b8bc8a20e184e9d33f2f70f0d5b17eb906"
