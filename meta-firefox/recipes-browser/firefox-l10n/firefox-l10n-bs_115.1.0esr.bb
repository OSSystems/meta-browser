# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fa20338ae3396c5235bbaf7ce36ba096"
SRC_URI[sha256sum] = "895a84219b29164703eba389cd438468d5abdbd7bdafb437c99fed353370e45b"
