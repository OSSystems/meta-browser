# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "454f61193c33e75742d3b3c11a98034a"
SRC_URI[sha256sum] = "78fe1274f8d0d972c566e3547ca19e7bfb05d2a3ba9aaaf2d10a13a73eebeee3"
