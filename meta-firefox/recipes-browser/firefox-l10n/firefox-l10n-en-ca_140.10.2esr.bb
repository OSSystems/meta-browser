# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "f44d8e3d550410eb0303384c1630a6ec0e926a98bb08d02aa91d09b0a1cf4d0e"
