# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d0c2eb14aadef6db1746987a34f72aff"
SRC_URI[sha256sum] = "d6b3f9998a9cd016797bcfac853b141cf824c1c3d8386734ce7ea1607262b04e"
