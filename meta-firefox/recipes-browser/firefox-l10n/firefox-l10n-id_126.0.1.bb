# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f8f34aace4dcc7e56afd3e6b9779cd15"
SRC_URI[sha256sum] = "81a3db2c5f08dab3a0fa0a121ef911b705220cbee92ce8a17da616f37da64de7"
