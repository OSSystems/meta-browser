# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5d51e88febb1e62c1deb1f37ed8f0305"
SRC_URI[sha256sum] = "5eb73b7d5c27ba936ec591413f72a6bcf0ef6428d53647340ae22bb3502c1c97"
