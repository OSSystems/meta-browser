# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ab0779f3b186ca58da9cf84b5aa09f3526e625ebd4189bcbfdfb4a37dea0dc08"
