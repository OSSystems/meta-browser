# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "baaa10da3fe5139fd7b838b46cf58f2b"
SRC_URI[sha256sum] = "cd2a49b9d6fda15eb634da798cc4ebe77d937426f56da5e1805a2e2660792053"
