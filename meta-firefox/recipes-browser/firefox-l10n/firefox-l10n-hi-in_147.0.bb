# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cf48c3c543800f459b6a82d2b9484c22"
SRC_URI[sha256sum] = "9f88e5cb221ee645fa9c1276f60be2d8de922592a28b76ccebf3de42509f8beb"
