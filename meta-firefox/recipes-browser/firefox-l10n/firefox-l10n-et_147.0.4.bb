# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b29db0806dafd75d73cbfb88c45791e0"
SRC_URI[sha256sum] = "dbee9301ed3aeb3c95f12c32c6c1fe07af0144cade2dfb3624fbcd86d2ce6779"
