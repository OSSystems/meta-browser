# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1e9953c6daaff600c5a42507fce408da"
SRC_URI[sha256sum] = "11e57f612bf6789e1e4f94a4b162b6e1601527cad31c21002d12bd6340eea359"
