# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ebde7796c507a4a1edbc8396b65335a9"
SRC_URI[sha256sum] = "113197eedd19dedec8d3f803b59291085a60092a7991bd29979f285b48944a4a"
