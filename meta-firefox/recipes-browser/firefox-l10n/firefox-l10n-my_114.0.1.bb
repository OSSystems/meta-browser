# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "16fdc39934fe146d25bb2f8f7423d70d"
SRC_URI[sha256sum] = "62f7af4a1947b22299e7460eb3f4d22e00b569d506ba6d32ca343c97f5cd282e"
