# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fcc122cb67d5de2356f74b5c47ac1c57"
SRC_URI[sha256sum] = "d514d27d09f76cbf786fecadee5cb0831393437e53385a650b4cf0f406d99550"
