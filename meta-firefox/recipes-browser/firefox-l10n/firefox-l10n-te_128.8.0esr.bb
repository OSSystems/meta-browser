# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ad1e70ffe1bc4bef8d80758b4fadbea5"
SRC_URI[sha256sum] = "396cba30cfddbd287f12de24f290e06b7bd1d33b1f20da2a0fbde21f7397f7a0"
