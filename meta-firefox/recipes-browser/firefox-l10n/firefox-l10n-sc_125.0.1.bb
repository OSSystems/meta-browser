# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "29f8fa1ed333cbefaa2e5bb04c4b84ef"
SRC_URI[sha256sum] = "509fd6e27ef9f9f5e805be8c597dc6545e2a89c81e4229af3c58916cb35b8b24"
