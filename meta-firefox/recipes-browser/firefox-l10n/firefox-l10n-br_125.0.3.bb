# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e42a4ae0a556976bc6e1cb3d89fb30cd"
SRC_URI[sha256sum] = "ab0bed3d54b622185624ccd40754c0bd3f237044e10c3ad03770d782aed27671"
