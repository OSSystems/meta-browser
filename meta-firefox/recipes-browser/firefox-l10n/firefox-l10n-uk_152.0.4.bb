# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "43575b76131be583141ccb2ecb42c1eb59ac6387acd1107327c8cb39ad2f5acb"
