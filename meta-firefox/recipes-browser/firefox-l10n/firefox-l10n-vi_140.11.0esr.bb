# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d61ea846e2d315025d546024865da75e291390992e28b3655d4eab4eca9c4d2b"
