# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d0a591c0880827179a87f4cb2e5610e3"
SRC_URI[sha256sum] = "1006410923e94e6bf9835c29148f52ca49b0729fbcb6783ec576ed4959ca0c7a"
