# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "87cc91097bbd142940d71e214405cf58"
SRC_URI[sha256sum] = "01a3e853da2073c5b98314cbcfea78c56e682c3734bac203c67be68aa6f48ed5"
