# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "acd2144ca5c32d3fa61d465656c405d6"
SRC_URI[sha256sum] = "e5cb3ae398fa4672347931336ce762105303850f6cf8d18a3d437238f32d8446"
