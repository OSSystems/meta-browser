# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a39eea6b408f54996e5db6e13fcdddff"
SRC_URI[sha256sum] = "9b873da2d2356162cf2061b9ff3ddf403ee402fb95a1a16dcca50f237aaab7a4"
