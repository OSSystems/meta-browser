# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1ac95b1b71bc23302662ea784595b139"
SRC_URI[sha256sum] = "21ec70f6e20fb18def6236bf4ca36b3ef19c0b598933a169bd0b1395474fc5a9"
