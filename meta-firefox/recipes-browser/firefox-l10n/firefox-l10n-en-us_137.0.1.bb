# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5f3880830bdb5101df4b585f70317739"
SRC_URI[sha256sum] = "978f9c346e6cf600c6119c118423b00174318a2a713150655f3485d143b94d27"
