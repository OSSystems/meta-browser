# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d97ca83dfe5d059097d17b398565dff7"
SRC_URI[sha256sum] = "3146e90c28b5d0ce73cf3d4b6de99b623d31d992568da11427c0ca1b3aa1ada9"
