# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "75438f7fed48125c4f876073f0b34d2f"
SRC_URI[sha256sum] = "28b4086e2a33ece005cb9cae45bd7de67104b9db77481fa48102131e747c55ef"
