# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fae25393e20372f89bb262810c6799aa"
SRC_URI[sha256sum] = "8b91b8a3ea560b344954c71baa4c952d1a5a3ca77c57b8574ee05c5f0802589f"
