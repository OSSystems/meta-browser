# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9e115eb0b5923a674ab902a6f29b83a2"
SRC_URI[sha256sum] = "9b1126fc91fc49d97a4be58f7f63c96e4fd9825a3ac268b9bc8c47a483c1a02a"
