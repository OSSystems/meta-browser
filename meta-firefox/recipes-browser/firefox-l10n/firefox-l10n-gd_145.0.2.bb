# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2aa45c7f92d5288017cc9ed2c27324d2"
SRC_URI[sha256sum] = "8b91c658838466c6653c4a7eb07d04088f42733c844aba221b192f32cd18c5a3"
