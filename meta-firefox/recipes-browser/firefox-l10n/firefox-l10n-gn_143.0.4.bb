# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7f2c10ec24c603500d9304c689fb04c6"
SRC_URI[sha256sum] = "3cbbc70eb6231bb9e30b40dd7c3b78f77ff0c1b7692834d61644ff9461f2192d"
