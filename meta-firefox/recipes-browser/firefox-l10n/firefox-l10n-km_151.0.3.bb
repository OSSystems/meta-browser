# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "42460f7b70c796ef0cb9c4d32a8fc47161ed6fee2f9a0bb2c171ddb56319cf22"
