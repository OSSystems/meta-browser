# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bcf94c90fd00fc69e66392239e15e58d"
SRC_URI[sha256sum] = "eed648c2e2d17dd600ca0ffdf4dbf89fd42bee3c57e0a71a2f9db809b6d9e846"
