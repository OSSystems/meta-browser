# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "58379016233ba915337c064b2a261629"
SRC_URI[sha256sum] = "aee78ab52d607b5381aeef1dbe8a0d6eeaab6f08699330502aa5db42eb64435f"
