# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e2d7457746e7282cdd5f278133652509a4eb5ac1400938021b19bdc36cb48fb5"
