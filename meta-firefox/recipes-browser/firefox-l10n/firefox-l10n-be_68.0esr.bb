# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d383d55bf72af5bed1c29490b88b3e2c"
SRC_URI[sha256sum] = "0bd1522840830e7e6efede6f9e290e8242d72f53f6823a4c8ef7f21f2f3e346c"
