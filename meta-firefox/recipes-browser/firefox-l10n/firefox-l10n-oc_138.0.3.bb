# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0a21f335ecd603200292ea0bf7ab31d1"
SRC_URI[sha256sum] = "17d2ad546a8802dac09b0caab6fc1919c478b15f7ce1ba604b1b9cc4c6ebf259"
