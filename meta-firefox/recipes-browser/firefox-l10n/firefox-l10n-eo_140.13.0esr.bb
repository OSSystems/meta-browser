# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "904f862ca5eab7e0df50e7d1c68d17aef8d86a7ba31fbd12130705e699ccaa58"
