# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "98fa1664e54c34509c928a3aa13a41bb194725ee42d1caddb4b9ad3939c17f69"
