# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "483d7bae71dcff172354a1c75c0bcbf8"
SRC_URI[sha256sum] = "3014df4034b90cff7af94f1eaadf2d3e273a3d1dabebfdc1b46dcaefdd32a987"
