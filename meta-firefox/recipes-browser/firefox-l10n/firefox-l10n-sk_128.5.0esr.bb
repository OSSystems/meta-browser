# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4541128bd78a2ed6c4272cc31d1a517f"
SRC_URI[sha256sum] = "1bd6bd38500a08a83df7ffbc86b205a299e9520f1589608b6033c5c28d009f91"
