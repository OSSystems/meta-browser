# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8ea5aa91a8647820c5912d99ce635eca"
SRC_URI[sha256sum] = "efdd5cfb4e02814ce6f783f140e909fb03f310fc5e53acda5a89801b4e5aac07"
