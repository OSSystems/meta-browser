# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f6a9a61f505d9aec56a088bf9e77f619"
SRC_URI[sha256sum] = "eea45e53f4ae6b2360d8009c2cd618fcebef4c160ef610ca0d6abc14888b7ef1"
