# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c898811607b633af3f8f86650fc0be13"
SRC_URI[sha256sum] = "f12519291503fe16b663033318dd248d9f6acbd2504b4cfe13de42bf362b70ff"
