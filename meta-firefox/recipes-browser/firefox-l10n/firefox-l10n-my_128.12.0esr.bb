# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6046299bc567e8fd2c704ad80d0fd6d3"
SRC_URI[sha256sum] = "c97056b46f359e011a5bc8d86b7aa9e538ff7be6c29aa78a1e467099c10f27b0"
