# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0b700d8ddf9b7892c0cf4088af185e39"
SRC_URI[sha256sum] = "1d499db8ac89406b6ea8a17b95deb7e520fef695e8ea42f8ade4603deb9c9b33"
