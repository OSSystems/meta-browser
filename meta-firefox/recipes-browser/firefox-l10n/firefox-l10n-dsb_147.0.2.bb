# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bfed048bf59a000c9203fa9c6c34bb8d"
SRC_URI[sha256sum] = "9c34040b8448467805afd5eedd202397e6fc1889edb380227cd1431cd628e9da"
