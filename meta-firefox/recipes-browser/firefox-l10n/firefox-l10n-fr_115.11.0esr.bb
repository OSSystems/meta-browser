# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8d2b8de8cf1d847b6e6b548a6b972dc6"
SRC_URI[sha256sum] = "862b3338ef0f8ef3b19e210bef6422f0ea85afad0c2baf9095bcac622c9e218b"
