# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c0dde0c522b1438c1eae2cb9f0b8932f"
SRC_URI[sha256sum] = "6c1045615da5d4ad9f4ce6800944a0bcd6f919b18ae70ccc39e0d950513196d1"
