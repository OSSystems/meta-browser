# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d0c1111996b24db3d69e25a9febc8320"
SRC_URI[sha256sum] = "c0900dbe34175cc45cf869cabfd39f77036223224776cd7a763725f457510ca6"
