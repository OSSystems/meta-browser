# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0825ddcc34b48857e24a1dc94a4cb1e7"
SRC_URI[sha256sum] = "7a86cbd5c77dc7e0485352135fd58f51d6982002d41f350e333bcc9b509de3cc"
