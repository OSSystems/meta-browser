# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "506e0caf01cba13d8c1d95912eea917f"
SRC_URI[sha256sum] = "daacaee0c4736cad4ca6311b20007ffb0ace2abb7205c8e5660905cfb3439d77"
