# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fb1369d8a4f9b168452e3523480377f4"
SRC_URI[sha256sum] = "977e8b03d1ede120967332e25c3f95ce800a6ca54bbcba5b2ca0a4976bf37487"
