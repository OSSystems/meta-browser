# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "19d8514e1a02e9b4bfe44f816beff962"
SRC_URI[sha256sum] = "16c0627208d690236c644437768f8a613ccd549f7a36665a79a60b6e5ba4c060"
