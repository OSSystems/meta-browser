# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ed74df969c8953d5ed980dfba21c02c9"
SRC_URI[sha256sum] = "ee228c4bc50a6f057e8e3bc847f0da1fe4707200b4d22f5f61d65eb1e624f37d"
