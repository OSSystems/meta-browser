# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "064d097e99a33fc1ba0bf636e0d5f845"
SRC_URI[sha256sum] = "14babaf62d5fbf95c975dfdbc07229ee549537b53c2fba77b088b78f93e4cfcf"
