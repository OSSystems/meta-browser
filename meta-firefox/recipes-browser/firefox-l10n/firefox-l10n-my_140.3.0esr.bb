# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a8d4c4b1f9f5ebc9abd8d507b7483c59"
SRC_URI[sha256sum] = "385a014ad5e8968851895eeaa607d19899df8e4f5c0f5d0345a817c5fa163534"
