# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c9d5822d3e89ff371842b46ffa154185"
SRC_URI[sha256sum] = "d0b612184c061071fe41bed79f39d3712dc099f9e9f6779cb058418566771ad9"
