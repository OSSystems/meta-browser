# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b440a09c81fdda68882dcdb70cf66e56"
SRC_URI[sha256sum] = "b8586f9c897d601a5b6251db8e87b7fceed4ef912279a797efd910851c00708c"
