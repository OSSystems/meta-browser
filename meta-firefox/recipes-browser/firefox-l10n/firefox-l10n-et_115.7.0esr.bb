# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3eb17dc72041971f80d3b786a4b091d9"
SRC_URI[sha256sum] = "911109dd92e487909a72623b7e40b5b37781b621e6fef3579d9b437835ff1c60"
