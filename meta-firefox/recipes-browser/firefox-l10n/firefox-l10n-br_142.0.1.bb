# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b6fa093bd6290bee7c5607a3089b83ed"
SRC_URI[sha256sum] = "06da50fda93656846d9c04b364a82e8d06228a32e25a7e207f46db813bbad118"
