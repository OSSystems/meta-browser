# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d88e5e706cb92d7749acf07e77d8320a"
SRC_URI[sha256sum] = "17f0694187aad70824648a79073abe199e313c24e5379ee0d2774e1ef7236d94"
