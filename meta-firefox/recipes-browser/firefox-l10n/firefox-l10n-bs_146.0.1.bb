# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2528f02f8c7cb6b8d7ac3748d3329f41"
SRC_URI[sha256sum] = "9f884494fe887fdc0dc66a604aaca851452d5915e9775a6cd406f77a3fb7a9c6"
