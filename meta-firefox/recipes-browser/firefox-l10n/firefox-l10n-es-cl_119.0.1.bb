# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "34dbd20f7d7d65c263efdbe420bdc1da"
SRC_URI[sha256sum] = "95476180b8b2d603376da4b4d2fa5c1941ddb2439e85a1c80209421fa5e14300"
