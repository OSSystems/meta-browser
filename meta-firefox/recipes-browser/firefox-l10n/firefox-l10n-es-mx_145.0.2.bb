# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aa26adb1fbb8966d1aa2268bbd4912c9"
SRC_URI[sha256sum] = "d564608b5173338f2dd0844ac715dcd42192e80f61fd0344b286f3e34ffeb124"
