# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d6afa96753b0c60fe586441ec967d06a"
SRC_URI[sha256sum] = "80a1a956d8594b3126ebbe12e7d761fc95e6f96ce92b799c0f77ec3aa9cb4285"
