# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "35e05e8080660cd7fb320028a283d179"
SRC_URI[sha256sum] = "f223cf4ef513310d1cfbc6ffc25c4ff0e11703fc2d91c9d0aefeab5cac65c9ab"
