# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c1002052b6a1c4a47a3e042c64dd219e"
SRC_URI[sha256sum] = "062ec21b01dc49249847639c4d8dbe60ab52aa983ae7abc7d5c524530987b8d5"
