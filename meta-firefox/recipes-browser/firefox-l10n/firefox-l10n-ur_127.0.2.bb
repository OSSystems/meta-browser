# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "90fd2cbcf8f09b5b4268df75b1f0c670"
SRC_URI[sha256sum] = "3fa8496dbf4a7503e7fb395bd35f49130236709f7e56ab748da9aa3c13f8835d"
