# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c9d298191a00833b51d0358332366bd"
SRC_URI[sha256sum] = "1c9b6abe74db720275696aed48353d31d37f93273f167d51bbd8a863cacd7397"
