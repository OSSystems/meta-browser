# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0ac8ff105699878b89e7148a6e3d4f86"
SRC_URI[sha256sum] = "0cefb89c403afd366f6403a515bb5e44f12c13113b534d2d8032af215b901b20"
