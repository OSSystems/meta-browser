# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2d97c1a9d17ded22ddc14203e6c0b974"
SRC_URI[sha256sum] = "65976f745af09ff0d5ce8bdef0a13ee58c7d6cf2057cc63485a826640af45034"
