# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b924b8c5307c58af80d2fbe03aef8d3b"
SRC_URI[sha256sum] = "ef83e25a1e80d44f8e2dc12966330feb28c65f1e8cd9541254fa04afa3acefe1"
