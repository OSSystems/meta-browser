# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "773fea5a2aca5a6c54638b7cf6467365911e91746a5f5363e4b74b1a850f3ddd"
