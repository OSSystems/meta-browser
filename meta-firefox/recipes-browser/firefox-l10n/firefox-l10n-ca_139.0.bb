# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eb7d11a5ebcceb64ce506ea97c5b2a88"
SRC_URI[sha256sum] = "5b786b16712d6f24cf6cf92b93df40343d26bdc1702e7bbaa8a16f7d346914c4"
