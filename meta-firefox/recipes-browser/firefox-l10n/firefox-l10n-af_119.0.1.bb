# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f39b8eeaec4780b75643809cce7f5891"
SRC_URI[sha256sum] = "3d0f483d19584b2e68ed17372b2b46eca560dfdf2e24e8a86a889ba4d09bd47a"
