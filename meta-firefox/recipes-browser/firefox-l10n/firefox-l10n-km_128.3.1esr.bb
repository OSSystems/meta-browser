# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6e2052324476869b270033a41b4ac12c"
SRC_URI[sha256sum] = "f0a8941b9750e5532aa0838a6e74354ac34b723c952e70c7c17e7621b637724c"
