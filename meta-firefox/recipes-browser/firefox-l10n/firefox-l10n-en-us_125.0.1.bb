# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c70b9d2cfd87ee52eb5a8f1fb502e731"
SRC_URI[sha256sum] = "a5df902a6e418936d52200d0cdc9cbdd35b8432c51f2971c6ed47cd8a26a45cc"
