# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e82f448011344477e5e0b6028150d197"
SRC_URI[sha256sum] = "2b291946008fcfa3dcade24aa114930f298a61fd7b628bfd1cfd3e3a3f964314"
