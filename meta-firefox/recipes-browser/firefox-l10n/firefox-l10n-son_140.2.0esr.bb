# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "60e1b9eb2d6f9d747fbf110fe448bda4"
SRC_URI[sha256sum] = "eb7b64b1574ffdc9d5232f9941e59b19c8658736167ba2b0b50d87a8b080466c"
