# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ee165dc33ebec45064aad200886953ea"
SRC_URI[sha256sum] = "fcdcc14e792c8a259f884474c35f6e584fa8c8222ed6c5a5d3e3afef54ea013e"
