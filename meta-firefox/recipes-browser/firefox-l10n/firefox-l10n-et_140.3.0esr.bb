# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9dae3dd3977d8212ef20cede47ebfca2"
SRC_URI[sha256sum] = "3845b2752f6b98e26e5670ea3168f052e94a632aaa182b9a757807ca95eac61a"
