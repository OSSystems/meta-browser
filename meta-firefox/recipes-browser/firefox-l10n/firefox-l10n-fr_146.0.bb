# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7543f644e597b36031ca0bbeb03b21f6"
SRC_URI[sha256sum] = "96b241c717a09e63d54592fa90b0e4a42b21e3586812fee726ccdefa1bd3a2fd"
