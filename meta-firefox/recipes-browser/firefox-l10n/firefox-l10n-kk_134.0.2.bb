# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fd1074225ad46f9d74afbaea76327b12"
SRC_URI[sha256sum] = "4019627d885baedf5ad556a2443b8d5acbbd42eaf340f5e5bf8c18dabd32992e"
