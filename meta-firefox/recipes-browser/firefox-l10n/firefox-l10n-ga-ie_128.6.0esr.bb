# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "500c042df29d7a9f77174fcc6e4ac3d5"
SRC_URI[sha256sum] = "60848eb3d57b14ca2f699efebbcf797eb6e90b232225fcb797fcc45e354830b4"
