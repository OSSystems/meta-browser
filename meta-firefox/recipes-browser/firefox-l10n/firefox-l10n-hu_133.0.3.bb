# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "98c8d988313b8ab247ff5ed7404c4a0e"
SRC_URI[sha256sum] = "c07d046322dad5ae56cc5734abd7e398ed4953c7c8b217358027a23813efd445"
