# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c0dd2742a4f41fd4c9b696a0f1fa0a57"
SRC_URI[sha256sum] = "81319673ac6a2f84d804281ae656683db1e72a7e4354b78a24c01d2d227808d7"
