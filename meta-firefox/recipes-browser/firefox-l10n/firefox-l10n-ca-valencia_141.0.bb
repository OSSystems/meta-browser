# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a076cf044e2bc63763edf1f5ec420e50"
SRC_URI[sha256sum] = "6fc5406d541fae2ab909dea6432fdde97715231007c48fcc9f366150ffa8a324"
