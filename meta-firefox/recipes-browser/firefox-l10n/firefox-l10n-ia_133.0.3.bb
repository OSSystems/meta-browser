# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d2a7713adb454c310fb2b195fffad14d"
SRC_URI[sha256sum] = "70aec8e052e8baa1987f1672c882fb0e3fa994a93ef55eb4556de201fb3600a6"
