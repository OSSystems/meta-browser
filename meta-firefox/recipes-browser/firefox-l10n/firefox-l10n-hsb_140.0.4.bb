# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6ef8cac7b44e13af14b4bbb1f1756ac2"
SRC_URI[sha256sum] = "8f144465ac754e0b43ac50196fe676e50b314e5f2add742ef703ef73e3ed053b"
