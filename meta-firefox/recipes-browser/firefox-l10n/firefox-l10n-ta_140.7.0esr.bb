# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ce5125f65bb84e664919e0ce4c0431a1"
SRC_URI[sha256sum] = "1f4e48ad95e7df9b74430a0a736273e11308b9824a0bb00601c7479ffb237042"
