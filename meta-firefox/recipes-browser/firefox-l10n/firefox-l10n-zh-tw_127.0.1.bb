# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ba09dd774312caf03a3c724b46856f53"
SRC_URI[sha256sum] = "2b880056b79ffbced10782fba800c3f6e81b9b43abd278b190fffe8a2a8aa20a"
