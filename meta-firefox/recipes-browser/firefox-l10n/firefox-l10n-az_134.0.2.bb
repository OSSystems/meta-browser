# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5b367468943fd57ebb15c2d39140711f"
SRC_URI[sha256sum] = "24b217f62fe3884e7bd4bb23ddc9cad666b7bdaad1cecba4d053bc699f6733db"
