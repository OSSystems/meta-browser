# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fb36f972e95e0c5b528b84052a640098"
SRC_URI[sha256sum] = "8236c33176878c27c73ef8b99815b8c697180b22b2afbc529995d5077ada29d4"
