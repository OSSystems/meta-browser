# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3e541f5317cdd04e43b46c7cb6f2a4f8"
SRC_URI[sha256sum] = "6590297dfb4b6a33516ec6d8e2546d2820db6c63e7ee7180a5ef95f4e7c69c27"
