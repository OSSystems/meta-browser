# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ec4e869b762b1252bf27c2f6d33ed4a1"
SRC_URI[sha256sum] = "4101f8d9a4bf5bf7c5f0ba4183d823b2641fb416426b2ebe14b8d06c768d3bfe"
