# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ca3810383206e9289027174d28409091"
SRC_URI[sha256sum] = "50014b8058153d1bc1b215b37102ac3b3171a20f2decf6c9ba563f0f4f10e47a"
