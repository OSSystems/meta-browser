# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a2823796c25bc54d7459ee500092f026"
SRC_URI[sha256sum] = "be05198c719c438c79d91b4cca26925ad477ccb3c423cfe7e6fb407210b60d0c"
