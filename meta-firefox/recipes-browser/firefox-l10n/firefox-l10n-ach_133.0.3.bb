# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5d221756261d65e65b59bb6a257185bf"
SRC_URI[sha256sum] = "12b33986e5d6b5ce21886fce7a468e0f552067bc75c8a2de296c5fa3f8898e55"
