# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e84648d3a06cb2b11d18126caf246942"
SRC_URI[sha256sum] = "6140ec0d07a88f49bafaac4d241bc3c3d8c26bef6528fd9a7f15fa97e8b2c0c4"
