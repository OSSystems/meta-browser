# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c770a106dc2baaddb969aaf171389682"
SRC_URI[sha256sum] = "6bfc4680c3bff6cd5c9fa9eed40564f28e355661f69ff541e92885f24e85ca2c"
