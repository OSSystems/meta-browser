# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fe453103dd4392dde1929e2d998b88ba"
SRC_URI[sha256sum] = "169b992dff9ab3cfb8b0432d900776cb568d99c65192c406505ff4aeae982203"
