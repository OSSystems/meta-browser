# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "de37e6134e41065ca028ac158ca200ac165e68f1acf5b9b3707aff1e68ded342"
