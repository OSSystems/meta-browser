# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "6c28cd0ac38679e2391c254ba0a12ea4bff05766c9ea51078ee7ca67e49f65c1"
