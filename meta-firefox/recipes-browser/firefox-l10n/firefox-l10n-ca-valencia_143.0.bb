# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8893b6d69082e2bbce1519f812947904"
SRC_URI[sha256sum] = "de9067ee58d282786a45e3de25f19a934fc9d3c64ae6de09c364e3ad6115f80f"
