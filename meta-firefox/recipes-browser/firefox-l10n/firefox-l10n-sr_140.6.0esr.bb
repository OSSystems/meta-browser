# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6bff41f84386a28b6a3b7c203eed5a2d"
SRC_URI[sha256sum] = "bf140f5c9fc9372f1ab43a9a4c23c6977d4b10d20faa30cf17b72e4961f48d51"
