# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "24878440685015fe9e8bf805866d013c"
SRC_URI[sha256sum] = "92ef0794a6c21a34c21c5c7eef41852c3cb4249b7d4ff821356746d0a58539e4"
