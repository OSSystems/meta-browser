# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7bb63c289c0fcb057bb4afe38d5fa432"
SRC_URI[sha256sum] = "56cd20dc5c265a984aff117765e62aadaaa79d40c01875b50d893db91138daec"
