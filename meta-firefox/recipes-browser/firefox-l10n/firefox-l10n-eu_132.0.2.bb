# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "efd7f7f2604ad046ae8348c4135b916b"
SRC_URI[sha256sum] = "3c16395cdc73d2ea1401d38575333ef8999040f1e54c70dec44ed860a2779b3a"
