# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2eaf7f1f187359fbd1b23577517714d78f1ff889834ca17c082c8698b3993f4d"
