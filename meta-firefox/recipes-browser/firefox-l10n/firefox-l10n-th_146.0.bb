# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "68e17c139784f53e650d0f5d1b2193c4"
SRC_URI[sha256sum] = "3c64d6e49a42b023d6b9dead9e65d1fe5fe4084c8ea7b8210efd6769916cae1d"
