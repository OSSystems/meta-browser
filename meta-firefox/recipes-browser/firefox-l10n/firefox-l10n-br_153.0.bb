# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "de0d7ac127512e2f92c4c68fb2486dcfab8dd016efc595cfb4d5ff7d4583f7a8"
