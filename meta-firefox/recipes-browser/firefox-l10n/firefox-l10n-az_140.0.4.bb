# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "153f1695f7065f5a2e232dfd951f24ce"
SRC_URI[sha256sum] = "b2ade3339502b9cd9f2803aebec9a520e9eb0463607535398a5a20982a3a08ce"
