# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "13ceff04243e7b32d66bb405bc7bc9255837cc571f31f445a7418ed2e5b81951"
