# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3f64712d3d3e769750ca885f6b6efd0d"
SRC_URI[sha256sum] = "33715f81cc221f6bb7f219457276312eef6cca340115c8cac5ecc3141c68c096"
