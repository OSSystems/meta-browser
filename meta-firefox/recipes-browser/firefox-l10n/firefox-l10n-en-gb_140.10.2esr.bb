# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2cc95f939288e4e55c7ce652946835de5a43cdbf6d2e6dd8f28d552af4429a90"
