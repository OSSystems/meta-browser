# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dbfa3b6fad562a25a844892c5baa3fcd"
SRC_URI[sha256sum] = "07c42a6a2b6783caa2c75807b96d2079328bcc43669b20e4ac5a3873a3243d80"
