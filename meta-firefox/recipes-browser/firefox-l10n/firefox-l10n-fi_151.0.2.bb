# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "202026704b28100fa17ca0d9245505f4429380470c990d6f1dece8aa34abd04d"
