# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "43f85e514ea844c83746d20c66346452"
SRC_URI[sha256sum] = "6fa844a38a0a4d47a3a0b00aba65845384084ac5bc4db8d88f6587a0ebdf3737"
