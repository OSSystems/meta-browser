# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "89444df378b9e37c4d32033bd4dd680a"
SRC_URI[sha256sum] = "3e690370fe38d75dc9191262c4f90c1174d422c14ac02e20374c9dc594f56c02"
