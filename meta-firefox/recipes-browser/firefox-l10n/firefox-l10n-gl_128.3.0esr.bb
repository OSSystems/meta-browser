# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fc87aa97b8bde03c6d8a0e7aaf4a7458"
SRC_URI[sha256sum] = "3f9078a7afd24ada4339fd35b1d410939147edf085d302ff1f7c89265ac6841c"
