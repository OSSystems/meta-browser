# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5371ba6fc95c682e1cbc6dcea2eac2a4"
SRC_URI[sha256sum] = "581082487b38f2c9138d4d9a3efcf0170a9b741a3fb77bce790de4e9b1f0c3a4"
