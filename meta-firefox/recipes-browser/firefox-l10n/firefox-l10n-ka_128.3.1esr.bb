# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f8cbd7edf22794a14d830533e09c1535"
SRC_URI[sha256sum] = "2283ed49b05624d2db0ba1e28fddc369e1e499646f2857d0d522c58a35087f29"
