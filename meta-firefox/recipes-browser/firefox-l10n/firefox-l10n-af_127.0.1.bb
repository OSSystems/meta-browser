# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "baa9f69869646eb6628f7fb32568c693"
SRC_URI[sha256sum] = "6fe2a80588d9c17c94cb5903ed2821a76b11e6c0fb9967169493291973258cdb"
