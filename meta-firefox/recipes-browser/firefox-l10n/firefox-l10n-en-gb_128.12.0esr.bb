# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f8fd7da82f96718dbe740fdc1aa7d54e"
SRC_URI[sha256sum] = "f25f517656563c341215d58e95190e69c46310662516434f770fe133eb545aa3"
