# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3adb59ef57ea3d71a2e81cf0bc49ce19"
SRC_URI[sha256sum] = "565dea5542b915c5b243b77200a0a987b157f68ec10d55268a17efa63bab5e6f"
