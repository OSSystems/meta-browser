# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "70ad3fae2631a13ac74da1b2d92a3dcc"
SRC_URI[sha256sum] = "69efcf3298711c7da2d523874b441e2471daa6e3c93dbe2494931fb16b5b6565"
