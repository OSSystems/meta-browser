# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f158592d0bd45005a05a3d69aeeab667"
SRC_URI[sha256sum] = "40303f0e5d5fec097f1e099241fd464c4b2a7ba130bc57be865fd0ea41239071"
