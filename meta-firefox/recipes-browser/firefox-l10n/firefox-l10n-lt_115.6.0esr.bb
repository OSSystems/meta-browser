# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bf7a23979d690dc9bcaabcfc3e1b017c"
SRC_URI[sha256sum] = "a369b20cf256f9d17c31901198848db0d317503e6e27fde8fc61da128dde3af1"
