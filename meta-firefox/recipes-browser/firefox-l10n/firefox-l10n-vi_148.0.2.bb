# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6ecea91c98607c35769d65e17259a6fc"
SRC_URI[sha256sum] = "43d59f1294951492d6a240c3bf58c4b18483e560785a337a0fd4162fc33f2257"
