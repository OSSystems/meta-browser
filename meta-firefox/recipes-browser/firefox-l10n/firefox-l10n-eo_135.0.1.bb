# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8c83929f02ed844519d7e18b4c387d3e"
SRC_URI[sha256sum] = "237c494e872cd3edaef5f826621b94fec59c56b86b02916794a85d448a917624"
