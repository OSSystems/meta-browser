# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "175d6e10ac581699c5567c695be296e5"
SRC_URI[sha256sum] = "f76857dcad3a45eac83fc330f0716b79c01fa8f96fade5959b56d527fb89b597"
