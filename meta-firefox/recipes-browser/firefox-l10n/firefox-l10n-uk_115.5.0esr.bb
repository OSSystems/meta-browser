# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0df2346db45b28902459d2afb0fe1a25"
SRC_URI[sha256sum] = "487740a55ae48213cd81bb702845ff70c897119f004ae6f0bc0525f6829eea39"
