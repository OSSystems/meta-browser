# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "675515409e3fd2b20a8f267e6bfd3aed"
SRC_URI[sha256sum] = "4732db942a521b1fd28aa390c87ac9fc74d3e7f691eca1bf8061cffe52983eeb"
