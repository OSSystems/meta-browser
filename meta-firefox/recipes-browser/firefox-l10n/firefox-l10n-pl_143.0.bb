# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a33a0377da47b99ecaac7ecd197b6f13"
SRC_URI[sha256sum] = "1679ac77d1a2ced2a96f643da46816e710a4ad3aac3a71f9438f67bbdc2ca905"
