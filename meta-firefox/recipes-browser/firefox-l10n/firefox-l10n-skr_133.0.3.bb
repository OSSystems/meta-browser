# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "03055f4afabce037219969372336c9f2"
SRC_URI[sha256sum] = "ec7c4bd3e9587fea1a83f8f177a766e27af86af5146cf71edb7175b10b251eba"
