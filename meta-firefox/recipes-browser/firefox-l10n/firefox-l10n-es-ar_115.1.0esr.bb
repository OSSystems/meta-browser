# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b61752198b3ec026db6f20ff32a4b3fa"
SRC_URI[sha256sum] = "a5ccd90dd9e5d2ccfc6e6fa8e2fc76c923ef2082decdd1b5160e43002feb63c2"
