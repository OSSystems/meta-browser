# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f6f7d558b76d67205830848f866377e5"
SRC_URI[sha256sum] = "5134aa81eab9cbd9e626bb889216835d3e0b21993b72153474a10bfd8fd2c1c6"
