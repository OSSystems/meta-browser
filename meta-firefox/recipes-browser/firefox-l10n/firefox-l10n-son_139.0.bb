# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e1a3f9ce288e9e56cf8cce5517525b9c"
SRC_URI[sha256sum] = "0f47b5b1b225276403895564f40a48178485a6d5526824d8e7160078b694fbeb"
