# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "38f82a68cd9dac4c381c5e299588ebc9"
SRC_URI[sha256sum] = "1e497fa20525d7626771a38d53171ed23bb35c55c2d211a9795f4318d5b16592"
