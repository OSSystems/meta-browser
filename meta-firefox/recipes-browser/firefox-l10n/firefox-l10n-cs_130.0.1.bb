# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ac84859342a6df414cd4f6430ae8a8ad"
SRC_URI[sha256sum] = "00ef558dcfd486df0a542547b975021aa6c2f46f26469bf7fa7dd9422b6cd8f3"
