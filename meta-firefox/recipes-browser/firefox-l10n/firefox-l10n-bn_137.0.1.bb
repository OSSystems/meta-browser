# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "56f91a3b3dbe66bd631e030f067788b1"
SRC_URI[sha256sum] = "e335ebe8d57b5f520f0a36554363a2c75d61abfa06827bd20c0a8db71f037815"
