# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "643e24b5e83a4907821a64b02e5bcc3b"
SRC_URI[sha256sum] = "7f50834c620101f439986b03dd9a39e93aac41ea17c956442889afc239004774"
