# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4f8dfecd3460c50a926ac2f7933953d3"
SRC_URI[sha256sum] = "44339b68d465a09ff53da2857d0bcbf2e24fb5832feac3ddfe0c01228241d6af"
