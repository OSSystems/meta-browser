# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "faebc9e8fa99814536b7571ac8b8baff8139f8f570be92e4bc0d2f711f984ad4"
