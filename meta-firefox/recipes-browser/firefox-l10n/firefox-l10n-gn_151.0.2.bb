# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "0a8c316cca5dcbfd6d432926540087c30b980f2d76419513bf0ec997031cba60"
