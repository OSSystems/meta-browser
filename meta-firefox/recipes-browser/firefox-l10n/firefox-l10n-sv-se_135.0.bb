# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "789d38000f5c7aa8fa5ebc694b7354da"
SRC_URI[sha256sum] = "3cb1fb4dce1d8ec0859bfe144139c5b566678b345a95b99518e6a0195bc3f46b"
