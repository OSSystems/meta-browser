# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "90e4f6f1a20c0be065722fdfb67f86cd"
SRC_URI[sha256sum] = "3d0565548bb44572f317cdd1810004b3379813f838802d7d693c34accb0643e0"
