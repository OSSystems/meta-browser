# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db0c7b7798991b61dfd5f4e5630a7391"
SRC_URI[sha256sum] = "0b4df2810f1d574d50cebf89e3278af34bea623f342b41449b5e29f34b2e831c"
