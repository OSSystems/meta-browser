# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0ca7f57786fefc4fe391b64ff112e26e"
SRC_URI[sha256sum] = "32caeaea568ff9103385ec6c0ef771ae56178461ac9f013da0cc893ef6348012"
