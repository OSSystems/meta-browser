# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7819e7e47857f6f6cbb31c85b47d4fcd"
SRC_URI[sha256sum] = "1f89d03ec7020ce9fc407b742f0f793ac87815483ca0b292e1331ee33d1eadba"
