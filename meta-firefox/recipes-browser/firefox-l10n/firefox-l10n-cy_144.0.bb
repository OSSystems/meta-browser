# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9a5ad33a774fa2e6b70988cf49da1969"
SRC_URI[sha256sum] = "e866a62a5bd313cad4d480ebaadc8a8d8bdd89872e14cc2213bb87f8dadadd53"
