# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bc051d715fe1b51ac43aba0e53900ad4"
SRC_URI[sha256sum] = "8e3841954b5499ba70434fc5acc8b52bdec404e1325c25bb26849e65c11852b1"
