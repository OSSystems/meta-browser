# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2588f4ae6c9ff60ee0dc4f264577da30"
SRC_URI[sha256sum] = "317f24b06e57cfbfc0ce67d2d4b047f90fee2b45043cda1e12ca6fc6e0464044"
