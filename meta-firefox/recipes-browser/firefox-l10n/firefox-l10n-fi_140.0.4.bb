# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bec12845ede07ff4332bebe98b20b278"
SRC_URI[sha256sum] = "ab4db8119fe28b6dd7f8756b6cc9d65f602a30459420c490c9c4e87c815454c4"
