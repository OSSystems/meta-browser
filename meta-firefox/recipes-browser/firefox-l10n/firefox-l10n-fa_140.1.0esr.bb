# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "edc76aca59431ddcbcf917b4c6b35867"
SRC_URI[sha256sum] = "9ba184be3038a4e55f1d223579eca54de44e74adabf64f8510a2d88f7324bf69"
