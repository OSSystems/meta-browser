# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "99236bac3b95b3310e9deec57f170a11"
SRC_URI[sha256sum] = "69fa212e08f4f3b4a919979545db6426190db7928f33666b122349d9944ea1d1"
