# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "035dea1162ec50448bd68656de1ecf40"
SRC_URI[sha256sum] = "cbfe3f5331ba84ce03c5628b0a1c07f0906d334af9b8c35f991db71fcdc0e0ef"
