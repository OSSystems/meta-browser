# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c5923e66aa2f96c4abafca659d6d014f"
SRC_URI[sha256sum] = "a6e82fc4eb6a9aa60c383222c0c63a33b5c1826ab328af76ed5e512033acaf73"
