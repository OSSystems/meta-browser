# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "79b248be8c90059a02145b49e04c2c29"
SRC_URI[sha256sum] = "315767629c363ae00bcb9652f76af19eff1c1418d2258976cab770585da354ed"
