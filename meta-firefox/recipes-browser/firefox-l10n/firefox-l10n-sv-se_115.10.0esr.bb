# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d08388bed0181244c4c2195079268328"
SRC_URI[sha256sum] = "c50c6b7ed09864e6fe5a58075ac1cb60b9d0814125c3c8eee5f771639d4c4a4c"
