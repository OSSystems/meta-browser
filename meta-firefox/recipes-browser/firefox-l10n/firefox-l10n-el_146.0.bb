# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "00858a81bfe98a3ab93a16a78e91d5d1"
SRC_URI[sha256sum] = "b98bbd2917123c0acbda4431ddaffeb2826fc7c248f469ae9a19a663d066bf64"
