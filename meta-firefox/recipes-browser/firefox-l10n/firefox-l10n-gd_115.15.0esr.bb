# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fce452ceaae08e7f05e47e2983960279"
SRC_URI[sha256sum] = "f6d2245777f2c3a65487a52326598869e38a5047c28b0962c63c57c4bc66b486"
