# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3d1011c365238ac020055a6f55a7457e"
SRC_URI[sha256sum] = "4f1fb1085cd6f09ae866ee5323e3ace038bed4ec3ac51a6314769a2b7a5459ad"
