# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fc5ba70198bc05729e5c0950fe4a369d"
SRC_URI[sha256sum] = "788e9aa57de603937432aefc8c183b40bc2e1e2e38bfe5a4c9578a6fa58fe6aa"
