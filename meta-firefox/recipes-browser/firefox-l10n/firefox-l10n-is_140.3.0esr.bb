# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6d69e15683128a240d2a0b32deb85867"
SRC_URI[sha256sum] = "dea3c5e8b0e7d00447b6c1025f7cb08d37a561bc1aa40acb3002b3a956660551"
