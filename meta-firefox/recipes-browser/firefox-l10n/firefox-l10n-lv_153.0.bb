# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "4777c09bed4b76669f1d7330c92de9e058a1d44edc20a69e2db1f531c37bf79c"
