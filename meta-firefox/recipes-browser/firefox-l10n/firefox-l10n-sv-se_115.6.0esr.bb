# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "71cfb911304f21097d753a8818f8a196"
SRC_URI[sha256sum] = "41bf3872be5c15beec62528c309a1a00c2f91ce3276e23fa14316585f04a56c1"
