# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e1cec7afaceb2f96d9796d5c32a7c52f"
SRC_URI[sha256sum] = "1b962905d961aaf2019141f969a2f2d45c324ee42e165047b2ac4c8aaa75a66c"
