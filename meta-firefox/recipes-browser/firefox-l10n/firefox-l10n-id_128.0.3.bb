# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e0f566405426fe578ef370d57f67827e"
SRC_URI[sha256sum] = "98fa15df90c4792669ea225af86a87b766efd2200f4be9ea7489e3cf288dcbfd"
