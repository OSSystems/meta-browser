# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f260c7a365267440a27e21c65a7c632a"
SRC_URI[sha256sum] = "767063b7aec64c1d6ffd4ff16bd357776cea66b5a223b043cce5cd0823a29381"
