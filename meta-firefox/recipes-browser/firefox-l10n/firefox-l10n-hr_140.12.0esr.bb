# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "64a381d0b9b366e7c0bafdd9a772350b276f4c9dddbf80dfb839619dbdcfbd22"
