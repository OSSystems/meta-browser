# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d56678d447fca8478d3297f5698394ac"
SRC_URI[sha256sum] = "09c8e724d9abd10f2a4f63ab74f5a907213b6ac56efd95c00dfbc749ba982c2d"
