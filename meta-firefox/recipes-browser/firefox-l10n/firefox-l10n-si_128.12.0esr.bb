# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f14c44b851ecbbe81757147722951690"
SRC_URI[sha256sum] = "6fe6bbe6511b1347f63b33fcf1f16231b139ec451319aa8526696ffffcb3707b"
