# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fc9c323273cb3edc05f93a2b09f82ea8"
SRC_URI[sha256sum] = "b79e4ea157d98b1e3c0dfecb3d8981b177dc8620c12494b4148daa2240db8041"
