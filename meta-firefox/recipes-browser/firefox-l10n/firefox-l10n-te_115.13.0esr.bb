# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ff54bc7819fb09ededb658fd41cf8df7"
SRC_URI[sha256sum] = "6c3529a5844a4f703b510f34a5a4965dc84219d9fc3e2c63b08e7cc87321475c"
