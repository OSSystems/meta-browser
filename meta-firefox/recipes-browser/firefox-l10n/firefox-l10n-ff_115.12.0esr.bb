# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2783d13c1f8ef7c1ce5aec4a76b43e75"
SRC_URI[sha256sum] = "3c5655b5abb3a2de64ac4813ab518aca3e02aa3ca9af6dcfa3da344c85d499c8"
