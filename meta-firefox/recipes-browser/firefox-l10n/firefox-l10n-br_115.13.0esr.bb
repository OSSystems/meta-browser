# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a6d7b72d1cabbfeb6928530913810bd5"
SRC_URI[sha256sum] = "d6824d2b7bc031e5db29517548462490bc60a1a49295be0a7902d6bc94bfd60a"
