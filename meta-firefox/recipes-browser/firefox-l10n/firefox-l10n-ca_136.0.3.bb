# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db2e17e431fe9e88edd2883e57d23cef"
SRC_URI[sha256sum] = "3c0c4c2b11004566ad4094c98076dda23335334ea42772de16ef115517d1469c"
