# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bf242babeb6edcc47bd5f9faa781995d"
SRC_URI[sha256sum] = "fa87287f768ff512e7dbb4e020ae3800eacf89373091610f8466875c76429f17"
