# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "42f36196f97646d9b0727359511c7fcc"
SRC_URI[sha256sum] = "2199cb358ae9fa24ed90a93e1a47635d9fa399dcbff82f824eab7fbf143896d4"
