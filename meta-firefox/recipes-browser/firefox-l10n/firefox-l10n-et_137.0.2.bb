# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fcda32805b845681562913292579833c"
SRC_URI[sha256sum] = "b03a8a4989ddfe61717863c223c66dc0207d7a17931b2f7387243d817b154668"
