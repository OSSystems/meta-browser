# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4a60ff7f4a006f9d2c93333431fd34ff"
SRC_URI[sha256sum] = "adeaf4bd1ef3f47a3580f4178be589a0d5cd4a78927659e36daa283ae5e06166"
