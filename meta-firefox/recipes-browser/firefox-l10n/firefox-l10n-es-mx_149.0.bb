# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2ea5c4ec774122423d200294071031b8"
SRC_URI[sha256sum] = "761e09d78a300031be531cafdd11244d7fbd2072a7fb268c92eb93068092208d"
