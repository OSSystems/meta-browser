# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2dbbd0a0338b4736bd48100bec27582c"
SRC_URI[sha256sum] = "2810383498089843c28e5b384bc15fcef67d54ba790bb28fc63f3321c28ad069"
