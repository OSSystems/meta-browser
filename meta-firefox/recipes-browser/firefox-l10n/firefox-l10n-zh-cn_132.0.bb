# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c4bd4b3207c4539aa3b59b18ad06db55"
SRC_URI[sha256sum] = "4a0c3c67d8a62d7c83cadec06abf5b1fef8c9d578a4c3ce2ee1bafbfd85a400e"
