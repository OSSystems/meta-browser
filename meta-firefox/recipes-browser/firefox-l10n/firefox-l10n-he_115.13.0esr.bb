# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0e5e8e018fef36d59fe0d6ccfd6a8484"
SRC_URI[sha256sum] = "46bc3f30335295edb6239c0cf796fac55a1a20110aa1c391bd2793cadf8a5296"
