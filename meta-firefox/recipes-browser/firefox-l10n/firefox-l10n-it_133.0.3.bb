# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "476a592044cfef2eb97262b86ab67b00"
SRC_URI[sha256sum] = "d6a8920c18dcebe72ab2d980e1373c69d3d1db7c0791c31a38a5ca310338a42f"
