# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6fc3069c76b91e8170ebfaf88b8bd395"
SRC_URI[sha256sum] = "9c989d7b91c6c798357549c81f37feb8af969a88a5c45816ccb34e084dc58eb2"
