# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bd074f04340035c089be42aabe4b4fc9"
SRC_URI[sha256sum] = "0612e392494af32ec610e703d719797fd1c089535ba0195b9677932fac57ab5e"
