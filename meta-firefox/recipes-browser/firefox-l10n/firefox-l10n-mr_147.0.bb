# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6840e8e327d7dfb4e3f64b3679608042"
SRC_URI[sha256sum] = "d8f5c3973e099d738146bb7158a202727bd9970eb9ef9dd5f1928c3fe78b5d49"
