# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "46b38a8f6a814437a41fcb1eca3f328f876862e7fce4067ef38367b1751419fb"
