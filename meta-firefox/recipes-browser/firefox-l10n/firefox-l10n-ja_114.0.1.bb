# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2a7d3587b04370cbfe24b93f67dfa0e2"
SRC_URI[sha256sum] = "d373062b9709c1cde131b6561868ef887e0801e1589213b1a38a1cd2bb753bfa"
