# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "faaee4990d62b4ef40e3176e79b856f0f48771d692d94f406fe111a61ff11f7c"
