# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a6d3a5b2dc7c37b80f3407fac3db7d9c"
SRC_URI[sha256sum] = "0314cb403a1d07351a40295fcc105e37146cf967b3cf55b3ff76a3ad543d874b"
