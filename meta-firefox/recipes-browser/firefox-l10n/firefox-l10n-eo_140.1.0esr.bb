# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1fc2047f094baf7406101bb96ceab740"
SRC_URI[sha256sum] = "ca086cfd8eba637ab19e27e1661256383e1fbad0d43931937f0beafd37a6a433"
