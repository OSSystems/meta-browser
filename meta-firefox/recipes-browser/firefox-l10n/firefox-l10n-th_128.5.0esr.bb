# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8ba19f05d7b079ed13962a40e7a50e25"
SRC_URI[sha256sum] = "ba68ee86c35a79ada8fc6523054100320fcd7126a8feb645798b50c6a80112a0"
