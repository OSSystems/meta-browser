# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8b164c0a1204defa50f428dd6072bdbd"
SRC_URI[sha256sum] = "957de943a376937acb4e84bb05bb05c71a98f0bcc877679a05bc8d0a383af813"
