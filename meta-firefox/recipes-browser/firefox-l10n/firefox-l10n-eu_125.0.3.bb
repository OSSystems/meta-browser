# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fb899100d26bca459e30702a9ee04fce"
SRC_URI[sha256sum] = "03cc32306393cf9bea3eca86edd0ecff6b4504526ac744b6f5c301bbe28d88fc"
