# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2f425d1dad623e009338fe25477c4e49dff27423c19dad97096f2768f1c4bc65"
