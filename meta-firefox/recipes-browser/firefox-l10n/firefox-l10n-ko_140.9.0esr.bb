# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "edff693ca759a7a741fbe3c7db73a83c"
SRC_URI[sha256sum] = "121529923416cbb9d4283f64b7cb8162f21ed34177f60661a3ce50856d21ff9c"
