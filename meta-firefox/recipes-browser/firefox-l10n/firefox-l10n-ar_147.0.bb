# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "26f94bf34f207808e482b13313a09149"
SRC_URI[sha256sum] = "5cc540ff90e035110d45e60e512a76731427726113c3a7baaad3e769e6ec0bba"
