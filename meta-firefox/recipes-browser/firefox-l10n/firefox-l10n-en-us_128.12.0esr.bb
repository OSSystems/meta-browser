# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e16aca8a9a509b53d1dba76924404d3d"
SRC_URI[sha256sum] = "a9b3b2569c5148da6618aeb219991af019828e23912f78fe85e3c86e362fbffc"
