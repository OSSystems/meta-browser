# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "25b21ecb4f37cd12866eae3069de6854"
SRC_URI[sha256sum] = "b03272bb681effce8e8c82ae5848279f3b71721c3435a8315d9bff8598c3574d"
