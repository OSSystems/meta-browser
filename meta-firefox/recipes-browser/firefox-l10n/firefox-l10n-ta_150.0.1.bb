# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2cf572e74e9d86d02eb9784a8092c4672666663c72a7a3bf8d7b0c689df3d386"
