# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "04552b459c5fd4d70d5c65d95d4b96c6"
SRC_URI[sha256sum] = "7a8a1ea29439e0b87af45b96da9869a966067e4445ea9f5b2de2ac2af85ddeaa"
