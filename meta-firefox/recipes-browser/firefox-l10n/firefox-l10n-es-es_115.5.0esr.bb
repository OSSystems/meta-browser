# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "36a68a96e877eef121468ea7f2bf7b05"
SRC_URI[sha256sum] = "a5841378f4844d363d2ac1535b4ae0ad97254e971de30810ece257f43b919ff0"
