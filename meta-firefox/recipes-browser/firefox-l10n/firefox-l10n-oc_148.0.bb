# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d738840c4f0c5ce6e7d8804817ab38f7"
SRC_URI[sha256sum] = "e855960a7d508aeeff2213fc9581940c80f3b670dc946bc2d95856a89ab86e7f"
