# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "969a7aa316eb1b0d9d74d59ef6f39833"
SRC_URI[sha256sum] = "9616578704dbf273ccdb229bb8cd22cbeb6fed35ccbfd4d7cc5b35b3c1c21f3b"
