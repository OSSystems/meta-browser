# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cefd31c298a69ee02f85e93f3892b9a5"
SRC_URI[sha256sum] = "fe85d5bf26670b998c98c7d1b46318b65475bf529bcb095db5d725e85913e449"
