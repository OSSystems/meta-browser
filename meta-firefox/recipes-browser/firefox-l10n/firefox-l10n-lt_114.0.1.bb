# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0f2c7213d2e2553e2fd5890127131a19"
SRC_URI[sha256sum] = "462fd3772da6a5ec6c045ed5318cc9784c2b09a280a3f0276884506829472c1b"
