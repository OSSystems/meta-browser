# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dcfa3a5971b4512922ad47bae421f95e"
SRC_URI[sha256sum] = "ab762b5ce55cbf3a1a0b318d92f46efcdbe5ace1007c1d233da6fbb34ef7bf1a"
