# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "88618214fb6b1f2de90b01e756e94aea"
SRC_URI[sha256sum] = "3ddf172238dfaf10d444cc235b2d162f6af64b89100d6f80471acd86b0ade310"
