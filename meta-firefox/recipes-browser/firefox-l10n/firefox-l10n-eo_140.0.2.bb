# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e713613a1962f8e77bff944b75fd4627"
SRC_URI[sha256sum] = "3d902cd7d1730549e0c8a05701f1f6300ee0b4aaeb0f67ff323cd5dc50b4adce"
