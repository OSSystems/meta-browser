# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bf79cf97201fa0281d59f5991d03c81c"
SRC_URI[sha256sum] = "54367ed1337fe38ecba4e81d269d617d17cfdfee43ad96f223a595b7951cbd3f"
