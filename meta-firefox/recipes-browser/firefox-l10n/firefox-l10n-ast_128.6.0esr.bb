# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "502b22ae63080e5e4a30818f57043fc2"
SRC_URI[sha256sum] = "fa59f1ffbbae3c5ef9dfdd0c1df5a0b33b21ce04dfffdec45fbe87fa9f3d4ecd"
