# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ef7f1f1d73ae804328d86baabab8e47c"
SRC_URI[sha256sum] = "6a2b243b33b7bae4d2c9746425daf516d382762e9eb3fad6a31cd38fe4425d52"
