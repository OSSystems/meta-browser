# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "91deb7fa0c70b6888017decd7fdd7456b819867090c3fa17f04e78fbb95d5436"
