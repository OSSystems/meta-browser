# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ffc144017ef1d3af21a78a2fb2e5cdb06b6c5451d673704248705f13d3ceba73"
