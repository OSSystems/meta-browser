# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "75b5227255f4dd25bf68d438edef3554"
SRC_URI[sha256sum] = "66a2dbc7cfcfff00e437f9cdb38ddcc4569e4372d5c2faa37691519e4dfd02c4"
