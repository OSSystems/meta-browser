# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "60ac94bf04e09f983812cb203622b55f1dc1eec7f883df26d23b37d7db69de3d"
