# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e9fc198b46db87254050cd087bf51a55"
SRC_URI[sha256sum] = "2b0dc49bd10bc15798fe66879574b149fb56295d0a4aff62b2f6fd2b0426f5f0"
