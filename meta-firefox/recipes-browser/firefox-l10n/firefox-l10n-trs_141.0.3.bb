# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f6aa75cfa90c2c1162951a8aec68ece5"
SRC_URI[sha256sum] = "443289097e45db2eaf628a983154414e7a7517dc9ebb50a2130f48de971c84d3"
