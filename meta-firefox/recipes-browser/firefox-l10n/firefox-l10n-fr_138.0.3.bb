# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f5ce0a8b68a4315a5a40789fcb4e3351"
SRC_URI[sha256sum] = "0a02da12f79bc96a0a5e29072f2712c71dec116a823c6679197dcb39cfee0119"
