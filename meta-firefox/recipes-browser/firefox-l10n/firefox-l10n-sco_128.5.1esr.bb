# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "99df58b673f090cb0723b581b1ad1857"
SRC_URI[sha256sum] = "ef9fbdef857f45e4a321ef76b43383268e3ca8d2e2ac86183ba0d06554ea64be"
