# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8637a5762592bcc71d16ec98890c40b7"
SRC_URI[sha256sum] = "6ff7a212f335875553b26d23022da2e8c8d4cf327287e8c96d07a743964fdb38"
