# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "481e7879578cdb49e77d1b981f0ae086"
SRC_URI[sha256sum] = "b2257fdf1f7880b24b182e3412eecda4829ddbe9f9582d329479ee9334f3c579"
