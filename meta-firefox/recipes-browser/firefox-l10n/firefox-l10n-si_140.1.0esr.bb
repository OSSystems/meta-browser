# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4d2439470fbbef0adf74c43126f441f2"
SRC_URI[sha256sum] = "5e7aad352dc2752faeeb5c4616e537f4c9a3e541e7d8084d4d43ecc3cadc45c0"
