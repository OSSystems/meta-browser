# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "833ecfb3123498714e2549e05586f7cf"
SRC_URI[sha256sum] = "49efc20d7b7a2a92dfa8033492721eee0141124dc41768122144afaed54913b4"
