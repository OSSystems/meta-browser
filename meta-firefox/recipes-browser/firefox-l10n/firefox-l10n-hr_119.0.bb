# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f7d446049076960b1bad731b2139f0f8"
SRC_URI[sha256sum] = "f48b8b10c3fc1b13aa967f8d951e93530bde3a545cd26510250f3ec301a4a120"
