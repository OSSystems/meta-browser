# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f9c3330db1f96d0335f1ea47be6e56bf"
SRC_URI[sha256sum] = "ee27f7d599a3c8ef998c8cf9494c800cc7964ea53e7ce77f32e4a9841050acad"
