# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c3853fb0e44bf00c2f4af4d56f0a641c"
SRC_URI[sha256sum] = "6474882ca91b8310bdb6de7d2e7832f865542b7922e3d24160bff585311c3ac3"
