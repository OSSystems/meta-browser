# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "046949fe65620ecf997e8c5b4d7ceb7c"
SRC_URI[sha256sum] = "98364ed4f587bd9ebf0a0652f3510867ca3a88af2f729e0aabeba0dc641a4283"
