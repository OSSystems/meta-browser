# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3647b013251c58f86cedb861c209ab7d"
SRC_URI[sha256sum] = "be7b6012978b6a31427f203b65ba64e5db7cca1d347c101fbcc694275a051554"
