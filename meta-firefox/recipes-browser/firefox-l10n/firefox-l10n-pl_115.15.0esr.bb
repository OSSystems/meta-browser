# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "821a53fe6f19db638ce09c73bee1eca6"
SRC_URI[sha256sum] = "200d3064a50cef4281ac2815c3662c1049c97e5d58aac9bf31447aff7d9bf594"
