# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "992fceed6e2a0f18186dfecdba2c5371"
SRC_URI[sha256sum] = "721f9d19ca92d1db9eb23caa21a8361edc0523f3d20db09d7e0e907923e94500"
