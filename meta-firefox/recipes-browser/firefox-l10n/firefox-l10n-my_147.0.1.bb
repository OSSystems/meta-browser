# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2fe08b379399bb8abb57b2c8a3cb39e6"
SRC_URI[sha256sum] = "a120604a551bf3ce34c1e7cf8dbf969aa9f0ad9ca5acbbbac71f6698fa802902"
