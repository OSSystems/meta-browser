# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "da00bd07ba8fcdd97578cda4ac378467"
SRC_URI[sha256sum] = "63c607f3a234b87d57029a1388225dcdf3effa1f223bf9ae8f6f4da3354bd222"
