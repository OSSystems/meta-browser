# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c5b35bf72e0ac3677b06b78905e3384a"
SRC_URI[sha256sum] = "24b35fdbeb10d95f46f6b835963d8de467244a85b28ab2546fbad83712ddd05e"
