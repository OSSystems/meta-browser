# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "92f07d3934a5a7ccff35d61c9beaa5a1608c6a24fb8be87983c818c786e72bb5"
