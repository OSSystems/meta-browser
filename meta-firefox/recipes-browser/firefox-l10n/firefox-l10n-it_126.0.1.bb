# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a5c44cdff40e515c60cb2ac700d62ee2"
SRC_URI[sha256sum] = "8068ce3bf4c48b03b1dbe09ee942d0b63c31b94eabdf451616f740db18f89b74"
