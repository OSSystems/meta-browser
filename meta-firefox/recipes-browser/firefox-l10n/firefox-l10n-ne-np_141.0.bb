# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bdbf6067bb9d2bdbd58795b75d9a3da5"
SRC_URI[sha256sum] = "0f69d8f16b479f0c72fe9b360df9ff008ac52a40fbe7152ff2fee8fb07e31c0f"
