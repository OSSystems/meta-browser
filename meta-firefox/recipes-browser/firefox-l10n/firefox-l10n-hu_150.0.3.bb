# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7e314c787c8eb9fb3b31e72974bf1a97886795b11bd1e9c815b2f28ff6476de5"
