# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d1e68516932da87df8ee66ceb7cc05e8"
SRC_URI[sha256sum] = "15637ea74bc82655d8407b06b57d5ed66d0ef55c09b079edc63070a6c817ee51"
