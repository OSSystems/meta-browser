# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b87d7e05ab65a045e19566ac9d5ce3d9"
SRC_URI[sha256sum] = "3d5974dde34507482fd3d449c42b67bb97c95ae5461bc1e3e104532e6dbe0b3f"
