# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d2d053c2c898a67f59c9cf96fa8f6444"
SRC_URI[sha256sum] = "610c7acbe0f96cc02312d69b11dd2ca490be2aac6b36e8a69b4822b0f94d0b62"
