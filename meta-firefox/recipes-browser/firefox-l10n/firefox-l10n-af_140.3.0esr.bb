# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c95e9d8039b85c882bad4f0e7075ad51"
SRC_URI[sha256sum] = "bb0b2e01a07ad9042ab3c64c73116946b07c5889ab3a82cc0fe793e2efcb4731"
