# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8b7b0eefb5f5c94db605d25e21cc86bf"
SRC_URI[sha256sum] = "7a23811be47c911b49f6e6d732808b458385b789fa82013dd20d3d0e83e8952a"
