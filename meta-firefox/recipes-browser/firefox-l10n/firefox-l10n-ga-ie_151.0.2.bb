# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "b208530a272b0cade94922085574de078f29c04d0eb01e16ce4a6af3857ef719"
