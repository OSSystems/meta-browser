# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7e7658cb3aded3278add661b072bb9fd"
SRC_URI[sha256sum] = "a42791046418dacc93612a0a2c26e1102129458a08f8d3c55c45979eb0d2f270"
