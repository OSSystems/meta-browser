# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0cae7f32160a12eb8c4dc3fb5eac8617"
SRC_URI[sha256sum] = "a4acfa2d87f884e69df68c925ef5114dcdce2eec1d10f28f97848e0c2bdeee67"
