# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "64eb828a1cf1c7cf7a397d9c5cdc9e97"
SRC_URI[sha256sum] = "f411a7ed940f7a95bc128abdc0afb6e5dd5523abd92bf941809f28210d64d90d"
