# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b79068a9d7ee549a56b0d3d76f2c84a7"
SRC_URI[sha256sum] = "e3e92e12282b5ac1f3ebbad78e7468676fa8398eeb2bbcf2b506b039a9093438"
