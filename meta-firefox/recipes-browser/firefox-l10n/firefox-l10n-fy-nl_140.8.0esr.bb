# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fe323a81978e99d32313c254724ccee0"
SRC_URI[sha256sum] = "839b08312eea81b14dbc77146ee6437474cc1b081f0174ca7981735393fcb8dd"
