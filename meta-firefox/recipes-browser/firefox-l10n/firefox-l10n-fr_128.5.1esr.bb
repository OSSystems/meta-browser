# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a3dcc207845a6d6a359457236a98482e"
SRC_URI[sha256sum] = "f67025fb6fd9b5d42c342b3bab379a27743272eeda489cf38774fe3f83c36494"
