# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a8e62241d6ac477e3a78532f4681200a"
SRC_URI[sha256sum] = "2caae71fa84447059605507a2d41f6da257f071cacc55e3c70155a9110af4428"
