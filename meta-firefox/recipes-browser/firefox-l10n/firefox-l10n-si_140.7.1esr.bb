# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2c9e83824532d2acb643dcaf98e12960"
SRC_URI[sha256sum] = "8b4b7a2ceeee7446d81d643d11e73cd31157af082c64cbb5b494b79b1c1c2ac6"
