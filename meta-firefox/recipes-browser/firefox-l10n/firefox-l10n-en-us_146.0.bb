# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "113587324e1c8d091bf795ba732c3755"
SRC_URI[sha256sum] = "3ea98e0b83e58a4fba5ad7cc7343fb624ffff7c754a584d3101372aeef91269d"
