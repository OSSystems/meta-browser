# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a13683b5c56e5b38799eac64f4d2407e"
SRC_URI[sha256sum] = "42bcee523c76024bc66ddac6538e5662d218ce943080c9e9e42c649dc89843f4"
