# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e8f82289191b43f161743e2b587529cd"
SRC_URI[sha256sum] = "93a7d0c708785a7ff1cc07957086a641bd3e45c3370ed72a8f90c298655368e2"
