# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ed58296cc7f035252034fb56dc72f163"
SRC_URI[sha256sum] = "64fcb06f63a51c674b0c5146ee7912645064aa57e06a42a258d37ddbff5acdca"
