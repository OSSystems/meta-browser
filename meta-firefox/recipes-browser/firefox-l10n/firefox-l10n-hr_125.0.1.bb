# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bab5ec2ce847ea9d0c17bbcf19027a13"
SRC_URI[sha256sum] = "31c2385d0c1964edbd4902f93cec6dc6fc9de064340fb15e4fe8f7b8685cfb0f"
