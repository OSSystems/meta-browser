# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "bbf71e712f17ae87f266dff461c5660bc9824c8b424056abb611cdb3d9957bc4"
