# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "28d256cc6baeefd568ea9bcec7a7527b"
SRC_URI[sha256sum] = "4603f67cd396522a0d918fe758bf674ffaec4640261223db477906e981091013"
