# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e2b5a3636be5ddaabd7c3ea6ec7f0f26"
SRC_URI[sha256sum] = "f04c71f0c7ae31f53564287f762b0a9446353f6474ad452a466bb1a271ec2035"
