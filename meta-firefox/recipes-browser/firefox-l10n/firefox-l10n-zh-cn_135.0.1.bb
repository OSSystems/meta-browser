# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f8cc4b594a0c729a0cc0fb4f59141d49"
SRC_URI[sha256sum] = "ab1f29ca33318d1c0473c3966d2c5188be857b1e30c3c2fa712551096875f7b0"
