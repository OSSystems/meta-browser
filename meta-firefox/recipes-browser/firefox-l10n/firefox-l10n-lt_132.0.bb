# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7f8aeff651483d7ce739b179559495ca"
SRC_URI[sha256sum] = "c45811361281b8e6706579d1d8aa3b380e472c7117f99343ef5c2d598f0c15cb"
