# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "162a1ca6a22196de06959c28f1bac0a4"
SRC_URI[sha256sum] = "786664d1ead116b7f9e4cd2a7c5f7a61d5c1e91ea15ccdb167771a9fbc12a1e2"
