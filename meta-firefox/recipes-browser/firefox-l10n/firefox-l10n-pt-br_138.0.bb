# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "698b6b82f09af3c32795ecf41415d9e4"
SRC_URI[sha256sum] = "1ccb2effe34ffe5976cd449a5867c0ab314dcb20e6cb46b323a068e9ace7b0a3"
