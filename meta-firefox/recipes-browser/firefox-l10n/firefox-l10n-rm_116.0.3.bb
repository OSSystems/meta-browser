# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ff31547cdea87836473143067c7cbc19"
SRC_URI[sha256sum] = "b2930e7ffa7e56e98d17a8a9d3b25208bab02489646c621dbda43b8bc7313689"
