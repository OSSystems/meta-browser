# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1d3388fa2c5f4d66909e1b643bfb7132"
SRC_URI[sha256sum] = "0b05cd8e5a7cf70dba693bb309cd32c4bcbfeb027eefe0932bf79af0309010f0"
