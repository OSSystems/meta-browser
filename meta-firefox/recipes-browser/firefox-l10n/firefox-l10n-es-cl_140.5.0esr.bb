# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "349238ddbf1fa523fe6e85b6bb586e5a"
SRC_URI[sha256sum] = "ac90e2e98ce7cb26a9513d6967516b6bdd1e374ce4609a692f4e343221e2cc57"
