# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6b68752c0736d0f3a827e63d898a4268"
SRC_URI[sha256sum] = "531331021346f8685111b84bb53d4bb605ff8849175f867383bb87c623f79ec1"
