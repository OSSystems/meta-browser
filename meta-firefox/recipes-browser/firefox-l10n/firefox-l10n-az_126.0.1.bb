# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7b01826282003721aa653696757686f6"
SRC_URI[sha256sum] = "6055fe89355a05c87f67c6b30ce56a9c165e917a9f44934edfb11b7085dfe4cd"
