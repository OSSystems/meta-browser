# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ce1c8e44a4bba419e9a620075f1697b5d4291e5dfe44497189387e5495ae42d4"
