# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "42e760119a40c52b6d27ab91f059df8d"
SRC_URI[sha256sum] = "8302ed75199e4fffbb7cfc0e476ef83611d960824a357cdae481039ac6224119"
