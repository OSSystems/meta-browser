# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "334519330e623b7bf3d8f968a69f1f13"
SRC_URI[sha256sum] = "7d9b95ff93e561d095109dbd1cccd0057b8b4682d4513baf270d8ab13a121140"
