# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e928bf561be6e685ecf54323bf10c747"
SRC_URI[sha256sum] = "b9609fdd6ada8cbb0c4648d8233201cd5e354a657b8939c2935f3b683bcb6396"
