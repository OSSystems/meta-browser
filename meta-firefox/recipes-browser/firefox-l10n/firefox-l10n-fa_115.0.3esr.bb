# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c8562fa844f9939baa36233041eea49e"
SRC_URI[sha256sum] = "a37e30bdbd37255fc179f52a93f751c4242a2701f4c956b2c060b36febf685a8"
