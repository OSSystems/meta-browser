# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "63756b7bb86012f0894480f1cf194438"
SRC_URI[sha256sum] = "d6101613523c9d4b00cc7c085af31e307f329b4b5ee06da877484e24088ba298"
