# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2177d8181021258d0d887399455e7a63"
SRC_URI[sha256sum] = "713a39e6bd9771ccf5ee9f4454c9acbf961ef4eaf842d2b8d8fc6849023908bb"
