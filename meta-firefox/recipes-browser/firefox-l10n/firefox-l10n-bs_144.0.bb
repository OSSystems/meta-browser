# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4b83a5e96ea7c9a35f95c6deb07467fd"
SRC_URI[sha256sum] = "5ec5f7a649ec7d32a6dcbc60df1fa1e389fd8bac617f29969464a0c1e6d5dfec"
