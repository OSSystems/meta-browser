# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cba2e9cc35dfa11702b4d8594b95bab8"
SRC_URI[sha256sum] = "fcb1f65557a378e1a90aa92d7f72568efe923e3a2cf031d316ab8c75a5d86029"
