# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2da5bdd2001910c521e106b65c58e3fbec2ba300c86307af546ede0268a0d83e"
