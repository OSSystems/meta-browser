# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "1111e88a1c7214a8e4f9d55478831d3c3254b9ad6c0f4d5221b0652b842f2ca9"
