# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0592c7aaf1373bf90b49e383288c1bd6"
SRC_URI[sha256sum] = "3193b8e5ff4e1acf6909dae0a7d1806e617c893aa39f400eea5845f0b08706e7"
