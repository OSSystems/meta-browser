# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7e03465b32183ee5d5c5db2a03041111"
SRC_URI[sha256sum] = "093ae67c9693136a744c85f3c0bb3eba111506ade119d382ff2f551a8b78b911"
