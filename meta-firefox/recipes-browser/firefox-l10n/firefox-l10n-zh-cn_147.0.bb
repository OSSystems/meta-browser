# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5bae40db1e54b1260c5e0c0b5b3355b4"
SRC_URI[sha256sum] = "a1db8b5826e365e9c9349db5d81916142c0e0a8a9ec946524fe635399ba0cd14"
