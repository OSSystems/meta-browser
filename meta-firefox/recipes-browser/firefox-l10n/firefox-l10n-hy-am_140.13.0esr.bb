# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c94c7a4e28b0c0f046aba1a4d4057d4a49f2a1709ab7f0df1a1c4a12cc64997a"
