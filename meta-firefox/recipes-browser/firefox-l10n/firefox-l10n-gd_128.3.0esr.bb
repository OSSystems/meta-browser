# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a5978ae126740ac023ba72f39a8775aa"
SRC_URI[sha256sum] = "a74ebd579e0b1067d7eebae6f6a37055d0d8f0816d5c3e3a4040a3d73a95a559"
