# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "49037ae5f8d54f113b22982a1d6bfa4b"
SRC_URI[sha256sum] = "da71f44df4f5e13403cd7c88eaa0d2d6283b081cc29f82d74408fa308d77255e"
