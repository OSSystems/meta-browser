# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "27c884002f1bfe4e094d9ce8e2ea832d"
SRC_URI[sha256sum] = "637d0275bdcbc6cdb181fdebce9399143161a87bc94276464fa57a6dbb2abb83"
