# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2210c2e16d37d0ac969c3ef9268a9d4f"
SRC_URI[sha256sum] = "20d05afbb5febd05f989894f81c685ffb02959a6dd3ddf99feb5d89ecdd1bb65"
