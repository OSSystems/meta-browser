# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "962a55439d398a9235e51db7e36afe565cf758b72b95ad7eb63408382eb3a1fc"
