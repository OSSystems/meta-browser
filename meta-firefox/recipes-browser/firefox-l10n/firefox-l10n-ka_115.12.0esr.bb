# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "905b8fc5981c5b9bfb3b0cff3c99e156"
SRC_URI[sha256sum] = "97364c0a1467118aa818017d44e880bc90707379dd667c44e6423d8ea8e8a413"
