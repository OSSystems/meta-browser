# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8db48603e3c280a1252e9b0eaaadda07"
SRC_URI[sha256sum] = "8fd5165fbe8121ca52f1fa90f80d9f55d4299798fa4ac1616c313372b1eda6bd"
