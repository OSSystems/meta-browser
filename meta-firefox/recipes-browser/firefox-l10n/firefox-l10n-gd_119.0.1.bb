# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d69a1e9796a3cefffad3bf8a7ecf607b"
SRC_URI[sha256sum] = "163991c77ec2616d3139e7eff100dc2e78fd98868093c94a6e6a3aa223c6f223"
