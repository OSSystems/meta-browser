# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f2e44aa537f46ce3c202c508d55f0998"
SRC_URI[sha256sum] = "b3738ecbb1b1ee1e82253ebb198f7fe3da6f4318ed697f2b46d164b1df464c9b"
