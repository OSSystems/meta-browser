# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "02daf443be7312e386b8c91ee74f814e"
SRC_URI[sha256sum] = "19092b5973c72602496db957b617d84ee83088af16442e46fc32fd5ceab1d206"
