# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9c49c0bb334b498aec53eab2a70ba9f4"
SRC_URI[sha256sum] = "6059159e2d3a2eb26ac9d8ceee63a02101a1d245aaf98ac56f32cd8f4a616df4"
