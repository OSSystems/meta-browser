# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1ce12e6a22a51192c60de87f79e275db"
SRC_URI[sha256sum] = "5974a7efae941ad9374a0ba778d378e8e64c5226540ac38b9094434269932757"
