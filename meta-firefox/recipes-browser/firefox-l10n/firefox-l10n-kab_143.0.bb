# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5a88f16ad0b5fcb900f73603aeb904b1"
SRC_URI[sha256sum] = "9253e8f494f6951669dc8867f372f2da8212a5a74067808ff4e64726f093925f"
