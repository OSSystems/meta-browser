# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6e966d531345bdc65e458fc06f5a7df2"
SRC_URI[sha256sum] = "da93ff73b66a4e04e20d4ada5fe82b4b67df7c7fe63e51b4c6a5f968ead88f95"
