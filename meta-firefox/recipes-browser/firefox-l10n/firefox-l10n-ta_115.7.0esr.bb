# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "912ff2e2af3b6829d5a9bdaa1c9b4ca0"
SRC_URI[sha256sum] = "34524c72f006d69e0441a8f40a6ad5ed335c298cc54a74566d7fd1f0f317be5b"
