# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6b81bdb326e7a803f317695d46694c75"
SRC_URI[sha256sum] = "1e019a9030136cef646b9dc986fa0b862aff354432a1b5f67496a08859ee2dd3"
