# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "506a9009a91097c7c0b7e75a5d87e693"
SRC_URI[sha256sum] = "b5f9a6581b7a2e3c5e35f2b6ed7a98d4a475a9df95552b402771b8fe295c4584"
