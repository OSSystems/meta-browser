# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c30e3646665ce7dfa89ba6f7832821f2b541e397d13738860a426700583763d4"
