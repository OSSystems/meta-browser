# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f8732a10c867723be8193b81322b51da"
SRC_URI[sha256sum] = "3a3aee7904c4ad417dd0d265bab9070aed688fd7eeb99f682846e6106265cb76"
