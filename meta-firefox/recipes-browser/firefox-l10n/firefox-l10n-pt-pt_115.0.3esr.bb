# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f3ad147ec15a0c7e401101febe7809c2"
SRC_URI[sha256sum] = "1f1527e1483058127a4ab9c124759aff29e0a0c0861f7a8e49e91807f1275b6c"
