# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "32c92fc35ad1a1be6d74cf9d236b686c"
SRC_URI[sha256sum] = "64e9e8a89439e894d3ef7fe57c0e0c65da570b1bac118641a3d3a53fcc9d7501"
