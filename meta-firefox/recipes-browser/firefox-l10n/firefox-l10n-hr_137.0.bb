# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bcbbe13b01443af6c3055b62f0f4c1fb"
SRC_URI[sha256sum] = "6703ef3622e09afa70e7c5791094793363bfaf65d1e2de74ca368aa2d25ba21c"
