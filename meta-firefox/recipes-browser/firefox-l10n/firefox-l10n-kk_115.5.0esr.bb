# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "37479973a4c231987ebe983f4a501716"
SRC_URI[sha256sum] = "2739065ef087db8a01f56fd624c6c4d8600efb4e16f43945401b17a2708fc78e"
