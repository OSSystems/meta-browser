# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d39c13495914e0854a3d38b3de35aac3"
SRC_URI[sha256sum] = "664aec983e18bc3d08789c1608939150fe1d81bd53d21e6ad437e68dfa71e54c"
