# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5a1a7cf9c9ed0c317adba15be32ae19f"
SRC_URI[sha256sum] = "441e1c730c61c0135b6ef7f5cb125f6ca7be9c9ed2739e56a5ecc23a90d73c0f"
