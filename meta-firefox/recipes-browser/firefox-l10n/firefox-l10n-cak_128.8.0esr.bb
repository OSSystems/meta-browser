# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "662428febe790e2e8baeecdf13baaa67"
SRC_URI[sha256sum] = "9e258718f28c5946f8286ad92186c974a4dd8d15253b00c824055c426935a652"
