# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b41b6fa9f0c01057f9db543f3693ceb9"
SRC_URI[sha256sum] = "511386fcc6319091c24a7b083b6bb66995cb7a616e1787b09fc6c674f9cbfa08"
