# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3dab9ca13b0efb763ca79f23c119bf89"
SRC_URI[sha256sum] = "53a92e7503fb4c3e982f800d4184cd11a6289f042a19a5a8070a9302b4f203b3"
