# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6cd03424fbeadf5f8f3e5877738dea43"
SRC_URI[sha256sum] = "dfe933b7883dc2282685540229b32fc31452d258611c5f22e4456f9cf08f9dbb"
