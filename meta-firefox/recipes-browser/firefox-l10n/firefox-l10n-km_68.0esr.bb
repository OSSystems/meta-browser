# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e6b3429cc0e4738fd60a2edc0f1b09d2"
SRC_URI[sha256sum] = "a9efdef53b56806f9239717e7781b7be789f438b0117e8d9cba4f6317b0c57d9"
