# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1c334ee205a0543730c6f337d27a068b"
SRC_URI[sha256sum] = "697a82afa6158e4d34f0b13a66a7963c817a4896851e4f9946545fe54fdd804e"
