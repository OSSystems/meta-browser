# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "288647bf0e374894032f58946292d076ef2230ec345ddf8d0e9348086a9b532f"
