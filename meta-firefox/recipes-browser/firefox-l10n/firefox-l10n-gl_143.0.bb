# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d576e884ea3e024ca126ff201eea413d"
SRC_URI[sha256sum] = "82c0ef10cd9482f870cf634fe5a1c617a93883cedf4418feea5a4002cd7af177"
