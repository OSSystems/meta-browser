# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "91593c17f7f0da278f74d6872b1f50a4"
SRC_URI[sha256sum] = "05e96b8e3d241f2cef0b2ff17fc15bfe5c7bf774b00157244ef68806731fd8b1"
