# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9eb3b9d92194df9dc5018e636c5c8cd1"
SRC_URI[sha256sum] = "b9a966b97fee8ff72b34bbc509fa99b59700fc4a6e8dcccb31d64cedf4f9f5be"
