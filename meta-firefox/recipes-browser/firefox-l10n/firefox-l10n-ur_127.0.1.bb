# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e76d848540705ea9ab81ffafed272b4e"
SRC_URI[sha256sum] = "91ac7eb3350d23a030cdb5572e848911234715bf04f7479ca17be49758b7c9b6"
