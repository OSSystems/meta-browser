# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d08f4fe83b858624447099a64a990080"
SRC_URI[sha256sum] = "ed41d6f1cca4d43c4b5fa036fbfbdc45bf01bc1dd61f311657b4d9b88f745d4a"
