# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f97ca7c3d56f2d85cb4cbaeec5e9ae49"
SRC_URI[sha256sum] = "96d542599ab67fbcc845a06608b78d31b1ffc35b7528ba2b25f1df992a6dac9f"
