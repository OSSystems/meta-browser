# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ad35246bb0378e85427edd9ab0d0c5f"
SRC_URI[sha256sum] = "e5a887187e9c2b5de1279783328eb8ffa387de358d8552961ef86edea7296b9e"
