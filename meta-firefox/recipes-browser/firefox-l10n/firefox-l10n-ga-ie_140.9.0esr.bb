# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5e5ed4f79e3ff167828456ad0de2e996"
SRC_URI[sha256sum] = "b1b410644500bb1f70f6493839a69a2adf8563dad78a6a469a1a2a44a526cb73"
