# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5043482beafe1d747011c5ca8c9e329a"
SRC_URI[sha256sum] = "8d96f92265388246df7156068535c805bcf6d428d306bd6d3c0ff9fbb90b3fe0"
