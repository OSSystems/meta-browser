# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e0af6d3b7000e1a58d4a8fb409ba2f7d"
SRC_URI[sha256sum] = "0c70f7079dc495581e93afc02da5942350ce159ffe5b2c74cf128e8a16dd7369"
