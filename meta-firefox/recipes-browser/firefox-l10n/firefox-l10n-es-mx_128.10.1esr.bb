# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "46d2eacb5831b32fd23fedef7b4242d8"
SRC_URI[sha256sum] = "a7b7b4fa044e5de8bc1d2bcea0e05ecb0ca0eb49668d3c76d45e903905172f01"
