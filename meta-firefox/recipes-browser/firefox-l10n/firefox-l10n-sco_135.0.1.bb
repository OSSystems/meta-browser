# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d0f24070fa7d867bbf1e33779c208982"
SRC_URI[sha256sum] = "416348dd8174cd5090b1b2cdc5179113dde09b75abd4530f45b5909ba46a4182"
