# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "18f195e0d7be0fb036bdd4a605e659ad"
SRC_URI[sha256sum] = "12b494adaf7c3a5c26871b21abd814a34a3abfe214b8158c06bed8d54ce23cf7"
