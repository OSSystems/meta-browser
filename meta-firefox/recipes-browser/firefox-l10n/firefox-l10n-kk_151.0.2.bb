# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "fc2bc098b47e58c31ad90b26d47a90bfe6741dcd73378c9a2718e96be95a7a23"
