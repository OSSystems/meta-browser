# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7b693341fd3842f8063b6987fcdcede7"
SRC_URI[sha256sum] = "5b5b3dd6536fce2b1b49a0601531a6d99de309776bbeae9bc26fda3ad8ae00ef"
