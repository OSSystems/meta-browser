# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "58eaf125b7ea57532fa47b438a60abb1"
SRC_URI[sha256sum] = "9499210232adb93a310368cefeaa74c18d55facda52202a7af5f3b4bdcf9641e"
