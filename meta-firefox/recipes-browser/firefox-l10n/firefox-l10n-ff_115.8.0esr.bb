# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0baa8ddc082c9506a07f6f1f56013c11"
SRC_URI[sha256sum] = "962ba62372fdfaa931bbe25d95ed95c1ef28e722ff18a2e470cf43c06372ea5a"
