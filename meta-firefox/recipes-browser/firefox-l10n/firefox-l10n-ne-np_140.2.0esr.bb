# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3686920faa45739a4c7d683d2de98f60"
SRC_URI[sha256sum] = "ab4c36a048322e03de44cd8b629210665d8bacf30885cd124d59cdb6696a65c2"
