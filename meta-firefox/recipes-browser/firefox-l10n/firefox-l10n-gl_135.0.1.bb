# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "08da2dba675ed756eef2a3aa9f47b3fe"
SRC_URI[sha256sum] = "3d31c7633ffc6200e43cbc32125172356369592ab02fbee176c657ff06173ecd"
