# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "35a0ea767116f64e62c9bdd2c04838de"
SRC_URI[sha256sum] = "152684f0b75bbd5a6556125cf8bfd2ca5fdfca37c86b394076af999a2c196d72"
