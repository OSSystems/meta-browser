# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0e25f65cb392f3622ca284557d97359e"
SRC_URI[sha256sum] = "616b86926fdd3758c92ba10173ff9aa57a2d7cee5d14409cb39935332790252d"
