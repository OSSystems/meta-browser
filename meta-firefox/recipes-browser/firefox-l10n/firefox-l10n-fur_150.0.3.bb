# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e8c4523f686cc2a41d16c0eb5e118459f4d924aa3018055b7935273bcbce3179"
