# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ce0ea42fd4c78bdc8c139bdf37d08ed1"
SRC_URI[sha256sum] = "19aa22b9aa5b7bfb96befb3fa9e237350e9cc0897bbfc553c7628028f2038ff2"
