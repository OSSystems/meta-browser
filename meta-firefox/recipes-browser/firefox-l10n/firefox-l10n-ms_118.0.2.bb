# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1487408e098bc0d981d017122c4f1076"
SRC_URI[sha256sum] = "00406b863e6b0f2adc1f4362ec427a7a827991c957ace277c83a2887012f8175"
