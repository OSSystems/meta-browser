# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "5de37bb7cc2b60b0ae40b2d650241f1181973d2f7b8a232d7bb9986ff6eca7a4"
