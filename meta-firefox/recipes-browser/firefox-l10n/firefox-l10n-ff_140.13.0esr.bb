# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e81fb9785c18fbd71c94f600df6d469e05f46a6f9fbd66c7925a87b333f265db"
