# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ce9318cdb013a04bcaa7f2a08917204d"
SRC_URI[sha256sum] = "c9f15830cefadbadbb06d1a268fe2c60befd74d8d570a78fe3634bdff78caca6"
