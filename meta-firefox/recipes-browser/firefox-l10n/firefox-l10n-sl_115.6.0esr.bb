# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f61d8c4b6c7f5969785f7a5034eda598"
SRC_URI[sha256sum] = "ab6bf76af6552ff64330126c8c5e10953fa7d5c19467ef62358b9ee67b7e04f1"
