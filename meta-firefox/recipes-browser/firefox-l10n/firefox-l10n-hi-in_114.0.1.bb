# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4544005fe1c0f3ed2962877da6d3b01c"
SRC_URI[sha256sum] = "c9e513a96cc506ea7d1190fc7cbd5e2d10e4a4bb03ee8db18728cd2792a73979"
