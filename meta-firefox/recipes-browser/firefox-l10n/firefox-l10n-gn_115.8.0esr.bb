# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5be67bec6c5ff0c744dae7f2b4f28395"
SRC_URI[sha256sum] = "0bcb590025a79a9819a14aff4e6572cdb866571065f8cc3a43eff3f34be142f3"
