# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "56dbeb11fff42a8dd36bef09af52628d"
SRC_URI[sha256sum] = "972d44787fa7aff7c7ecc8c0e1c55a0857db6b6b50a6e467f3df79b31f837cd9"
