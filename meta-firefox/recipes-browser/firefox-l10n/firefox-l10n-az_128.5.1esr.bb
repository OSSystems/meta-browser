# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "61e009a416e25ea01d4e8e0edcbc41b2"
SRC_URI[sha256sum] = "8b02558690c6d86a08371d8773aacfc4f4bd845752eaed3b81435010a84c4c7b"
