# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e3dd54dc550de700abeadae853a28956"
SRC_URI[sha256sum] = "11ea20def315ff62adcfe5dc6c700d7a7fe8dfe2fc50eaac0f7ed7d4d8aceebb"
