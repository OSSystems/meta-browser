# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f96e4913d747949e8eca74aac9a362b5"
SRC_URI[sha256sum] = "81573bc1e1c3583f1c69f6cb7b6d1b033a4b14548902f748091d4e9e40c9b94b"
