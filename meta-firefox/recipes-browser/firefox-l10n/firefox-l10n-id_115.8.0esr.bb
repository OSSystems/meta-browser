# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eaf71cb5edd1a1207d02dfaa30be3ae3"
SRC_URI[sha256sum] = "0da42f27403c209daad852f827cd93e986383e654530d2db4d657d53ce529d46"
