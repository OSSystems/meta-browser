# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9fd329ce728e93702e4ee9e2cfbbf7f9"
SRC_URI[sha256sum] = "3848c4b329b2ffe2431bfe4874a959424770d7a751ba235463ba06c1c674a769"
