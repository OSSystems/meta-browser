# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dc2b3576688d2af153d2e5f9f83c10ff"
SRC_URI[sha256sum] = "7858a065908008f1cd23be958b97c5baf843e976bdc4c1de9ff6d7ace943d9dd"
