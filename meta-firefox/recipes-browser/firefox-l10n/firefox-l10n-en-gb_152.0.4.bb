# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "6043700e7fa53be284e3640a8799c63a93d68658ee717f3023d8aa57e72833f9"
