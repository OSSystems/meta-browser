# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a259c42e342b6ce63d360bacdc2e5bf1"
SRC_URI[sha256sum] = "8ee3c9f69a716cffa2f3638d5fc7d295ce5f8057742af301a5ec3aabde696b36"
