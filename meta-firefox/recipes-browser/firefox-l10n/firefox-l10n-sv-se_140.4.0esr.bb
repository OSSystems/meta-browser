# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "185c4c81a97ac77a9e95fb6c05acac42"
SRC_URI[sha256sum] = "8fac5fca75f8b3d2e632aca7ee3058a7795569ba00d5186218cb9eb4fe6fbe2d"
