# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "60767783f9c4a4b81c02fe63b444de64"
SRC_URI[sha256sum] = "43eb52207c323f4b8514f2c762d6314b5ef95fd4409e8aafea73871cc5d3376c"
