# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d78faeaa18baf82de514ca33414ad272"
SRC_URI[sha256sum] = "c06c0eca15ca420ee9895cc5b615cf603be01e0df40b9926e6fff0bb61266f04"
