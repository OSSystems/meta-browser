# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "483f5a6448ff7b17ca3ec8a0adab47fc"
SRC_URI[sha256sum] = "7aed1d26ac38243f32fe13321a75b41ba4478451984500484460fcb2d7b6759f"
