# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5bf32d37a842fc0577424cc1dcd59a69"
SRC_URI[sha256sum] = "442ff7c7f995af9aabda5a2be6349ce38304fcdf7c3d2d2b9102604fb14ad7d0"
