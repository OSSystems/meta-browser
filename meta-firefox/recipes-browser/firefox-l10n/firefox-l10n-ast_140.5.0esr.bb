# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "856f276c003f46d0bd7d1412036274e3"
SRC_URI[sha256sum] = "2b22628439a5cd5d4e26523a050f9fa4617ab489595c9411fbee8ca0e90e314b"
