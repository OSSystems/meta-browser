# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "688aaae99c0a7dbee5b2d629f968c043"
SRC_URI[sha256sum] = "27391ab8545f4a09c46ced3c0b45b5f60ce7f72c7cb2ae323a6ccc275d745b2e"
