# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a26a7e9979bc5859d777ca259f359f5f"
SRC_URI[sha256sum] = "0eb27d3ef1fd0c162f0e992c492aabdef93d961d688703b8ff8e0de4492c7263"
