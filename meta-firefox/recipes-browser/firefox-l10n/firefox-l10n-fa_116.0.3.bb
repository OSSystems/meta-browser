# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9a28404499b8f012d483eabfd42a7ffc"
SRC_URI[sha256sum] = "b883242e7b8b3cf213a3aa780ca46eb8da2046cebbe4e4afa5d57f8ae44f9749"
