# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "be7b99aab565cf11638cafdd013aeb18"
SRC_URI[sha256sum] = "f8374f26f2ff405cc7032a0dbd88375b977171a13f48d005c733ec940a6a0fd5"
