# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f146bd184a394fd538ffa7055c960839"
SRC_URI[sha256sum] = "fbe382415e7f23b6ce52c24458e9f5b8102126bc5f4f76a785d0d8e39f40b72d"
