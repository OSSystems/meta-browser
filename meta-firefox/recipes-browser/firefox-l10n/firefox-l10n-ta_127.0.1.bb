# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "67101586891e45371dc2a632ac79d22b"
SRC_URI[sha256sum] = "0c5c00b3f87f2e883628415a0994b452e8b36f483d85632e0f92e838981af2ed"
