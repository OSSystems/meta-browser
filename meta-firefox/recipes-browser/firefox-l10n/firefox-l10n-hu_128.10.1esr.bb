# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a66357d289ab832fbe948018ec547147"
SRC_URI[sha256sum] = "cb9dba39bf530fd51ed9cdeaf8038864b2403da272878a8f369572ddcaf27429"
