# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6efc62ed515ac09412ac0ed429521856"
SRC_URI[sha256sum] = "315773ebd4db4c837af71220609ad4aebf4589c32559e25c6097f05f3ff52e95"
