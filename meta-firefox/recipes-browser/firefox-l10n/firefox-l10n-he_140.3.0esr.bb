# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dbd1bf2a138221acea3c5ddeff0fffa3"
SRC_URI[sha256sum] = "2ed05a9fbeb2afe9bedc9018165d8c1746fc9213ac0a3f94aa97f8a79c046fd2"
