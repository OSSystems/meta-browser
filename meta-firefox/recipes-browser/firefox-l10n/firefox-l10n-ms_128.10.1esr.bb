# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "21c69880fe327f0a3ae72c0a9f711f2e"
SRC_URI[sha256sum] = "961ed4f3b0b061e8a52309dbe282d16c359ef778df397065cf4e7e1ecf7c1630"
