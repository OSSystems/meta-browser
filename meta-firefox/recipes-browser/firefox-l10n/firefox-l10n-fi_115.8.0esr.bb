# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "83ed3f3707410f924b49f3468e196405"
SRC_URI[sha256sum] = "83798dfbc54e67de6c32c67d340f92da2afa787d571d9616b159419eb3cb919c"
