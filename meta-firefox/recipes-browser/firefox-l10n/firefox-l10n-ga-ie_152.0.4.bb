# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e64f3dd602e3c34384e7364a48135d3ba973cb990cebaa4136e0b05ce7a83100"
