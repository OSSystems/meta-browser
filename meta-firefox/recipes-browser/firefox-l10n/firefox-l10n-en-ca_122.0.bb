# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f92fb5f81abaf7683eb8078d44783e0f"
SRC_URI[sha256sum] = "c41b223aea5d3095fa37ac5728f4df501c8e0cc20aaa4cda6c8b7b7a26fd656b"
