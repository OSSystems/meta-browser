# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7a606002d50f14400c0bdf3bcfec80c4"
SRC_URI[sha256sum] = "46d3038e5888a8be8a02ea9bd71f1b95cdeaf43d7bcbbfd131570f59226ef5e4"
