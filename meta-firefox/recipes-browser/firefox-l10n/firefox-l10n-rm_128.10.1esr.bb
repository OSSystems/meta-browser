# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9fc2dbb30f4cb63c56770e85e369b37c"
SRC_URI[sha256sum] = "6aeaaa653ff041605dbd47c705a23a6a5619af1003e40986c253d8d58953fe22"
