# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "02a785b7e2da23580243e0a3659183d6"
SRC_URI[sha256sum] = "f21da7563ba33979fdfdd71cee54331562d5bbbccd89430c1740efddfefa104b"
