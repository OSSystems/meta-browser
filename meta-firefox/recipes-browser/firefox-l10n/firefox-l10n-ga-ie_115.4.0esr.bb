# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "be75472cea299be0a501d37d4ea9b1e9"
SRC_URI[sha256sum] = "fea62f85a3a5fbb844d990c22a8a0858988ca08d16682de77e9125bc8af8906c"
