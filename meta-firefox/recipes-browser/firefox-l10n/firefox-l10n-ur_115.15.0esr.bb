# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "960465d15065d11b7e2f462af7620b15"
SRC_URI[sha256sum] = "aae4adde914df13c167545b9b8688f5efd55664e4d7c8b6055ee52841ea0740b"
