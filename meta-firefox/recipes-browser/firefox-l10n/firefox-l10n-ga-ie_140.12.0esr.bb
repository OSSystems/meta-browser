# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d26f0149b059bc68a1b068e0e21f63499f7b7d18bf4f2c5532b2503ed4787a27"
