# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dda142325f2aa6eb05af17ac68911863"
SRC_URI[sha256sum] = "76228be886410f87be24f54cdcd7b89f1c25208efe45dc53e116c4f3c6f46c9e"
