# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4c5b49d2815dad64b285802ece16dd20"
SRC_URI[sha256sum] = "c0a456e74fc0a31eff3acb573593e2e588468670589d099457c29bb9d14020c4"
