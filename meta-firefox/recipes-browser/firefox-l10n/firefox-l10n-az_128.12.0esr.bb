# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f100e5c0c4db4038ff30fce567c8d036"
SRC_URI[sha256sum] = "79d3ea7ac3377d3fedf17f2e65d7badac70a03f64056ba67d0a61961d8bbf851"
