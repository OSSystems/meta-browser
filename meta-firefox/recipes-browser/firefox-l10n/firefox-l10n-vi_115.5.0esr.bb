# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8934d0e13736e20f15f228f0a82146b1"
SRC_URI[sha256sum] = "52dc7214cc6742a48ec8af14a6c677a47ef79d7554c635ae3ba172c593c939ef"
