# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d8e919c78b8b85eac98ab28531c167ea"
SRC_URI[sha256sum] = "71955688e2c4af331c9cae91f1b7654e8d1eea0b6443ad70877187df689c213c"
