# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "324bb1157101d28ee805ac44170184c3"
SRC_URI[sha256sum] = "424ead56e63bb7076c261d69c59d2b9a6a9703a336588eb415b6bc3510d663b8"
