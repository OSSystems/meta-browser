# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "02fe7e0a0da81ebbe24b458bd87f63e0"
SRC_URI[sha256sum] = "4afd44d0d345a9dbc534ddf1e64bdd627ab43a896cdb91b5d038de54840fcb4a"
