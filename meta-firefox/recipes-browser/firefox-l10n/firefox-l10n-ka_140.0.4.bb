# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2b4944186c66e63cd17305051b7abf70"
SRC_URI[sha256sum] = "2b750fde0e31dec0456d9db99b81123d7fb3d1f39d6f9e5708b0fa0fe1ae9e0b"
