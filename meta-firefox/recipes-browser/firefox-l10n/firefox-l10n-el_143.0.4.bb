# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b7c648e777d97f951b1483d690cd4650"
SRC_URI[sha256sum] = "bc5f3cdaa791cbaef59bf52b240924b4744b57d4004bcacd3286d0902798c2d3"
