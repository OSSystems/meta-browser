# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7c7c36e82bbc9bd6b2f66bdf0906701850b383748e0532715de91d9fdd4872cc"
