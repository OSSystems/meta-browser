# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "66fc523dc9fc4dc8fd9c88db1670f6f7"
SRC_URI[sha256sum] = "b1f2d82e80bccdc153f2f64df6de270ded258f987860904a203c91ee0c7daa18"
