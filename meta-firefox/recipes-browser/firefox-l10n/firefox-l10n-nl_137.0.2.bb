# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "143d97d15d221969b245838e2256a2be"
SRC_URI[sha256sum] = "e31034fd598ed5026ccbf9f2f730af8c5e051f11607e018b262c60d8d7cbe083"
