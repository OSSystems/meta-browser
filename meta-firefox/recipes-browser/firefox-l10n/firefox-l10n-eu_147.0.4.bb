# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "12c06145f6c6be1b33ea417353683153"
SRC_URI[sha256sum] = "e812c94f1e4dece19c33474a3e1525277e1a50dc6481ca145c32ec5daa4ed7c6"
