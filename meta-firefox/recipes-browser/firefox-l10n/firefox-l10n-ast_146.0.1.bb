# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "65027ea0eb431aa7928ed56364dc8538"
SRC_URI[sha256sum] = "f2da17273c04eb58094d36e0088e9152d1ee470d830d2e7902df876749462c91"
