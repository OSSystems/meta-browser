# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8833186d6bb3fccbf65ba35684e999d1"
SRC_URI[sha256sum] = "7c76d659502d8692ab9d6ae2767fcbe2069585da36fbd69b6207c27730b97c33"
