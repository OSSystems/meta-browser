# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "100d1b6454ccd79e91d2ff36cd714240"
SRC_URI[sha256sum] = "ad91c7e297908dd0f75c8a6f59336a380e506aeed6d8d85e38b56ca042d82264"
