# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "27d16f907f08ccf9779005edb8655c75"
SRC_URI[sha256sum] = "71194d0e84e3eaee41eb0e37c0df598dbd9ed62989a1a86f958bb6bffb9d70b6"
