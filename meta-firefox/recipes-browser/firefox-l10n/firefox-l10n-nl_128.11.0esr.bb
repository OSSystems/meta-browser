# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3113b891c7172d229979d154f6dfc5a3"
SRC_URI[sha256sum] = "7a48fd42f160db6ee019afe8b90526b18569aed39bad69690dd147e8c06940ec"
