# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "5fce1ad714520a5d96163e6c16bd44c30b47796fc761ff654441f37accc5ea3f"
