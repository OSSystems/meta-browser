# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6d36628fb88b8451f6a378ed00b7cb52"
SRC_URI[sha256sum] = "0876bb6f50366690db6bbb8de37f1282f28119820eb1502a73125a9fd3f8c02b"
