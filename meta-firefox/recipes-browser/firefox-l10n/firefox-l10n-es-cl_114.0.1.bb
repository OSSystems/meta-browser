# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "857632fa8d4be947f96fecf8063bcd2f"
SRC_URI[sha256sum] = "f21169ee7b3517141edd88745c1a6220972ae279564e61ec9d977d520db6bfbb"
