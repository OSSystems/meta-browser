# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "79f050326deed4b01babbddc3eed4bba"
SRC_URI[sha256sum] = "0f026c89fb1c2a43e6d0bacf26c284d5806fe88779f8209943c39466658520a5"
