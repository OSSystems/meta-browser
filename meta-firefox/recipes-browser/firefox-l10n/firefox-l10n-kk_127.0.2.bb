# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c89e4d513ebb5fd66c38eced19017b8b"
SRC_URI[sha256sum] = "542863b6d4aca02d62d371f54faae78b0e781b5da66441c1a8535a57ae3d1a85"
