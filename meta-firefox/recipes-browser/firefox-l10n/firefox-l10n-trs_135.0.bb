# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "adbd7dccbc2d79fcba90b97935324719"
SRC_URI[sha256sum] = "ccb079ba9782b829d1c5faeae2b35a9dd07b86997b47c90b42430c3fba35a1da"
