# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b3c412ae130ccb6aa37b15b4b6e4261f"
SRC_URI[sha256sum] = "27717c44da4409d33f8aa6081542a51e0db289b03c0ddf1fe50541ab3826a3df"
