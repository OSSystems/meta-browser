# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ba69fb71c299adcd6836995d93f16550"
SRC_URI[sha256sum] = "4505f32044aba1e4426424ae4fb96ba04c1af7a495b66b2990dadfa3bd5a080d"
