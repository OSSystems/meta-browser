# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c16514ff3c3aa1806a5d5575831404b"
SRC_URI[sha256sum] = "2ef49f5ad0a5f2539d5c79300accd10e791d90ec708b1251282a851e54db40c9"
