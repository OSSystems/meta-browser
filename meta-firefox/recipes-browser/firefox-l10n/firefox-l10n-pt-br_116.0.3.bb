# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d6d1d337cf2a3909a0dc8443124ab778"
SRC_URI[sha256sum] = "fd1be41b8b6853fc2c971ace04970b1d337fee6455bbfc8f1368618ab2d2e168"
