# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1e600a510cc1f02af6abc67507bd310c"
SRC_URI[sha256sum] = "dddc4b48da461b4ac68898bbc2036211d95447655f886d6682c61d43e643f8da"
