# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bf240e7e7de3b29e09c3e428169640d6"
SRC_URI[sha256sum] = "4125006eda53f8d2f6b601948bc69dac77397783059c6d5efe712956d9f88a31"
