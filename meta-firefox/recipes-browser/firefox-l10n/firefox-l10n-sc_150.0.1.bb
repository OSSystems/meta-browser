# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "9b4c8f8aff6f1442b27e312259f3309c10867a4f613cce6710654644f9619bab"
