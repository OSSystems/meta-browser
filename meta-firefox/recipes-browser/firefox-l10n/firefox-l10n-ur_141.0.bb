# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cf04fdffef7159804a7ee6fe157a4081"
SRC_URI[sha256sum] = "49d50abfe7aeac062eb23014631a00d709e14d4570d746b8a82be3124c0f5d40"
