# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3e4dafa3aee1ccbe081ebc23ea24a7f5"
SRC_URI[sha256sum] = "7ffc796a9732782edb50f73f6bf937ccd4a19804811d9638d6b6930f84d66b73"
