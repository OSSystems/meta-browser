# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c10c8437e9f397b23e141d80d4435ba"
SRC_URI[sha256sum] = "262c8efffd65559700725a23da0080e7a65cbe1796834ecaf4de7d7676d21952"
