# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2c9d550ccdcdc83c35b2516fa3a23a10"
SRC_URI[sha256sum] = "76e4e4d5238c21d554d803f0d751d35fc7181f2023e6a201d4531d1caf9b47e5"
