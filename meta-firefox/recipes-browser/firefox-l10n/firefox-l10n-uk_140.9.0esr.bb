# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ed3550e6e408e39c1db9113ad328652e"
SRC_URI[sha256sum] = "c2dcccf3d30b047db3e2355e034dc78a7b8f8faf6abb68075e0d06e00ecdff72"
