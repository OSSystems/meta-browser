# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "87b421bed5a4a506d6d8900923ea892a"
SRC_URI[sha256sum] = "56ff58abca601d51aee5418d1c888cdd5baba625e05fd410d71f5630c90061d6"
