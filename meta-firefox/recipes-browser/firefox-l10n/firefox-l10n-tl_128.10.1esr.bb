# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8f013cd96296cf3af9170da3f7776c59"
SRC_URI[sha256sum] = "a8f15cb73a02b1a0de2485b09b87ea122c393874666ec687445d116ab0da7737"
