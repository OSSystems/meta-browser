# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9e065a7253c7db760a20285368c212aa"
SRC_URI[sha256sum] = "903661bb8e9c4d0daa7f2beab8b08b407c2be24a3c3e26786a34d90fbdff19b7"
