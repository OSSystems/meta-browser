# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e0e90dcf3aa806461f052d24c48ab342"
SRC_URI[sha256sum] = "e8d143afd59e7221fbc5c52df424e22c802d4fc9fe1bef92d1daa9c218045eb1"
