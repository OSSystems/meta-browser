# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "465ad26125c223c4ae64c80b7b4f0be5"
SRC_URI[sha256sum] = "439fe04dc9a9987a7aa26e077e6baf182e4209f24e06cc134b637123529c62e0"
