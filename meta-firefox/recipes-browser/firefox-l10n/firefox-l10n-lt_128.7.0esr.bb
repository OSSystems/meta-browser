# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6397760aef3e53b1e2fce57cd7c817a1"
SRC_URI[sha256sum] = "cef1f13ac9438171ec0cf02ac8a80ac6af014b3815962f1e064232b804a7d2fe"
