# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5614b502bd5c4b5b55d9e84ba30c7771"
SRC_URI[sha256sum] = "e33d78085440ee370a6227eb26db4bb7cce7cfc3dcc17f22ad4dee1d47465056"
