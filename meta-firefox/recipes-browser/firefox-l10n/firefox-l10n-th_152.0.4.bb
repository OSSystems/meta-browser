# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "39a0093568c3686ed68db177aa5ba4db4d917bd1a2e479e79ea4f9ede239691c"
