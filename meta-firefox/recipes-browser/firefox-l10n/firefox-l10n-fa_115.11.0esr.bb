# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f9c7c92e45c6ffcce971a4ad5f7c1a06"
SRC_URI[sha256sum] = "a3d79416bd13539bf88053fe2c60053689efdbf7f4d6a65626cb7f9b4ba2e686"
