# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c10a64c727b4380c6a8ffd3a2273a97"
SRC_URI[sha256sum] = "3cf98e3b9950030048e9fa2886fb5bf10af0f0613d303a8e679dc2df9e01453f"
