# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e18ba1e33449a1e1e8ebfaf7e1f04baf"
SRC_URI[sha256sum] = "6189a9671a253a55fd2eb1ba4d0cc380aea9167174b110fde0158f824f19188a"
