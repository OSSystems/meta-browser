# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "39a08b16c4010c8b8ab25cbf97a0ad44"
SRC_URI[sha256sum] = "9e2ce7e7aab45db280a3431db0506f3aa8bdc8e41684359c297c29d1c2a0bc27"
