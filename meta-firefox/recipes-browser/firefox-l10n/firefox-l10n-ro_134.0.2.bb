# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "02f8dcbb2a4f6a49c97cfe2460a83c9c"
SRC_URI[sha256sum] = "84f93ac5077d80fc4d42ee0aa15fd9cf1cf820824d4baab3ea972af278abea85"
