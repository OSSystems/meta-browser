# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "726478bbd91c15b522bae082168002fb"
SRC_URI[sha256sum] = "8e9114fa8a961688d655e89cb3066ce18fb8ff3a401214cec516377678a4a303"
