# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eb50ccdf0f83570cc4557e6bde152f00"
SRC_URI[sha256sum] = "51f9abeb306b5831dbd104482ea241a7b7bfa07f4137a84400ed561e51a82e94"
