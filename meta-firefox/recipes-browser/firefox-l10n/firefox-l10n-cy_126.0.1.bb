# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6001d57843b4ceea39e2e667beb67df4"
SRC_URI[sha256sum] = "960b36240c952322fdee370b2b15cfd3188069910bf5665ad8d779c5e2cdff36"
