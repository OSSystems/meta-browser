# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "575e7ff2bce219d1637a55194e7b9af6"
SRC_URI[sha256sum] = "cb28389606139fe9d350aa36f115b8731cb376189a3c3b2e1e4ba62e2139b86d"
