# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ace9824ecbdb037efecd6faa5e2d8bf3"
SRC_URI[sha256sum] = "927270fb80bbc150be2db91c180cec36eac8affe952301a577ead1b64501a1bd"
