# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9f934aee086d329eb47311af25e402f8"
SRC_URI[sha256sum] = "0613db0686b017877f31f8147a2eae172d012271d832f1f362914bfcfdbba87f"
