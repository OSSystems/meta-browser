# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "752aa4f311fb8780b9892b46ccafaa70e646cf88306d95253650190a21b129a0"
