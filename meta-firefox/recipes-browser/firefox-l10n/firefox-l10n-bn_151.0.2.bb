# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "f15fbcab7a51e67c2a611d02e3f507af59a5727f8b1d869b8f16837286cb686f"
