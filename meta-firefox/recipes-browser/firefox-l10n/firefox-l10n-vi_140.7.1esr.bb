# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "600da884365935c82a4e36ef955b841e"
SRC_URI[sha256sum] = "0209e0c9030f15781ba2bf8f5b4f58fa6a81066c2bf2496852b89347298c30e7"
