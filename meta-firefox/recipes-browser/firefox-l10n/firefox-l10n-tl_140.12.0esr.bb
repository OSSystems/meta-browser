# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ee5b002c8118827626670e579d96be32641454ba2869d1c880c306ab6140cc7f"
