# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "26d07637e266d00c7cac78dfab56dd65"
SRC_URI[sha256sum] = "1b06122d6b91b65e1f4b73fe461c8494c00561d2d51e1fa44a999917280ca622"
