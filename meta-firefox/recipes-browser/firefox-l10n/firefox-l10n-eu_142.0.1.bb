# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "61e2599ebae5663d6b14d94fac20041e"
SRC_URI[sha256sum] = "02b993a72c0018f01b88fc911c11e570aeadb35d7a469281212c703dc9450f69"
