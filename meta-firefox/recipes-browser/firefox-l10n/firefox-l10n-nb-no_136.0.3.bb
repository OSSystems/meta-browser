# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b529209df1e82735956dda9c33e6c4a9"
SRC_URI[sha256sum] = "dbfcddf5011e764c568393191d66cfe7c0adfd599ad5b131d542deac3de71ba7"
