# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ba48ebdd2f5c3103354984055a0aa20"
SRC_URI[sha256sum] = "35e40719d1ea30c7effe972f6df6c226fabb205da2c03150b61c8da152a024ed"
