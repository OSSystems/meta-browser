# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "21d2b73ab3d37a48ec3a5c78586d078c"
SRC_URI[sha256sum] = "979c1fc11b5ef84ab0a820d7ff0742dc9d507978d433b18094a5d515fcb12151"
