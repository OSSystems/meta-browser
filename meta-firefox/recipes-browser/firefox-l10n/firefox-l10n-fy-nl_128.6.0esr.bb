# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "42e907ae82c3854a46c479937211be8f"
SRC_URI[sha256sum] = "d5013d4335c220c5159bca3902836949b8a51ac48d0690b038ab99915c0baf6e"
