# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d3f1e5540334b96d794d5c51fec55630"
SRC_URI[sha256sum] = "1b9449e775cfd0559ed195f6d67953dfd725ab0f641d5ed7046c98db861a12c3"
