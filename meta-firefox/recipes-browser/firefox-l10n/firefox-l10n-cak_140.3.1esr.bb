# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "67bd8062a2625bb995f5e664e59642c3"
SRC_URI[sha256sum] = "0086502ff3d303610498ca4122f411f63fa96aeffbf7148945afecf146031fc8"
