# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "5464030002f2da1562931659e90221f6107d3aeaf7044aefe1bb7e63aed37518"
