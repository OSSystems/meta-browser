# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "30d400fe8f191e88b6db9d907a8c9ed6"
SRC_URI[sha256sum] = "6720fceadfdbb71637a1fe769d815936ccca3bc7026cbf4dde70ae3d1085342b"
