# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "69db727f205a47c19a6119bea10d4080ad92514dedfacec2c9bc3a4c76efa376"
