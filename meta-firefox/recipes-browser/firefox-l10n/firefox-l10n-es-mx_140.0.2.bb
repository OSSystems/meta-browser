# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "117156d4379192dc2be3e97b35e393d9"
SRC_URI[sha256sum] = "3e68d8de67cd6c6c62a449cf8a580c509403d938d93cc87a98a4f52cfae2fed3"
