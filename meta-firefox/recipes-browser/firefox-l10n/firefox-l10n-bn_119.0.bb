# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a8f004b55e918164cab9b75f1a7cbc7f"
SRC_URI[sha256sum] = "33b0df71bcb6292bee3da6adbb2fb2524cc825709ce99109296c5ac68da127a5"
