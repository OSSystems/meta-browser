# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "be0177cb29443226576b9b9f24d21766"
SRC_URI[sha256sum] = "c403277326c54bc9faa2c1df2df498689627f9990cf63dfa4ac5a9ba75a264f2"
