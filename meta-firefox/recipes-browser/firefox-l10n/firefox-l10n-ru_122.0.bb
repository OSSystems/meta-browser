# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0024924525d10a701f372cac7dec731b"
SRC_URI[sha256sum] = "d9ba861d3fae6dd0fb3d8f376ca33588f5b3b89504a500a5a8611e1af47158ee"
