# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1297c7ec6728c2496a8a4b715acc29f6"
SRC_URI[sha256sum] = "a3c22d1fba0019912ab41df53433e6c9e7518ada9253433df3b106566d9efaea"
