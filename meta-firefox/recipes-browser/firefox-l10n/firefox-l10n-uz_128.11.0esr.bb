# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "14a0e65411443db16a58aed8c54e600d"
SRC_URI[sha256sum] = "d7885a44dad177ee0550e21d96287aadbaeb85482d05d13f5b1cb0f602db2087"
