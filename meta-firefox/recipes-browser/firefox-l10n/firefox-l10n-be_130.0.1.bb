# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1f574c6ca133d494bd8407dbc1951bdd"
SRC_URI[sha256sum] = "aafdc0e651e35d168d4fdca30dc80a11783baf293bd238bc80f0d9ee74413b56"
