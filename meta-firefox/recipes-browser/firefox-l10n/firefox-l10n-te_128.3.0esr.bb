# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bc8907f93fbe80d77a1dc57be5db1e27"
SRC_URI[sha256sum] = "b892c3fce35039bcd1d9b9d2de79ecb1c4db73823b975bfa1c0a2d359303a038"
