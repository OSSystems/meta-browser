# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eb34f90eefb78eebcee3c1d3a505124e"
SRC_URI[sha256sum] = "a7b2f57a2060370d2a504110cdbeaa7c12ecc6a5dd51d62df3ed1d6575164233"
