# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "63fe7b31fda361a27934f67772913b32"
SRC_URI[sha256sum] = "6f796cc2d6f1b9ee003aea0c9c2324b4a99666bdb03aa09a6560d53b81795e50"
