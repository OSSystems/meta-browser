# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dc0feef1218222cdb754fbb6ebfdebea"
SRC_URI[sha256sum] = "cbd88b8085dc246ec6cea3f7792946e8b627ded34b61809da6bf9e3d0b7e4968"
