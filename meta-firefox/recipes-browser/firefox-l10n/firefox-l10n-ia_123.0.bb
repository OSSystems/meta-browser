# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9371ffe04b0e1e57e5fe93b791bb5a7a"
SRC_URI[sha256sum] = "f58d664a5fc2435b8e673b0c862e4ba61027b31123bcd3e29455ee91c28dfa95"
