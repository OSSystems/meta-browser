# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5fc8efef8f9ce6780b373061e8002cf4"
SRC_URI[sha256sum] = "fecce19a9f9e1d9c1fbb5432482622254f0fc67ceee0ea0730eab94070014681"
