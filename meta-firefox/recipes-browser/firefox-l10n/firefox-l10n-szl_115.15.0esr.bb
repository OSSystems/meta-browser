# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "29b39bc4171d8db694cfb6c497f920f8"
SRC_URI[sha256sum] = "56939a7973fd176bbec109cfe5c3fe8720a2dd96242bdcb1511bfdce8dceeb56"
