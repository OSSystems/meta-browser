# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "658f4624d133de8d053fca533daf6298b61181204ab88ed8e38d4449632e4430"
