# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "52963e225092bdd2cca710198227042a"
SRC_URI[sha256sum] = "b8d32edbfeb21a48eb9d46b02cdf6d0db0f0d048e1c0f719c007aed25727c256"
