# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5fe075d2f4b68c399bfaf5b82eee0a91"
SRC_URI[sha256sum] = "d9916d43ab4b096f7912a124935b0a7827ae53f9ccd49b3156af2fa6512d4e73"
