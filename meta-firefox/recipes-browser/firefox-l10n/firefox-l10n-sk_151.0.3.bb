# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "caacbb1cd992060ec0df822e8a5a5b90e368f54bf63283d5ecdf0fdd1d825332"
