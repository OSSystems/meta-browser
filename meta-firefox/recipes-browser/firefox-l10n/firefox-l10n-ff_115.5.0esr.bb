# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "359c2e74cb791e7af6da2bef727d6315"
SRC_URI[sha256sum] = "7d278040fa1f74ad5391d50b35c5f5056433623baf70da248a698b7ea88e3308"
