# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f0cb9b5f003fe6bab937f55b198eab4d"
SRC_URI[sha256sum] = "b1153199ebf8e9367538b8389c728555701b9c1f4952eb885534f73e23f8393e"
