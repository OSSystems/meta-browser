# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fbdd620f63d72aeaebae8d07b5543ec4"
SRC_URI[sha256sum] = "e6b324bb26f013932154f80f017150a39c3cd9e0bdf4c4e0fa8bd27a4afd0b22"
