# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b4e255bf90b6da63e373420bfa28e0cf"
SRC_URI[sha256sum] = "b1f22d1634febda1fd3e89ff5eb66f5a8b3b1c8a1afad136ee320c33f734ae00"
