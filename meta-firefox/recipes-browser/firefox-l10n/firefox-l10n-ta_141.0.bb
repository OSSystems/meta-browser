# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3c13595b1cc9897eea6c376b9fe35556"
SRC_URI[sha256sum] = "d8417c36e0539a0752ae16dd968628bd05879c5ad43372821c22078f7ae7df5f"
