# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fca52e507ad898646aec08f5c0c37384"
SRC_URI[sha256sum] = "12893763fa7570892ff63ac0187aefb179aa703c385a1229640d6ad798c5e9dc"
