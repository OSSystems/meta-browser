# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "69f753fc4324ec13a48d988f99f99e9f"
SRC_URI[sha256sum] = "c6729755673e3b465c852d4e0ca57b156902ffe1d3afd97a49833f5875984a59"
