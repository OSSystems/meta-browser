# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9f8c13ed455567a1c1c02ad5ea8c5aa2"
SRC_URI[sha256sum] = "26a715ce7f68fc68322a98fffce71a3ac6fe08e891b08589ebab63397313ad71"
