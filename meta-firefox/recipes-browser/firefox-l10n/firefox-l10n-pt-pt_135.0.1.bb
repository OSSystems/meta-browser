# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "08273db27cec8fd07dc7101c049f6741"
SRC_URI[sha256sum] = "4818148523b2f26eda088fa724440b75be5b9644a97c47677a3e57fcccdc513e"
