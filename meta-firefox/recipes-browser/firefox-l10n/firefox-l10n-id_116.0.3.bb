# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "843040e529baaeb56ee4ea8385b0f822"
SRC_URI[sha256sum] = "4895e1d0ecacb8096911efdf1a0f6cb1ff0f1ebb209d09cc6018f72575228dc4"
