# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "9432447b3117eb15326f47da57ad1956d33d2396d0d310fcef5129ffb6186bac"
