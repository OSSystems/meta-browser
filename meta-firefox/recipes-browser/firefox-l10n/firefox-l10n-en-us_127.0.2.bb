# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7c3fc08d6edf541d087206249810bcea"
SRC_URI[sha256sum] = "4c9e2f070f38bd6cc8a9f7d3cb61e01763738742f9b64add2a70aa3986c55110"
