# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0d862ce0bdf53230d58b683457a8bc40"
SRC_URI[sha256sum] = "629fe41c1ff33d54e4d04dbff745abc56036f1489061ba0bcca77005753e52ac"
