# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4fba2af709d5cb417b330dc93e4f1fa6"
SRC_URI[sha256sum] = "2778cf9fb0314ab798ec2c025a2f81190cf31317efc47cf520a1758d56a896a9"
