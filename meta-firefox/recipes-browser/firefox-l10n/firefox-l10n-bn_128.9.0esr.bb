# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "04653fd8c2f5eec2b5f17d2efaebbcbe"
SRC_URI[sha256sum] = "b0dcacd2635f3ddcac5c05c55f55cfb2f840e69a32e89b9a7c4c4bcc9d4eace2"
