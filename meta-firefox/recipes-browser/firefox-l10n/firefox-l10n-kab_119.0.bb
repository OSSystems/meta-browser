# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ca465374bb2b24e8fd8271ddcd4cbe38"
SRC_URI[sha256sum] = "b7a1533f7517af97fbd375a1bfe888b4247ab05fdbd8e96d2c24668150f3aade"
