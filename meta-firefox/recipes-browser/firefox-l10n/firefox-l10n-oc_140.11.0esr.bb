# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e065adea89a8ad17a74a8d8d1f9933e5c9b93e6318edd53ddfb6a2d36a5c3dd0"
