# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "b50b45ad774ffc23d9a3e88041193b6abb064f526de05606b859180e1b57f66f"
