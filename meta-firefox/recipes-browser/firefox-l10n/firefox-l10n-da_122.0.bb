# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "97f776fb2e82403e2d82d769e6149001"
SRC_URI[sha256sum] = "c3d8e612a21ee5d350b70882f7ed45a03440f5c0efef3b351912f0230e8cd7bb"
