# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "525b37a408a044769a8bf2229c6f5287"
SRC_URI[sha256sum] = "2cdfca38d918adccdf259f30ecb062f9af448a282427be6f59317a8f51a42ac4"
