# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0e70be1cee36cd51cedfc8eb0fdfbe9c"
SRC_URI[sha256sum] = "db62dcdc4b9a468973e354066b4b1a50f453670c0cb39440911b3ba01bbcdefb"
