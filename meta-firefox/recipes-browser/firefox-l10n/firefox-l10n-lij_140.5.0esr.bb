# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b05d859bdd5eb27861c4f868f2e415fc"
SRC_URI[sha256sum] = "b45e4554a4d76e7a56e1d2d0500384c608972aa81a62f7cad5cecb19fea11b61"
