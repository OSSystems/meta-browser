# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3caf625b1b8d48b4ab9984665ae8ccf7"
SRC_URI[sha256sum] = "b30abd5efd134185c6d47f85bce558801b9c96a432e11a8c55b757eb1e8f28f3"
