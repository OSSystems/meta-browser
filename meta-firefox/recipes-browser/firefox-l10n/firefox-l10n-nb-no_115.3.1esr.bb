# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "de742e5d0b2e9846b8c64772711ade1d"
SRC_URI[sha256sum] = "4010a5aaaad21753d9a5681de74f2fac91f0d8772c93d66019e8971b19059d19"
