# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f5bf1d62ff9af4b659ddb1f9756d1ebe"
SRC_URI[sha256sum] = "488f482e52404613f3f68abdc5ae9d286abda118090833d05e8f9638b85cf727"
