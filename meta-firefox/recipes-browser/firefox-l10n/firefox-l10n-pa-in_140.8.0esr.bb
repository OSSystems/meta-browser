# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cf893cd12e86876e9c6fc9f8500c49d3"
SRC_URI[sha256sum] = "94f08fc028a35b40ec65fbc3061f5a0d044a9e803459409e498f467a00234569"
