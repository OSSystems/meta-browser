# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7120d057d83d1e3360681bcb270bdfeafff9c88c60ea4ae0c1638551ea09d0b0"
