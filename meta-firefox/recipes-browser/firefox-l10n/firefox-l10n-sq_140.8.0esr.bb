# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d0c8a4c2e3eb29fe3380fa5212602e14"
SRC_URI[sha256sum] = "aa5a2e73210405cf9251334e77eea78cc9cacdaa69bdf0a5ac9938df12f159c5"
