# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "99d4de7bd29e9539489a7034ded0f168"
SRC_URI[sha256sum] = "0f214dd698919856d685b8b85ddbf8554bb061f8e1d287c460b2da606f02e093"
