# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "345a0f9c894a1eb85099978159957bde"
SRC_URI[sha256sum] = "1ef9aead340314401dc11514befcc88474e0e4ad353cf827e08cf1c6a1a9efbf"
