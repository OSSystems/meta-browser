# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6d157849372746f927f079c87ce4d358"
SRC_URI[sha256sum] = "1d3350ba1a42545eebf9c645d9653d3f5ecb2ce314620b8343815b791f0bf44d"
