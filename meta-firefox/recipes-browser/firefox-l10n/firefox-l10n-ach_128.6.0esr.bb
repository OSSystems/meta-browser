# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c15523aa14f81df5b0360e7b2d1c8560"
SRC_URI[sha256sum] = "01b47e0b217ac562aa9fd7542a211023d7acffcbc2dae464ecb2e26ac3248ee4"
