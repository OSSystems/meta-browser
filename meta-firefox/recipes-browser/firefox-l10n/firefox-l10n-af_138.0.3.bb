# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4e15428c90393574dd0da1474798c953"
SRC_URI[sha256sum] = "42b0e4b79194ebd4253e022032dd819ce446f13848bcc40372e0509fbac64e48"
