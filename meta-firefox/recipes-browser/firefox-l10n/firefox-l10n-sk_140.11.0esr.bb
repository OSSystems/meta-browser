# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "8742cd2693497a76b41fde212f2e8631ab6b64fcbde623f9b058be0cb55795e1"
