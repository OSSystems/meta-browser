# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dd835c921c1297d58383cbb00e7248bc"
SRC_URI[sha256sum] = "55f8ed784dfbc0cd6d0db4f3dfd3c3e806c83ea65ad8055db369fc579b286cdb"
