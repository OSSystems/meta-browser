# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cce24b546c39c06ba97f5e3e6bbe93d7"
SRC_URI[sha256sum] = "c28352cd596e874b06d4cca02bbc1bba41f22ec6ff1171194a5376659b10c1fc"
