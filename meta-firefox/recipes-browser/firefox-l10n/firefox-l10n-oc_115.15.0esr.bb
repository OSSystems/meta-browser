# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "583f3bca045f3cd68d53a91b11b602e9"
SRC_URI[sha256sum] = "da5e9fb8d7adc1ddb008662cb028750941a67abed430710d22e19648ee523762"
