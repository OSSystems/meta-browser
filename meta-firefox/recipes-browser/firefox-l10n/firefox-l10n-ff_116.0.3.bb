# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9aa07333c3ee0cdc9549fff6d3cc5ef5"
SRC_URI[sha256sum] = "6d0c2d8bf97614e68ca3936346bbbce01c1ca9484c4ddf0c812d7c07a7fd07c4"
