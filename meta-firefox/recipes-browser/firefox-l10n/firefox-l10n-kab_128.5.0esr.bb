# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "041d4ca6c7648d082ffa784142c9bb4f"
SRC_URI[sha256sum] = "2808b7241779fb5cb846df3658108ed23151052a92550be9ff893c53de87a156"
