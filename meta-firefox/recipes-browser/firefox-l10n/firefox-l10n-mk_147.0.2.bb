# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c8dd26d1d7f4667f0ab6a9be2d109a90"
SRC_URI[sha256sum] = "9eeb71c028b3cd399f4043acac8eec12c121191d2bd206ddddf702a8638421c9"
