# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "312ffefa9f80165f906e6bfe4b4b8dc3"
SRC_URI[sha256sum] = "555d181267d55641feacd69dad7f5daac92ba454a9032b6f882c143cd73a5938"
