# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "6af77d3c73b69680ee579e18b3dbfe8da118eded1b7c53b91d50790e4a2c4463"
