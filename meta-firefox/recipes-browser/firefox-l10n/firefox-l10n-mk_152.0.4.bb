# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ec0475cbbf5c103d82b8a2788a91fe2eb4d0220714828103472a3d317db70f6e"
