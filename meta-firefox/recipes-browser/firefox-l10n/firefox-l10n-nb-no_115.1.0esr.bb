# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "93580fc26f58aa8c6933c34ce2724477"
SRC_URI[sha256sum] = "a765603dd2361979c492f364a03fd06fded7cdcc33995874e10a46ad43c9e0c6"
