# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "59c3bd0d340cdee572bf05c20409a3d9"
SRC_URI[sha256sum] = "d5999da7a4d462a087d728d942d4ffcbfbf5243bf5540d1e02b4a1f682fb311d"
