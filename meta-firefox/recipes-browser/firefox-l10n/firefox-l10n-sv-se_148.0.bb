# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "24b0ed2c6c279a4aca1aa87d5437d2a4"
SRC_URI[sha256sum] = "c6e8000607d47c6a4344f16d7f34c182b05bd5271508d4495de43cb028e3ce16"
