# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8419b0d8390bc2d0027d4751cb2c55b7"
SRC_URI[sha256sum] = "24c4423bd60bbdc5e79fe8a0abc215d299b5568a4a5df3232fc4918b86a0b339"
