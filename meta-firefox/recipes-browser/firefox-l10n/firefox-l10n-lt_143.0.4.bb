# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b12533cd4f460730973f8d01d98701a7"
SRC_URI[sha256sum] = "450720d0635be5d39653a746719e462dbca7d69a43975ebd6e217e5c8a188fb6"
