# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b9efe4e5c7d9527de2471d5baac2bebb"
SRC_URI[sha256sum] = "99a72e2b4aff6ef6248d58650b825a0688f399ed4c29d4b38c432f46bcd33a98"
