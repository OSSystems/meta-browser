# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1189a1b44cba80079364ff7c02936841"
SRC_URI[sha256sum] = "181317130cee60e074fc393010ac358598a9c9147afc9a5d3412bd44eba5147d"
