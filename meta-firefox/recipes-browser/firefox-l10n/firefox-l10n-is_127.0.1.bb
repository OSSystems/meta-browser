# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fe579af86660bcb5bf5d30db884b61a8"
SRC_URI[sha256sum] = "ed4c2607221a96c7ee59195da6c24b1aeb6a9a2606ce52b18a729537d93a23bd"
