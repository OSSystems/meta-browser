# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "56b3dd61a5e1b5eb0a6dfdf6a6cb61de"
SRC_URI[sha256sum] = "6420bfe020d7a0b97dc781672a9d9f0add1c5904843d8ffe8669d20857e1e778"
