# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "73cc0f30268eca991c29feb7c9f7c531"
SRC_URI[sha256sum] = "bc07f7e75d8a75a902c25f692033e0f4ab360d435499bb7fb39cbc4abfdaa608"
