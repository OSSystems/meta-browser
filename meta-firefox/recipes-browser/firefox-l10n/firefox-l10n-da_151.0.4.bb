# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "78afd7d9247bc604b0170ecfe3bf605873e1aee03dcacd8b2570318ec1bc4b94"
