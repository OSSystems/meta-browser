# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "52dea49b5fb2ff88920d010e34380319"
SRC_URI[sha256sum] = "e1e7ae95918ef7616bec601cdd60024cf8ce41878ca4261c969efc811663d758"
