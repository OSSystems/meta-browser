# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0fea3438ab6058df64ba34a59627d19d"
SRC_URI[sha256sum] = "4198c0c42bea68d672acf103a476f85b249d864250e87995bad1112101f8f82f"
