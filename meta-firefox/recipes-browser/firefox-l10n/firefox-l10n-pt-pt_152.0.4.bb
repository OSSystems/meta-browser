# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "72a2dafcbc343c3d3a438efea92e55e51e877232220aa58082b0673a08ebe17b"
