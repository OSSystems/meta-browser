# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4e4515d3f0f6f29df9d1b6286a7ea885"
SRC_URI[sha256sum] = "5c9b5e85d7cbcd463394f10f0c7d0f2356a38a10e48619dcf97089db6cda79a9"
