# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "511a3865817fcf8e8c6193b0a6ccf062"
SRC_URI[sha256sum] = "101b697f71c6852a32b172fd58a0fa447a73c75099bfd61a32d1c5a6d6703086"
