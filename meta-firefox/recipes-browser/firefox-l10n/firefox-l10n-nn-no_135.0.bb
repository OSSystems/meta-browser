# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7653977238b3459b4fa8433dc86b1bd3"
SRC_URI[sha256sum] = "27aacaaf0550a2d2fd9f200b1517c03e043ce1af75438ece0e9cc4a5c6894eed"
