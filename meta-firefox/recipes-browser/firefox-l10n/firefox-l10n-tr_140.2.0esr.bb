# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7cb83a65e7c21e5e38f234d2ea203bb9"
SRC_URI[sha256sum] = "ee1b064d5ba44e205c6446aaf2f644555d28f0bbc25c7fddcf002489489e8f5f"
