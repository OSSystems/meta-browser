# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cfd91ba848de722cc1da1fb387818483"
SRC_URI[sha256sum] = "f65872c2d89d7cb1270fd2de6bd22dc498b2db8d3ecfe4e710aa0e566dde0290"
