# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7d21146505101ff367709b58ddd06dc5"
SRC_URI[sha256sum] = "0169dd004d10f836bc4b30e0f42d01764ad58237009eedbdf1aac1435a51ddc3"
