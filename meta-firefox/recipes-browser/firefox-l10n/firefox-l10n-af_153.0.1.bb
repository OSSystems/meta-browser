# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "a30ba2c491e666f1a96b6c359f63ae3d98c6f793f8a081eeee1febbe574d3a69"
