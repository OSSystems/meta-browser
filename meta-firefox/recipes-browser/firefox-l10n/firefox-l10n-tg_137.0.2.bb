# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "76fcc142672162c47d836df57bca0d50"
SRC_URI[sha256sum] = "db1e01266d45d2e36bf50e64d4f81871de9a68369534c4139b1e25658e921750"
