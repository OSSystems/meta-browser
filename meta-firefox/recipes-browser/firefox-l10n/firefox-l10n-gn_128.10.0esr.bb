# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8b6ef1dfea3bd50991a447decf859b87"
SRC_URI[sha256sum] = "2cbd17f5025c5cea8d17cc46ec82cedebdc347083e62af84560ebae56b96cfa6"
