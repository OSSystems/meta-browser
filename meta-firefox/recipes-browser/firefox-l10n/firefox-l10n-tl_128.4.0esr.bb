# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ce72e7922e43ba7853636d99a2b3c8da"
SRC_URI[sha256sum] = "d599c26cad6f76bec5d6ed25a3e957eb60904ed27e19a6349a90c41b1b29578f"
