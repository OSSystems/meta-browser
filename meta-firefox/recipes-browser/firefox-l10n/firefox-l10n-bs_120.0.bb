# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b2040178d24a7095339237d3d34e572e"
SRC_URI[sha256sum] = "25a1ce5e971aee958a6b8af1584a6a8d96159dee78bf1e34d1c4e7bcc268a9e7"
