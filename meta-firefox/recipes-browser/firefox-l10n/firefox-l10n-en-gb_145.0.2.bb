# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3f8125afc4c454c369c45f5375b18bc6"
SRC_URI[sha256sum] = "893b0e26659b5350cffb98e8aa0541e4f8dc298bb71fbd52210602c9ac87cc84"
