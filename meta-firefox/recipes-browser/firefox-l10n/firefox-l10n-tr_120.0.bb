# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "354c5ebd0c3e6338788e119680df915f"
SRC_URI[sha256sum] = "5652cc55a01fae4cb2e4e3bbf8353eb2120ab05a8ac3cd3e4ce1ef1bb4a27ed7"
