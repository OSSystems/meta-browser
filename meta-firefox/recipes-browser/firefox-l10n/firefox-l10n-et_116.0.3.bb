# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fe5afabdb7b2c2eceecf1803000dfb03"
SRC_URI[sha256sum] = "a9b5927f195ec48821364a8ec32ff0778baa8304371ef339fad74faa73681d7e"
