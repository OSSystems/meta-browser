# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d4f37823ce88653e3ee52aeb1b066fb9"
SRC_URI[sha256sum] = "6e7259eaa52e42e0bcfc57cf8018d63bcb953a784817de631427c45b6b398176"
