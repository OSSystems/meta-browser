# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "430273447877bc96da175fcc54f284cd"
SRC_URI[sha256sum] = "900a3435a162ec5146ae1fa3f562f47f80a0db5f505325c0bbc30ead72779cd9"
