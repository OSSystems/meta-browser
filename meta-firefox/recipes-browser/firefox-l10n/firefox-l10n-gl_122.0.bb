# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "66474e1b999cd2b368993f9f18345fc5"
SRC_URI[sha256sum] = "886261cff47f2ae729dfdd0faef1fb954ee1dba6ba2b40b90fbc852a37fd75c6"
