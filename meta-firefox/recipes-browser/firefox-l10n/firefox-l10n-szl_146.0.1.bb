# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ff6f5d46efc101ae3e78167993995c91"
SRC_URI[sha256sum] = "a8839870a4a9f57dcd3c402194e1f808a49c0b22ce04bd4ee6d02d991f155358"
