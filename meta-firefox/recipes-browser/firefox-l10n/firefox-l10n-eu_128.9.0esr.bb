# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d2b74d20eee3833a98b16a1e74de6265"
SRC_URI[sha256sum] = "885b3c5d4715e23991c070213418ad35ff779c93f7c400ed6088a6d06eacfef0"
