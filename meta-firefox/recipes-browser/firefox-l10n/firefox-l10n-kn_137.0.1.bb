# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "779b377f8f5f4b76c719068f9cdb1f43"
SRC_URI[sha256sum] = "075ea43e2fd07e17ae8d294345e333d91ca2dbeb13c51f605aa4b8ed52b1222a"
