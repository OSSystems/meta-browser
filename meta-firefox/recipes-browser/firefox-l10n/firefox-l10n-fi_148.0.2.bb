# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "edcd8f6c95ec56c1c49956274c27d6db"
SRC_URI[sha256sum] = "1e135530d84e6eb422f882961cb8aa16ce405be2308a9e7f845e808686726894"
