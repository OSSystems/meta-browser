# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d52dda7f06b47ea445dc7346e633a943"
SRC_URI[sha256sum] = "0bf57c6308cf80807d142b74c2081afe37580a8673e3f83ef494b817981e6880"
