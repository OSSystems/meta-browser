# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "b579e76320e3446854a82a0bd916c01f668a6dfa2d3591b1879cd2d810e8963b"
