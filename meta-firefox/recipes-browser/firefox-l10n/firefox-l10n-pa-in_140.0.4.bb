# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e93983239f62c9a4234e4a16c3216d02"
SRC_URI[sha256sum] = "b938cd0f538b432655ba4e19172c7fac336abc2a7ff5e3e4c6c98a94bc042372"
