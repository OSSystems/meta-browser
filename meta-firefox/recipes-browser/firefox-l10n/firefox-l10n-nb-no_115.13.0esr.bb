# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6d15cb0afbc99007d0ef12c41adefa98"
SRC_URI[sha256sum] = "043746dcdcc33722ec54f24bd2851666e91368d243e74641ea3698d857894307"
