# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7c0794baddfaac3d72882c05898b6213"
SRC_URI[sha256sum] = "c20f0eaea7108e9a8e1ab89da1dff72a8ace9ba9c185d7868822c618a52964b3"
