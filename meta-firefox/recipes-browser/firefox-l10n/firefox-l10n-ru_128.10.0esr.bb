# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "548dcb33952c5a05516d438c7b06f0a7"
SRC_URI[sha256sum] = "b33a395c864979cfc97a2887e20ca44abf9a0ffa39ce85f543d59cd873f57f0b"
