# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "093005e5cc8980a15c644b62085768f0"
SRC_URI[sha256sum] = "3d646c2274082dfc337462004aa3573ca919f3ce77d4aa9bdec466adeba24151"
