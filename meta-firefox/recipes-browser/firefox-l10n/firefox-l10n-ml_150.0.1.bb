# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7abbad3fb4df4af4d0ff8ea11eb2dbac87230ddf80d40a92710e256dfc667a08"
