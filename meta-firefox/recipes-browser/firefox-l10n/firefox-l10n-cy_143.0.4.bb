# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1c3c5edf8549effcea16ee4eccff9a8f"
SRC_URI[sha256sum] = "0228de0d031880aaa484e469a0b283af9dcf65a30ce38eeda8ca4eb0471f9aec"
