# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6c59e6291cb6d1c8a6d7a9fd2d2f16e7"
SRC_URI[sha256sum] = "ffbfd3c9ad9e65f4df7a73bb75fa0933fec1ede4c23f25a7cc04a6049f2b49d4"
