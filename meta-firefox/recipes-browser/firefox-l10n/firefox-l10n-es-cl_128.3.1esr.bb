# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "639cf690d4f0ad068f4990d6d6c17b61"
SRC_URI[sha256sum] = "3ec8f50d361b4dfd971c05741f895a1e628ca79cf16c49de4b17a9cb4c816082"
