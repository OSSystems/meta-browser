# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "15d25b6f813fc54db4218b88c8ac555a117c43e6c5d3d833070dcc104934166b"
