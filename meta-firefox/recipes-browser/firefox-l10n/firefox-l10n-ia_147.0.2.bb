# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ad7570cb9dc33357d8467d3f06bc53b1"
SRC_URI[sha256sum] = "b81df4c598d06563010dd45c21afd6f1bceba340eb4abdff4127ce50fa350fa5"
