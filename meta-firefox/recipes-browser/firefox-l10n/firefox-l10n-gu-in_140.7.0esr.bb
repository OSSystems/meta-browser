# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1e6c8f71f3e1058f0378fac38608c548"
SRC_URI[sha256sum] = "c2081d020372c39a3f14a93db163f2ff0ca7ee602d5d1e10da0c1183a3423494"
