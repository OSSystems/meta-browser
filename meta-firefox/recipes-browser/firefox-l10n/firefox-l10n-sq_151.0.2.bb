# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "4882982bc1f06346655a18afc8f90b4e07b05d1c2597e7a71273fecea114f742"
