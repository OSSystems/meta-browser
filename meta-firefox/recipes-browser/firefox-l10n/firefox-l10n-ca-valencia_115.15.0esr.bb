# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a596246113fd91eed405e7c96c5f2aea"
SRC_URI[sha256sum] = "9048e963f305be19903a539f222beb711c67f10d1748914e6f7f37085b1dd81a"
