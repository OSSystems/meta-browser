# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4ccda6113ed8d0d50cf8ae1b1b0e92a3"
SRC_URI[sha256sum] = "7b6a84e1894fe0f89a627718de48d691877e72b1785cb828e9b25b526fb91db7"
