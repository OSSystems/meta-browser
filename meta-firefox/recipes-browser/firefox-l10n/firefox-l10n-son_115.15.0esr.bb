# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ac52e420d3b987e71a77a35bd2f1c35b"
SRC_URI[sha256sum] = "1ef8ac03c3dcbff22f6d3d4e5300cd2e4520a062bbe3732607209984250f5be4"
