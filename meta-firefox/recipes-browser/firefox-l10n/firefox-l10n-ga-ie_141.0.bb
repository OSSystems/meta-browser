# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fbf5e68c3511fb232ecf34b0cf962d2e"
SRC_URI[sha256sum] = "31cc62d18aff00fa5e9da1cae993947e9fc61774a8f3b67afad8df1d404c1c7a"
