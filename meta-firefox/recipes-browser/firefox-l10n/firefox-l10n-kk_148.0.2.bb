# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "22ca0ec17bb7cc0c01b914ef72d98acd"
SRC_URI[sha256sum] = "6c3353b6be155215b9a72b894bc6ba6f68769f4647600e00152e88200bf34701"
