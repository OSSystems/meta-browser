# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "363cda7979516f6d830eced7955768c6"
SRC_URI[sha256sum] = "920bd4b9d90722324801977876ca2eb04efd84cfd36c7f34bc9da32c1bc8a4cc"
