# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ae30fe6d1d1fcfd34764c0d14dad2fe0"
SRC_URI[sha256sum] = "dd05454e2e88f62a2ec8063bf4addad7aee5905af5fdd143edefe6c0cbcf8309"
