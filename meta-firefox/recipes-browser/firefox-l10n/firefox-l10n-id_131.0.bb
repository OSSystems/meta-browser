# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a27af5ce61d345878f34b632ce823f33"
SRC_URI[sha256sum] = "62280249db944aa375342b6e6728a40ee264bf472eb6a78bb5e8880666f6bb31"
