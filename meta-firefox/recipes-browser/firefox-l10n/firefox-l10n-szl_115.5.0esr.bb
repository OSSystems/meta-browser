# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a3737b05bf5712dca629aff9302e81a8"
SRC_URI[sha256sum] = "9d8bdd3a2077309baebdec715887d29bfdad2e0fde1fed8165180af24f1f8933"
