# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "43260b36fab36d02531f7a340dc0634fe86f2ad18b3b654dcf6f9f94a9e8426d"
