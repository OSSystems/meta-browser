# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f562813cb90aa5d271e1cc2db633cb01"
SRC_URI[sha256sum] = "5979859fb98b00f532d104c645b556c1ed64fdbcaf221bafc75a447203c7896f"
