# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4fc8f83d547a72510268715736a78d9b"
SRC_URI[sha256sum] = "48db6af84fa31e27a1121bd241219b697cf83ea0e32495f228018c0801ddb178"
