# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "96e858cc7cda653d8fe99079e1798cd7"
SRC_URI[sha256sum] = "a11e7ae5b195e962d81a3c4d2605a54fbc03b1ed0b1b8806076886756e2ffbca"
