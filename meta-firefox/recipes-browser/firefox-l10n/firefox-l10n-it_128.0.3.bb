# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "40c2c46fa404a76de3d4a84a4bc46c53"
SRC_URI[sha256sum] = "ad36c283931b6479eadf3732f6aa07e2f7519485c5c3461d0be809664b5e5d59"
