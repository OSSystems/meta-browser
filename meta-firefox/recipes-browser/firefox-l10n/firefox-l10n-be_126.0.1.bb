# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ffd8ede80b752bd86e2ca9b3a9e12f1c"
SRC_URI[sha256sum] = "d9b503ebbc9f64203259bc267d52853a8a1d39ace42e0cfc4a1761f1b9df8303"
