# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4132f987cd1fac02d3d80709e04e9ca8"
SRC_URI[sha256sum] = "3dff049bf7ad8fd30be989255b0daacfc7089c510020d9d546a15f9dd1be5ca1"
