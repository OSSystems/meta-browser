# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b23fb29ba62770947d3edfdf9af4372c"
SRC_URI[sha256sum] = "0421d9d7f24632938be8997d92bcdbdd85d3e11c6aa7841392d2be0a76631260"
