# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fc2404dd2b465f2c944e6f4162f2eae4"
SRC_URI[sha256sum] = "545e4eefb2b201eb860355ec0dfc015290bd6d963e74e93e7c918c5a3b9f0916"
