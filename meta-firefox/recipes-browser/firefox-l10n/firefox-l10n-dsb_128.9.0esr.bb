# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "51364d7bf5f978a2b7eed27c13196e6a"
SRC_URI[sha256sum] = "dd39fc0944c4f8bd6d8fd513ba5fb671ced04f9609b34a9921354326ebb678fc"
