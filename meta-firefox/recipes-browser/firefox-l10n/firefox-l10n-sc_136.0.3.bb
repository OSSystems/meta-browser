# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "707d114dd4f3ef4adfb16e1746268cea"
SRC_URI[sha256sum] = "fb8b8b1a30c52b4c7842e6204dfe42793ad30a20f1cc077a34178beefee3caeb"
