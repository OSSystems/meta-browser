# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8f4e7f376dfb7b306ae78b1ac55fd3a9"
SRC_URI[sha256sum] = "1f891d3cd5a9a3dc34f501eb3d95c6ec268c828a00ecd53f4715fa124f6ae896"
