# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b9a1b863ef77dbaa54bbc117e39d3ea3"
SRC_URI[sha256sum] = "77fa92ba57571c3beab1025f00ea4a0af3b6aabd67b10033f2bf076a2e92816b"
