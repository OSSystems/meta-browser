# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7ff782d140e7a57df9dc58cbd9eb00efb65f586a942ce5ed79142500404ce563"
