# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d71f59006cda978b9086828d51b1d388"
SRC_URI[sha256sum] = "f744e348639f29cf35365ce90d9526b7a7f44d64e8f618baebb222b372970a75"
