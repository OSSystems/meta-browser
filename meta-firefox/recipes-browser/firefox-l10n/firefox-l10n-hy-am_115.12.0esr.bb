# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a55480622bb00178cccf9320f5e18f05"
SRC_URI[sha256sum] = "0f5ac701c751a1d535bc7548e0f41d8066d078c6989d3098d4721593ac4d40e0"
