# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "63720f227dfb26396e2f4319e5522006"
SRC_URI[sha256sum] = "5c9b5b23a979647ac912f532419405777488d64efea64137a3f22a28a26b2f53"
