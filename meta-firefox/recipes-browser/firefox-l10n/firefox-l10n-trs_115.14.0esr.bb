# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "92513661878f052d487927aba5b4da20"
SRC_URI[sha256sum] = "fb36be4d4441c84f6393e097d722eb7b3282e71d15ff4e7a111fd10e30c2a56d"
