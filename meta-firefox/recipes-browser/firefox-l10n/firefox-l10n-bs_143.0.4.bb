# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b6cb02d912427a896ef2b45960adb8c0"
SRC_URI[sha256sum] = "99d5f7489f17731b4203772f5a8ab268f2fb17f20d74e89f1092c94bfa9c992b"
