# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c91163522c13df0272a286a876418a92"
SRC_URI[sha256sum] = "22b2e7383524e432440f1c36bf1647a08187ba43d82ee625835428f236ff790c"
