# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5d20e679d97dbc0892e2eda33c633021"
SRC_URI[sha256sum] = "0687314f13a73de1c10bfc48c549648b41a44e668f346cf155a4eec1e039f915"
