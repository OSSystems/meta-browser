# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "307cc8aec9c655375349637f85815098"
SRC_URI[sha256sum] = "f44b4998e4e8f9f68b22361ba0e2e285df0c52f4bfbc9890a655e9ce55ec9bef"
