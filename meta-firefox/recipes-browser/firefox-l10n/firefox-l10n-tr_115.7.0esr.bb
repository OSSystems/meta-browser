# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e1c5d442ef8226e25ff906fc19289a74"
SRC_URI[sha256sum] = "8e6a0206c36125efff92db8fa197178d58448adf0d1272a5c6d70732fef5042b"
