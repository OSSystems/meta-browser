# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1007cb9086c3ff041adf90e40b55e02f"
SRC_URI[sha256sum] = "e999cf149953cd0dacf6cf37496afed7548e5a323b32984c648e4ae69af06636"
