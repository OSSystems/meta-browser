# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9c60480d1d325d9de5dc34d2421bd2e7"
SRC_URI[sha256sum] = "b766206ff6adc4935a30d4b26175acfd06dcdcb6ac02554048ca949b3f2301c3"
