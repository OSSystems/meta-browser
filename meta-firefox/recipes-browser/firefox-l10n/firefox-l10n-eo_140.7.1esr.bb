# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "430567553ee49abbe5b8532e47251917"
SRC_URI[sha256sum] = "a46b0a0489887310eba7ee882ad60a930bbe97fb74535f454f90b650ecc64ddb"
