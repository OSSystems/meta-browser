# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "727f43e580a82e96e48349db4857b51c"
SRC_URI[sha256sum] = "5d0fd722143e80589ee55ed2eba8f96d1b344a3c4ee739b2cf76195803e80686"
