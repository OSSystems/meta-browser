# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "163875f1b97093ecf7d219073909e1bc"
SRC_URI[sha256sum] = "cea8d3dfbbb7e9bc634e3e70b98e325a4a388f0121e05777f4022c7c35ed6f62"
