# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "84afcffe702bb29db9c8cf0e9dc399bb"
SRC_URI[sha256sum] = "c1c7e77bce0ec29ba5f8de4e35801df303ced65d9c1e74cbbc82c59563b5ad82"
