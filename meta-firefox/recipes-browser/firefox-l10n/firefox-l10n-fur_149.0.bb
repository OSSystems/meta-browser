# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bdc86fff79e11b7776d7a4b68b9b0de2"
SRC_URI[sha256sum] = "ad3804bbe6c6f1004319d61a5f53db9108c6714841b3eee855ca2119e21bcc45"
