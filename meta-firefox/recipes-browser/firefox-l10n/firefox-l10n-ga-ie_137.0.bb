# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "382b33e332914a63b1c3e54e042bdf26"
SRC_URI[sha256sum] = "b5bd0a725c1715b2f471df38e1b99e520a055d97f399162b7c86b56e9abdc89b"
