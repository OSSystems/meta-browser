# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c84c363c8c84c598a6bb293d3742d47d"
SRC_URI[sha256sum] = "b07c992bfb87dc4154d8dae21af2b303633a49ab025dd1aa08a564977b55ddd4"
