# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "48a62b48804045714d631654eb5a7bd3"
SRC_URI[sha256sum] = "226e4536445d86ac58c90bfe4f3c533ec6db8b73da7c3cb05609aad43c1760ba"
