# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2807226fa4620db793de60839ba0d0c113d74f09831c8f8c38784c3403286fca"
