# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8a3345c1291908baac8e33af4009b55c"
SRC_URI[sha256sum] = "5c297a52086d4d1903c7c3fbda4ed075cd3503eb2092db323e2d193039fa79be"
