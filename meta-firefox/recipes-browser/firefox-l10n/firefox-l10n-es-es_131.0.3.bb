# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "178c6199e4ee655b613b2a4c89810510"
SRC_URI[sha256sum] = "683c1d9bb40d28c6772fc0aa59ed9792f32f17288269564d686e27ca83a31967"
