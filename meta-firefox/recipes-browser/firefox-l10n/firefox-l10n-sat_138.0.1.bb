# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c925c3d199eb785faee0b01c5e3fea5e"
SRC_URI[sha256sum] = "a12d4b120a2d5c7cfe7cb1b2191202766bd4de4cabad8e199ae56459ff34ac13"
