# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "48bd227279878b56658da39981aba6e9"
SRC_URI[sha256sum] = "b503162b448574410125012c5d6bc5eec340e13fc7fb9aac05efb5bac53c8c12"
