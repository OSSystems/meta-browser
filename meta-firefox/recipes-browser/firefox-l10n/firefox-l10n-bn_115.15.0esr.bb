# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4705ac59e4400c160c01852ce1edc334"
SRC_URI[sha256sum] = "76d3d888e253bf0a7a271a56f0878b71709ce4bd4bd110be67d335b37674307a"
