# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "09299be509112a8ada09f0955fa01619"
SRC_URI[sha256sum] = "6dd1c6cef6c2085cb4798d8f90cf23e3af789ee606f9ee1c172d9c6a0bf1c467"
