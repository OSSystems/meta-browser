# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "10a67959b1a40a41d1cd8276323bc9d6f51f1f277be4861034dbbbbfd1a7f7d5"
