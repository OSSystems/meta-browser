# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3c65a520c1685da5ad021a198d5ec025"
SRC_URI[sha256sum] = "432f2fd2cb85758f8d851475bcbddd18a06d83f37781cd8f25b4f3c18043977c"
