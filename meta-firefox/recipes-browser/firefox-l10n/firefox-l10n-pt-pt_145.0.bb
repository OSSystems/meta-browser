# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "399f15d7ec54efbf04d194224a3e7830"
SRC_URI[sha256sum] = "4d590c7fe49dfe2e095e00b3302114f5197722c55b42028f0b75b616617a6506"
