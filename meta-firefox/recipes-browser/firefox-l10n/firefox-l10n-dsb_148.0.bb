# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "57c14328286dfc4f1d30cc2003fd6c1c"
SRC_URI[sha256sum] = "8955818473070452d07172bbafb4f735cc8aec0d9646ba88547fba89fd4b9b72"
