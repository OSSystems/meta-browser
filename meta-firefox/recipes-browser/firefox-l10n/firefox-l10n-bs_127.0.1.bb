# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ae60a7dedc3d2f672b2fb9921f4ff4fe"
SRC_URI[sha256sum] = "e25062d955165b3016c18506617c98eed685e234648fcc1dc9dfe8fcc0fa9b4e"
