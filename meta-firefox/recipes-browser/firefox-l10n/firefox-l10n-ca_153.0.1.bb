# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "77b98a836131e444adf36c8dc28e2ac2e4ea1e5afdad9179e20d0d38645f2616"
