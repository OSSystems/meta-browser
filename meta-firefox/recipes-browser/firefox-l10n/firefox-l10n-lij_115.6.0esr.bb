# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f7ff9c830ebeea2d1e51bd34ed3612e8"
SRC_URI[sha256sum] = "5834dbdeaa4f64cd99736d5ed3c08314fe8798380662b0ef56d1ba91c3154645"
