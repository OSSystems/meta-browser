# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "77f7943afe9ac4b1e49c6bfed24631cc"
SRC_URI[sha256sum] = "8af6519905335eee8bc82faaafbceb96334c00383467bc20d3fa2803de39bc58"
