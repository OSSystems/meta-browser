# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7232491ddb4ee6672849cbde9eeb6ba4"
SRC_URI[sha256sum] = "0cda5c5067c5d61836903d7a1fac2592edbc03a30b175ecefc9df62ae086543b"
