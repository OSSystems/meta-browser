# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "960f35dc67d47e97fd8889f7819abf88"
SRC_URI[sha256sum] = "951ce8c21c08f2c3174832777f64f89504e1de9e9fc3829392d964bd3e182e6d"
