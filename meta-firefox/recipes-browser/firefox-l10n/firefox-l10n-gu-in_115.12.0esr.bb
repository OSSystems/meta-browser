# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6fcd713366145114ce3db74d7686ec34"
SRC_URI[sha256sum] = "3a069718140909c4f339ae4233c1f0def86cc7a02e7405fb5efe04cce1e62a6d"
