# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "df54b40b37da54cd2d4706fe88667612"
SRC_URI[sha256sum] = "4e4f8718a0ef8afeb63b2cb291696be8fa61a338c269f4f2062bb93dab75f6a0"
