# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e0f509293d9f6b58c643d454ed313fc4"
SRC_URI[sha256sum] = "8219cee932ba22e2ffabdf0eb19a51b8e6c6f88d627efbf3065b6d8c6dcf5f4c"
