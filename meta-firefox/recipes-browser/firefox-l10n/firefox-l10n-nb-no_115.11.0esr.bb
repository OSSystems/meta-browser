# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e087e519bbff4feacc70727a25f725b8"
SRC_URI[sha256sum] = "219349f8b5c55fdfbcd69401fb0823865d80f4d36fa72103c825e148726d698d"
