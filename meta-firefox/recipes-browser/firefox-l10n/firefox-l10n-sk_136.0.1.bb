# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1061188d92485413761460c47f930598"
SRC_URI[sha256sum] = "5ab02912ed3d2bfbe3d6100f51956e7dccc3fa6dbb050df95b6fcf7b29a041cc"
