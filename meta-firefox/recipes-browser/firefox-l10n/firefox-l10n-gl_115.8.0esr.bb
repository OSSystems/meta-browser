# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db0450732bb695e257d9322d485b4a5a"
SRC_URI[sha256sum] = "9e1a9ee37c54b0adad8d21ce1c6de681e5606b177b289d3d7eeb11d25b7cd391"
