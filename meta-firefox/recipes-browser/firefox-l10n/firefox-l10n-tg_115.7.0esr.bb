# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "56c6a640f5c022c50c75920d4dc921a3"
SRC_URI[sha256sum] = "346ae2a8d56b499e949c4ceca358e0e5f894012b3de42e4d29f78be293b8824b"
