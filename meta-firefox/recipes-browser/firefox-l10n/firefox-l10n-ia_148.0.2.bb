# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "360c64940acd654ce755bb13b80fa189"
SRC_URI[sha256sum] = "877a109c400b8f07c554351700f03bb510ccd4d197b56a8d82d7ec2218a9c9d5"
