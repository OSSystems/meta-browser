# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cf6c1be72f86a497a4babb224c5b45fe"
SRC_URI[sha256sum] = "8dfbd44a29c4c5ec050427baa9bdaf367c41f54128fda7de549c1984a2c75c3e"
