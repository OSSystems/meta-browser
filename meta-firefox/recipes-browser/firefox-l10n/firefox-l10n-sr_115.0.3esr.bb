# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9a468c1ea909fd7119980039c12e6c9f"
SRC_URI[sha256sum] = "de98a6c921a0a8b820f606586971974559e6e9163e4ecf8e2093e37d10cece7e"
