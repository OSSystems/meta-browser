# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e03899303cdd90b7305eb432a6d220bb"
SRC_URI[sha256sum] = "9cc4ca02745aaf0bcf591671ab3134bac8ce1047c9f3d38fd4806585a3b4baef"
