# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "298757b48f56abbf1105be1b5f6c584d"
SRC_URI[sha256sum] = "8cbbcf863f82ecf1ad802dad098eafba16efba7aca33751290e890741b244849"
