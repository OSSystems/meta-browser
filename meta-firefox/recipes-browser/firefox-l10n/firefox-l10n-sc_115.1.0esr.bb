# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "325749c377d6f845910137120e5a00e3"
SRC_URI[sha256sum] = "47e9c129ab75dab4b3181803b255fc505f44497c61e9217049594f4eda8e2878"
