# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e34ed9d25e4351c87cb6ead7064f2a1a"
SRC_URI[sha256sum] = "11d9f2759c7a2015810d3b436bb6ac6d80b266068606dcd06f2d2402a3cc2ac1"
