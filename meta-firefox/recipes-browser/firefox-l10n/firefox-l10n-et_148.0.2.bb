# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "138e3497bf016c09e54e40a34f035fc6"
SRC_URI[sha256sum] = "0f8e35ed1338bb8a25ea13f666095105932147c28f03e951a06b5c4d55901d82"
