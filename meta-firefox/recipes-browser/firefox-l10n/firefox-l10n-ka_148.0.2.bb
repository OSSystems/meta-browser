# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "19188eb7c78b09ff21588c5697db913c"
SRC_URI[sha256sum] = "dcd660f0c232b339a17243b273cfcb7c6b7f6ad0859cb7b11943395f580e1e61"
