# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d0bd370265ca9c42cd16c4d0b677313c"
SRC_URI[sha256sum] = "b9db49b4b0148e7318513bc3c35dbbecfa517d20f52bbb4f131c8aa221e86dee"
