# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "fb6ceab06b55b06f76ebba4787f5ef4af71155b16aed99d5360cfa562d2cc0b7"
