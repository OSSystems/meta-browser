# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b3e96ca3c1fd11f00cd7402409309dee"
SRC_URI[sha256sum] = "7a2b59665728227e969b6f72a2fc3e4cb6e6d52fc6f09d4ebf3a7f839e4d74d1"
