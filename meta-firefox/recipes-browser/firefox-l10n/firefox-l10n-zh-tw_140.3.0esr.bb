# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "648bd09798f2293449bb8fb42b9f1a30"
SRC_URI[sha256sum] = "22d9afe64b7f361f6b6811af507493391d97cbb200a3e697b1bcc32609b96c55"
