# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "aacaaabdcae8dce0d0be17a6ee91670c5fa0eab48ab8175fbc0622f7c4941c4c"
