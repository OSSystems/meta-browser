# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "542fb04b83b553a0d83d7f8c5e2b9ac0"
SRC_URI[sha256sum] = "608b010f1ec55c649bcec55a57e90762cb3d19e5a8a8ea047ca1607f0a862aa0"
