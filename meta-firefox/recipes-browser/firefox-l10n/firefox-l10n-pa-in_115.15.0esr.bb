# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "25844a1430d5c21112087c49a1f31845"
SRC_URI[sha256sum] = "248bc3b1ff49a8b6368cfc17669dfa3b5415939afe5b089a9603d568f299d912"
