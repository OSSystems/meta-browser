# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "638c00a5514f9d7cdc215da5ce00349a1ee05567b2c965f3a833c1a07f3827e3"
