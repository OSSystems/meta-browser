# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "00e702e096264bc5271d52b12ad310a8"
SRC_URI[sha256sum] = "48b6fd994f26721c64dc5c19a2167dd0f21a930c065796fbcd719944fa3fe4e8"
