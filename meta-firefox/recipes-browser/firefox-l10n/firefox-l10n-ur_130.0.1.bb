# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "af627410158abc293581d117948d5eef"
SRC_URI[sha256sum] = "be6f084c16fdd8edb16df4dfdc122db2e96be7ffed34bc9ccb9139112d9572d3"
