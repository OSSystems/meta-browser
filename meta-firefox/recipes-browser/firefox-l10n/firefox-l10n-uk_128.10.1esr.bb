# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b0ea87b2f1318c0c7c7d13f0d0feb2cc"
SRC_URI[sha256sum] = "934d03dc4ebc7c7c3a8cf3cc5f9183ee7b3c9630d07ae49354b250b24b3d0683"
