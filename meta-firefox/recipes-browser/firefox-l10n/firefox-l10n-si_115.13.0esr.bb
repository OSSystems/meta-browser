# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "975268aaa3c01b740f894591ab5e1e26"
SRC_URI[sha256sum] = "d2c9fc4bd4833832fbaa6a5b658c24e566c91f9c85666bf1d60093687b21a316"
