# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c6041d516935fd6bc6284efcb0274e7c"
SRC_URI[sha256sum] = "7974aee129791ba353d83b3074f3f8e0d0bd53242fff95fe3b10265011d11f9c"
