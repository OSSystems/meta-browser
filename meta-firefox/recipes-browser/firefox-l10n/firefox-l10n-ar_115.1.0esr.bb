# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "24fcdebca6baa4ee34e892b0adc35c88"
SRC_URI[sha256sum] = "d9916e39ffcd6e0727a7a19850592b19b14b352e10ba6c443eaa6b7625173b73"
