# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "cb8616c8d00e6402fca93a100cf2ed8523a4506e029d2927d246c9950ea5087e"
