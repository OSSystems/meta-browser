# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2ebf9f8c1143d94a6d8e5c6fba23a27081643f37d2b63462c471552320ba2ca5"
