# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "619792460b49a440e20e5bd71b311acf"
SRC_URI[sha256sum] = "dec7ec66f02d0c63ac205c745cc58ab7d0c1dc75abfb1830eafad121a57acc26"
