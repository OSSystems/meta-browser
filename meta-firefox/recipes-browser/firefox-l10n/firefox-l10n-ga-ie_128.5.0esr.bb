# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "70d54396951e73a0b7b730190bf15290"
SRC_URI[sha256sum] = "cf8c84d2e774fb18c7bff419efa132d81bf5b499dc8a2caf40746b4425f23aba"
