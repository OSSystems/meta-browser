# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b3ee4385a41f43386829a439b3decd95"
SRC_URI[sha256sum] = "321f9e432c4af7ed0c686233917655526525fd15465fc5fda33ad22a14bd9d06"
