# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "5abc5fcbba6f4a716b9e976352be94ad5dfd4047befcb2b7dae2a18c0306cde1"
