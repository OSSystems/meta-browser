# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5d44086064631bf749ed21a66b502431"
SRC_URI[sha256sum] = "2fd347ddef378006a651bdc9aba554e52df5e64b0d4ff621f8d8c3ad0fc64f8b"
