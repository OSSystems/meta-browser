# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ee969789154b40aacd18804aeea79bf"
SRC_URI[sha256sum] = "7f103db8155cfd9105604c73964864561ec8c6a75ace9fe109dbe3521fa0f666"
