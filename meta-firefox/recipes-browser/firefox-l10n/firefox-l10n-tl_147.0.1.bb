# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "802001b5b979e6151f31b74fc05c9649"
SRC_URI[sha256sum] = "a4d5afe170c22e65aff0102072dce1ca4ec18d5c2b43ed4528117c2e3564acc8"
