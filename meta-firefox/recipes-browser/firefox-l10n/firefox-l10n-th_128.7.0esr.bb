# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bb96bdf56680db39154d4b5578002a90"
SRC_URI[sha256sum] = "3ab2059a785317c4fe7485472b5ca27e4c2fc6d9036a73f86eed891b380bc1ed"
