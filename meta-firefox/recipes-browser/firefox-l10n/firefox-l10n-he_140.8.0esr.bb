# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "79f55e9b16e9fce704dab841be2d1bb1"
SRC_URI[sha256sum] = "8da057a258dc6f5a134ce9a31098d8282ac105aff32e558f56485742e80fa2a4"
