# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5175db284f2d0c72d00ac974aa5db2d2"
SRC_URI[sha256sum] = "198b2ef312df436e111503171fa4be1edca9d3fe24ecb701ff0c881d48125e33"
