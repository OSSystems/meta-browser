# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "45b8680ed168dcb56f6a391eb81a99a3"
SRC_URI[sha256sum] = "b1bdc3441557d82ca6849c838641a9d4d83c6ef31953effa6213982ccee79bf9"
