# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f581a9d42f50b1521495de260e5f68cc"
SRC_URI[sha256sum] = "315aeed9f8fe83bd16552714b7a34cc3acf5fe1c5fea2e59ba9b95b6e981d21c"
