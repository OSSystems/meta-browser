# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "723c0bce59afb2c730ed2f8ae8148982"
SRC_URI[sha256sum] = "ac8fd2d0ec39f8432996e3815413c279e04f797ceaf161779bc9bd8b3c728f60"
