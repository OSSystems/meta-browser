# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6bb1feeab63ac4951da0754134c68b1f"
SRC_URI[sha256sum] = "cc98803dd6b806977091263e6350de5dca66e712d79723775f022d84dfa978c5"
