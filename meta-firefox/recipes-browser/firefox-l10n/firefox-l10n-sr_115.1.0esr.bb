# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8ec620fe7c7a3ad3e871127e1547b91d"
SRC_URI[sha256sum] = "420012835e7bc569b16d9cad93e1e6fe4c309661270d56376a17acce8004feab"
