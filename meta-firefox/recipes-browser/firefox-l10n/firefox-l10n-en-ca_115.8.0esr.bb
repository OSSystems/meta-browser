# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2128ccabc961d536f01c7eeeb0875829"
SRC_URI[sha256sum] = "f81f2145bf6bc8f41c9f5ef07b3745b37056721259eda2b88021da10968c58dd"
