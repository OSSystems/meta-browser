# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bbfce6d94412388539ad64e5f68fc28e"
SRC_URI[sha256sum] = "8fe2e8d1af7a5dd14c98403afdf94a91e22453879c9cf0bd287d32f71aedab72"
