# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c9964a5484febcc5e53e7ac997f88c20"
SRC_URI[sha256sum] = "e56a528f87f2f9a08eed8da511ef55f375175157e20ce3ce5f2835f146d5147c"
