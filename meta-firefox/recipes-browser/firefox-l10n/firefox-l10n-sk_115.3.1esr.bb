# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "360d61fbddf4f57ecb590b7153df2845"
SRC_URI[sha256sum] = "2fb7303416ff848f8b1b6684f739cd3ff36409e397621e8c7ddbdceac6c52ea1"
