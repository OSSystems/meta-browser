# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "62a69428ddaf56e462721076a210b7d3"
SRC_URI[sha256sum] = "389bb382ef0c0d1550daf83b0a69c93685edcdaecbc5d024b44012b86e7cef09"
