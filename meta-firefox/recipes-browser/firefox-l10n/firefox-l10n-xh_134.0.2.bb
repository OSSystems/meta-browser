# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cbabbbd8fe1a6f488aaeb30e5631e8ea"
SRC_URI[sha256sum] = "e60d372aef0252bee9fbe990f0c359ba4015b257b7e792a42ae93c87611e9ca1"
