# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6fb42d021aaae3e23eebfa2bee74bf89"
SRC_URI[sha256sum] = "d2ddb25da3880ec44e422f2985f156583b8d4eb8c0c4eca27aa68cf758c1c765"
