# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9bc3b92630961a26cf4b37f0f2104a75"
SRC_URI[sha256sum] = "a73af5162fce9c15129e6ef41e870b37c06d1448cf183b221f2b504d6927b595"
