# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7d6efe6e5c6fec418b6b33131184186c"
SRC_URI[sha256sum] = "d2bc40ae643bd6fac03027e962b91783ae0264eafe3889be0929ae6ea20becbb"
