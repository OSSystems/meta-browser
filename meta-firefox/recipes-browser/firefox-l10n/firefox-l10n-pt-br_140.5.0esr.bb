# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2a312cb27edabb231a2eb50c7cb05390"
SRC_URI[sha256sum] = "92b1c295185b48e3b22ff69871dd83ee4de2e5d2b3418b367d4d49007705c822"
