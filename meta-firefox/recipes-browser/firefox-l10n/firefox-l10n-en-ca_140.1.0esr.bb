# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "950174e5625144ccdeff8da622d4376d"
SRC_URI[sha256sum] = "ca4449475fe92b76469dc978bf036ea3477a8b36e9cfb5f4bb67d78efdbe1cc5"
