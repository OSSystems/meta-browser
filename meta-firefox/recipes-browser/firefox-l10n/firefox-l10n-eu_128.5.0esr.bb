# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "30c6a43745d0e3dd4cb512a319e15b01"
SRC_URI[sha256sum] = "55c4ab582ac31ab9d3af34c5c21671fb39de2f4fe904a2ea88ce9c638f94c636"
