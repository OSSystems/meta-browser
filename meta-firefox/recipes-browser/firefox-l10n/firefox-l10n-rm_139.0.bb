# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "082cfb90b751bc1c9ed45684ee4fec35"
SRC_URI[sha256sum] = "feb2b1c188d557c4c04e3b90e16b0fd79f7a4a856a44bde1f5c6050d43e4379b"
