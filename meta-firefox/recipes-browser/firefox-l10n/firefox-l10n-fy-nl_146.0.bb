# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c2b6a26fac9a24a67dbc1bcd7499ea14"
SRC_URI[sha256sum] = "f67ec4e667c3e7a205bf234bc723ecff4eab5b71cdbe24814ec64664be75476b"
