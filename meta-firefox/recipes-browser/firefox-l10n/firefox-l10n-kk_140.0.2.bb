# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "79c623751868d313b524a5ecc5699cbe"
SRC_URI[sha256sum] = "6e0b37047452865ab1d6fca2f60043709ae4970472feb65d5e078f391bb0ecb5"
