# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ce55f02062084318113317728caf8c03"
SRC_URI[sha256sum] = "7eb666847f1b8932259f9ea17807b87eded6d9a8423e21e87ed18c9ec9e4a068"
