# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e4c1aefd8a88ae728df3d251baed2a02"
SRC_URI[sha256sum] = "34a672b0d23ede97ce248bc791df0fb123ab80531b30bcafeb9438ee5ad7153c"
