# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a943ce0fed96222d339b82d1a8077c71"
SRC_URI[sha256sum] = "f94242d3a746e8e075cffd8fcd556f5eb48a50833387f045f49243e0956b59b3"
