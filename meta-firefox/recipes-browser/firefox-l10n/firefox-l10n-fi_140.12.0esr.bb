# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7b53ff58bca6b025fac415847a355e44940171515bb5a71d5561eb462d36dd16"
