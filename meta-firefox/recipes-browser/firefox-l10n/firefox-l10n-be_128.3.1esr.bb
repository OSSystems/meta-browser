# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0002a07cce31d811d4d3e609b8cdd20f"
SRC_URI[sha256sum] = "1cad9f5003bdd440664a6918541f5abda8a50756e14d9512af9b6478f06bd7be"
