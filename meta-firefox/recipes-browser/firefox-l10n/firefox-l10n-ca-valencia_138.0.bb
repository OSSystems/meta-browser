# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4ef7a8a88c7ba39c0f53dbdbf0d1ac40"
SRC_URI[sha256sum] = "843fb1a4cb06ce4e0d0cbfa2447a5f26be627f23234222b1e5c30f4a4d3eb805"
