# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d5f642010076c63c643b43ff41f32ca1"
SRC_URI[sha256sum] = "8eebc1bacca614c08c8a933496fe4832805c0701fd66c25809c5cb3cb1636bfe"
