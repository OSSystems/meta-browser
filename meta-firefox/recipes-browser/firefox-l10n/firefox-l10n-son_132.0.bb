# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "75e9a90641e1e8aa5c60ea1e58381937"
SRC_URI[sha256sum] = "ad87b3cf5cfca4edee1e6ba695538282a11271c7a9e84ada1cc5e1f8e741d183"
