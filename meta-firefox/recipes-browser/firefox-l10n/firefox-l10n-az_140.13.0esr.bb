# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "0cdc3aa9ff5ab1f2a0c0cdc17eead87428f7ec87915be5f81e906f07dce39d95"
