# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ac1ac95b888f1d1728d7e341cba5c5ce"
SRC_URI[sha256sum] = "b2f6b18fc2b08dea6e3b3122a0f7c018bdeb307e6018e52da2e254f14c07e180"
