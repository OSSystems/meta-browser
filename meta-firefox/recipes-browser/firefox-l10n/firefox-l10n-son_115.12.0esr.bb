# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cda1050ee5753d8b3e6b630fac35d015"
SRC_URI[sha256sum] = "767496beba1a639efd7109f8fc72a75e1f6c71ae1ec511bfd875406beceedc7e"
