# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "90c5b3b8c0bf66b292f3f420dce398ab"
SRC_URI[sha256sum] = "7a205dcfbfa537266489976f4bcdca2b69c7a8e377192f40f4e0ddd899295906"
