# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4f38236a7913eee800371406a3e0a416"
SRC_URI[sha256sum] = "5194e476fa73d7d85583b0f1b8fc77af41da4317f3af31649626f7109968e608"
