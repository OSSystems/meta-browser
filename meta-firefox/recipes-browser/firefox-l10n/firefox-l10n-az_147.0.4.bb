# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9454ba54f95fba30b42f329d7a5031f6"
SRC_URI[sha256sum] = "e22652798d904bfce4df1ef1e7a49ff7a80ca13791b907084d089d6abb4027dd"
