# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "916101b38ecebb318cc8cd396a3c16df"
SRC_URI[sha256sum] = "3e5d65967a6d0a1a02cfbb75d71f2602d10fafaa1ac0e374b79ff58af1778117"
