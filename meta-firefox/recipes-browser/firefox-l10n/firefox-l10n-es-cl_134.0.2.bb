# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aa49dc74243543578a4d57291bfb5950"
SRC_URI[sha256sum] = "a1f2291bf273634886b3e16899ed415c4b3191e7fb102d49db89d1074bd8daba"
