# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d72ab08b8348987658a1b86652b92927"
SRC_URI[sha256sum] = "e238a6fb01a7cffd970ffca96d83c73d5f511dabbd598f4e491ad3c3987a68f7"
