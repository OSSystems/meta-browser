# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "26f90764a8916005e605dc4e47b3a591"
SRC_URI[sha256sum] = "c6658e501c9173be5b71a4f53f245b51158939181bf75e07b1395b91d177d1b6"
