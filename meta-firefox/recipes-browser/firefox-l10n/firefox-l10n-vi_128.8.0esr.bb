# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3771b6ba18060ec7ebc618386dff3ce2"
SRC_URI[sha256sum] = "aab8d0ab0156b9a47f901c0ac7e2c5e05f8c1b374502fd18d62654c0595f24b5"
