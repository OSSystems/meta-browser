# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fd8e904a91220343ae7102933ac275fd"
SRC_URI[sha256sum] = "e6760bf0a0eeb59f101ad68ca3779defea1ed283b48af04eebd67c915029e248"
