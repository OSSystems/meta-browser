# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "705cace24ca611018ea80b58b00f4468"
SRC_URI[sha256sum] = "3f5bf3da618265baadadc8823759276c0dd88a3f6a5e2ef4d1d2a8533a116e20"
