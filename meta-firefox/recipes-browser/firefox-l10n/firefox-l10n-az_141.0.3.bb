# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ea982fb7d007e4ea31efe65081603ecd"
SRC_URI[sha256sum] = "348655ed793387b6e1e1982809e32307fc47c4c709c9deabdf9d491f72191742"
