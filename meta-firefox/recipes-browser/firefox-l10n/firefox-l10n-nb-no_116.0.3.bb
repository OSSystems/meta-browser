# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b55ec99f5b5a3214223f99a49490a40b"
SRC_URI[sha256sum] = "70f116441fc593cac050c1392114e793b930c52ba50ba78ca1d7c94cd04e6aa4"
