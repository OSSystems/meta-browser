# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0ac7c06464bcd7e9d866676a040e9ef4"
SRC_URI[sha256sum] = "5b93cef1556b857d6035503d9c57236f33af9f40e382c99df241827f57a82db4"
