# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "6eef6e5187ff8dfa9f4a43e8f9bd2afc0527696d456cf3ff4acf18ecc516aeb2"
