# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e748cdd4d314acd0695f34ae6df345db"
SRC_URI[sha256sum] = "1f24dc49c9dee541afe4827933039405cc5d7cd196a27adc8b8773d006c112c4"
