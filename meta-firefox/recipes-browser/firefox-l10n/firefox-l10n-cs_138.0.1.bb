# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4a740d3affa66e60a7ba87236fc747aa"
SRC_URI[sha256sum] = "115da4ae2480574118db20138720a509772a00f03903f83aa5e4ba2021e93ee8"
