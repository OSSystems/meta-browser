# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3db9cc0fae4e6a787cc409df78d4b6d0"
SRC_URI[sha256sum] = "06507997a647b0340b252651a6ceddf0aa1cad1163eb64dbc1315399ef1234b2"
