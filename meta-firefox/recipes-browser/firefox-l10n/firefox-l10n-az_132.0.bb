# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ae37bb6b85a967016d5996b7551e5b2c"
SRC_URI[sha256sum] = "7dfd2f47e9506eb4c636e3153d64ec774b81502a1a23355101d10124cc44c912"
