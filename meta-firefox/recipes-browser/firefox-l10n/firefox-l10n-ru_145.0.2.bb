# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bd1a9fe53fd18e642c2d2085eef09388"
SRC_URI[sha256sum] = "99a8321979c8e6c605a0ac890b25eacc2e972c0296b1929dcca1a4cb6f4f3bde"
