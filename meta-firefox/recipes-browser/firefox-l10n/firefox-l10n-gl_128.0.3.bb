# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3e6f5be4d024e8becfee64ab37b783a4"
SRC_URI[sha256sum] = "a97272192bf78020d2078f970a8df298730d3b86210714c6c047352b145f388e"
