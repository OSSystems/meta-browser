# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0057612db54bf348c30ff8942e1e8b5b"
SRC_URI[sha256sum] = "b5c2772da3cca411559a5cff4762042f41b13f64f3f093e8b63945576577854d"
