# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "21d5506c11b9153ff8cf5a460e4afffb"
SRC_URI[sha256sum] = "d3601a22e791cafd270aa62153814156cf2a5ef67416c133da87a042985f19b5"
