# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "595b607266cf81cd011ba5cbc60a29a285f18e410765a62e2adab5c9f6d5e83c"
