# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "462c892f9c751402b26862e7c5400ea8"
SRC_URI[sha256sum] = "d3226dc68745aab616897a12ec14362efe75cbf9b704b324cf9d1b00963dbf17"
