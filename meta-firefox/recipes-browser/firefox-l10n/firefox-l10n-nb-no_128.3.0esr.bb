# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "30ce697c1b91268af558f9aedaa11496"
SRC_URI[sha256sum] = "513c4db24494f7c50168846a4a7e438a7baa651f112ab31330b0635c83f43698"
