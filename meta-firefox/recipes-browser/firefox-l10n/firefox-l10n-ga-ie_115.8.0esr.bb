# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "63929cdbdbebec7d78040d0ddae48b41"
SRC_URI[sha256sum] = "de846b7843f8c2be3b2ff33780e70eb5117d1dfb571b83e4bf1190568e7b2c2d"
