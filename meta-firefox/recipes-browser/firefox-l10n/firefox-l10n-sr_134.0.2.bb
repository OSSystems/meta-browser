# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9259eceb0809dc503b737ce322119694"
SRC_URI[sha256sum] = "a43854cdac547e03d862c954bf9f1d315acba4baad8af5584150f558e79ea3ab"
