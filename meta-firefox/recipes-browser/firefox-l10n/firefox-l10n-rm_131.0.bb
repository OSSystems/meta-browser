# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d36c7b7c6bcd8eb922c8ee0000b8b0f9"
SRC_URI[sha256sum] = "81d8ea4dbd07707b8e66726f4499105939af0fb9c2f0f79b2cb2801db805bb46"
