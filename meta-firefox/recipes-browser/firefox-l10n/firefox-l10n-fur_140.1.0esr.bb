# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f6410ce70d55c21e7647c793521ff961"
SRC_URI[sha256sum] = "3355c3941edb03d8039ff9af93c3b2f42a11dab635f7135f5b1704e048bc4e5c"
