# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9f87a230135be9fe3c5c6632a5492a58"
SRC_URI[sha256sum] = "869fd5a85c37eca3c83f58be6da82b016015fcc6c1f08c62c7b83642819716bc"
