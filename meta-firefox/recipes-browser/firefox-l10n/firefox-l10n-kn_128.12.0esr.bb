# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0ce33fd7719694323197624fb3e71099"
SRC_URI[sha256sum] = "de05f0e3415222730311956a9d9724811243e6b64a08d65094a94437e654d499"
