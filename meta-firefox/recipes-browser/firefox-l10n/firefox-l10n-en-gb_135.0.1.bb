# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2888aad9a96fe91412432e5ca81d241b"
SRC_URI[sha256sum] = "745532c569452eb3c694c63c45e9d2b6a138013b5dbd5911e29d4c5cbe9fe452"
