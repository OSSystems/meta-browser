# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ad180110319806e7a89c582e7c552002"
SRC_URI[sha256sum] = "fd93bf15934020242c6171eb935198082d3d73d164bedddefb9754c49902e530"
