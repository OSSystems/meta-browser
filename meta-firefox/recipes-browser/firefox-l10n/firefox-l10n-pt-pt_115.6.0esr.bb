# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "77f29a2897dc7fab27c781a411e22b09"
SRC_URI[sha256sum] = "3a2f041d2415416db7c647a12b201b92a09a7933b018173633f9cd1ea506fa7f"
