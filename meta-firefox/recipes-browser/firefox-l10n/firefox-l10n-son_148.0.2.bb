# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "72c18fd260c178a5f379a3eac41ca9f4"
SRC_URI[sha256sum] = "9e7947a35e23061e72bc2430ad3f251dfd5d235901a027b3d924f936adf46f05"
