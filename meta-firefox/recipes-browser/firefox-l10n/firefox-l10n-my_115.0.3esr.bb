# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "87e68b1df0d980ecfa11300194278b11"
SRC_URI[sha256sum] = "c649b4e7f41bc74901d67feef2f68622f346b461344a5659538cccdf370fa2a0"
