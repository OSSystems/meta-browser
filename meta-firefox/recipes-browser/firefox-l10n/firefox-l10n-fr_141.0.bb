# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f6d15177967ca343de4292b36d16ef4b"
SRC_URI[sha256sum] = "c0bfd86d8cbd8dc837b0d794bd463d716fbc8511829432a9411ea5f700e44117"
