# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e84907f56ec5ad998584249a175f7a25"
SRC_URI[sha256sum] = "8775230de3bdc8f6e3279b867bb81acd7ab9313ad25efc8d3f9e3a57f5aaee73"
