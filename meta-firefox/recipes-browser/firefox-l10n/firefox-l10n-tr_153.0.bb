# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "612c37130ac4f900677521a139442806f8a0ecacbb91762bb9c8462a01495be8"
