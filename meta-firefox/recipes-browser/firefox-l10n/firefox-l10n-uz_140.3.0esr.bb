# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4dee33b39fba8c38bb63db02c777853a"
SRC_URI[sha256sum] = "b0666fc317e0691ad392f6db89895c157582a599775b9c33326e97aa07a6756c"
