# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dd84d096e777c10506727cb1dfc15def"
SRC_URI[sha256sum] = "ff8037e89415c61620a5e867f13fb838cb100b8a12a1bbaf44fecd63e221905b"
