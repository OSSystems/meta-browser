# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "078bcf34a248d191178d14e932f1473954234bb1f9f29d67b3a72d2399fd691a"
