# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ce2d90244b4c1aad046854ddfccc09a3de1c29ad9ed5807c940f1f5e9cdf07c2"
