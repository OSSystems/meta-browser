# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a88efa150ad06c4d2a4fe789f8cee992"
SRC_URI[sha256sum] = "03e675c46face67ecfef4ccdc9948c26ef6064ecc7061845d38811be7f4c75bc"
