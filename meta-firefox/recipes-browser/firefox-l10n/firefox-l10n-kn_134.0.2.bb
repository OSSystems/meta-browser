# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f20985df1f513742331be02be391039d"
SRC_URI[sha256sum] = "69c4554b65a59477002a3e86ba83a322b6e17f70d9c89b5f9f2957ea8e4ab65a"
