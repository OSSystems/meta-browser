# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "43265f6f366f96d74128639ea7f7adb3"
SRC_URI[sha256sum] = "e30ca55f9285c2e7a9c2d5bf57836458c32297558bb9ec38dc3949bf0a23c819"
