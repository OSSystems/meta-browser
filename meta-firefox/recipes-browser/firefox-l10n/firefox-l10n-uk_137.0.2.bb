# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a6ecca10c5376cb7fa1d7f431f3c7cf3"
SRC_URI[sha256sum] = "8d9fa6707455f79f323988a9e508b6b073a2f97f47a1cd2a53b3bd05909f3522"
