# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "be65f9ea1006ed900d607f0947d336fa"
SRC_URI[sha256sum] = "6cf8d72656f2d07c580124bf3b74f4d9f612164decbc556bbe862b910bb3b20e"
