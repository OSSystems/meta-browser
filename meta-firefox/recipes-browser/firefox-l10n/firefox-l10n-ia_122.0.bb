# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cff9fdcda8bc6509cfa0fcc83817714e"
SRC_URI[sha256sum] = "d4e9ba09085f34b8613c73b91f80833b5946b34933311125fd8669e31bb86f38"
