# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "edfffd151f3c7af904b6a62737f7fead"
SRC_URI[sha256sum] = "42e79af148a4b6c71904c136879bfd575b6019d0018019c6b5bbe8d2f9fb5c58"
