# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eff8268cfa575bf27bc44b89d1fa6d5c"
SRC_URI[sha256sum] = "8ba0023d73e7a4a5d95a4964aab6fef0881185bc1e76a5049c03fdce1f19d05b"
