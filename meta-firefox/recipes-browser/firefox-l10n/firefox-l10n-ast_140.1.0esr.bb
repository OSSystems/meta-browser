# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cf5cae08bb721f171bd2853ca1753d58"
SRC_URI[sha256sum] = "ce9f18c442a59f58dcf96692cc96094608e1e18d7dd80f772d690ced840287e2"
