# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "deec7fd72bb4b4ab87ab4f53b4d7f9d8"
SRC_URI[sha256sum] = "988205dfdde46e45a3225b4e1888ccc487e645180e4861952da906d95500d298"
