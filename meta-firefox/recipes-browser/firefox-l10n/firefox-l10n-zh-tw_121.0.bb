# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "924385f8d9e548adaf817a6549dd1643"
SRC_URI[sha256sum] = "d61cc14d3684ae08a83b9ae299c3b4b03573960540a419faf4a31b26bb0afdff"
