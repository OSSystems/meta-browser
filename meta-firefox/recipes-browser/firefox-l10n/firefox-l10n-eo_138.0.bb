# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "778e2e14ed2fc2a32f62daf9a2d18141"
SRC_URI[sha256sum] = "0528b36791625c5245928dcab64be1d472b9a022a4e30e81bafe371febf76c29"
