# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8fbc2a1265cdc07e8d62840b3d984b6c"
SRC_URI[sha256sum] = "0e70584897445921fbdd8cd3c032cedaec6a892c55c8cb14f94baef4f62c95c6"
