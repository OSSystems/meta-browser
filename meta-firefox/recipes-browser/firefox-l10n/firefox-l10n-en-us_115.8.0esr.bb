# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "734ba479675bb034ae8127309310f6ae"
SRC_URI[sha256sum] = "56122f86962cc917dbc31b0e4f8e95a2dd0cefa92c8eb2d5bd80e48d38b06668"
