# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e88c4c1d7ed3a07b0ce8b0ad82fcb587"
SRC_URI[sha256sum] = "61b964e5f0bba3e6226adb84c98d7cd44edea8027fe0aaddd0979a0768c07ea7"
