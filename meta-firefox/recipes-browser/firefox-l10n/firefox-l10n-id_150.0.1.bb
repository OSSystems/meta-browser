# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "452423eb30757009138637e59b9e18d35b44428a40198f334219ea6b1b2109c8"
