# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d3c9ab75ef2f202c4fb34596d33d4cd4"
SRC_URI[sha256sum] = "86ed2b73909d944093d898e028515dee312a99ea211d6882f07f528393d99219"
