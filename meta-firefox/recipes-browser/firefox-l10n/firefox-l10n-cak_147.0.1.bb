# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3eb7df7fa135e76ad1a0776d7731fbcf"
SRC_URI[sha256sum] = "571e104c24ebd115548c699a19bf11480b3e99be441dbcb3f7dccd2082859d18"
