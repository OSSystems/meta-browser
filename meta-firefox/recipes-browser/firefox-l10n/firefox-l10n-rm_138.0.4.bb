# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c137098b69ead98b63d0fa679207a579"
SRC_URI[sha256sum] = "5d5661cd589bd1bba935e168f346e5d95f1dda25a57c99238ec5be5fc4e4bbc6"
