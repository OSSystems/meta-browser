# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ae7dec12c1e553e72a5f3fd84ec597de"
SRC_URI[sha256sum] = "7aaac502b4bea914c02d17f7dda7c2241a348066e17314a1743e13229afeeb1c"
