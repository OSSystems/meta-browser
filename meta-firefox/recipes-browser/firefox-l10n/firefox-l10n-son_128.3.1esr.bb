# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1c7d19ca051112ebd64242ee9a94ee4f"
SRC_URI[sha256sum] = "13d837938dfdee2ff59ddf6a7ea52a107b2fd8dae8525ade3a6642614984f977"
