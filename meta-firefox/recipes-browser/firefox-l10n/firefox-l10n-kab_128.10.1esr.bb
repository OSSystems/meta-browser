# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d63d41554abe8b4715ee3ebd4ec93b0f"
SRC_URI[sha256sum] = "05f14f3becd8e7b19a515ab7d0480908f58aaab66200133a84f296b5be29933c"
