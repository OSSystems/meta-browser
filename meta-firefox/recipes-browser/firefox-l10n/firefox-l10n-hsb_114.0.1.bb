# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cb4f93c6aa94ab559f43daa0fe22a7cf"
SRC_URI[sha256sum] = "92947da48d8d110f7c53990150ad5883ff2163df3bebe69634502fccf7d3a90e"
