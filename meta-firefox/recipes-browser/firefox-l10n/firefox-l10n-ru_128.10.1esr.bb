# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2765fa758aa60d8728d65dcb48fbb1be"
SRC_URI[sha256sum] = "071dabe95dcff990418073f9e5f0546a9d19fae7410578286e0a5c05f3bbd6df"
