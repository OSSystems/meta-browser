# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "601383b3c9bd6ab750774bbeb2690c9c"
SRC_URI[sha256sum] = "f8f9fa18aa4fbbda6cc077f5c34f6d9a7f8e84e1c983cd74bb9f2368a61b1726"
