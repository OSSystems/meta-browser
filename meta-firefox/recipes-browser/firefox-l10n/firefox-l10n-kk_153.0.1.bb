# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ead6d144a88f8c6e53de0d777ae6e6a81a5ccee2d04e91df8e73615d86aafc1f"
