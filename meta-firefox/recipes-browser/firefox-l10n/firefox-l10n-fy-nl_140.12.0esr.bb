# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "31bb0b14220164a9516867f78dda9a03f9c4fe3624a073eaf3e96de61ed7d2c1"
