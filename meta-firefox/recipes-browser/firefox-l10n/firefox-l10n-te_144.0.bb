# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f908606f56d0a1d16ea07b14faff8606"
SRC_URI[sha256sum] = "ebbe4f7416bb3b6fba9293f63c5f0c7ea5013f2b4b2c52cdc5bf9d48ead8d9fd"
