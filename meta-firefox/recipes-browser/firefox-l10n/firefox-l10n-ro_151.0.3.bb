# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "832074f20208cac36a059073d51e4663abab72d0fbccf7131ad15466f1c4c9f9"
