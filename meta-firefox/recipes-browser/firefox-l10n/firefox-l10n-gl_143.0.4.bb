# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1d8d87cb4aaca584bef93a50b2533baf"
SRC_URI[sha256sum] = "398399ad15e0199891bd0b36d0d428abc6a00cb00b5aca23a4f21ffd1a1f71bf"
