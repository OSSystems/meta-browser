# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ae30851a120f5dfda90ed5332d31189b"
SRC_URI[sha256sum] = "ac3677b2eff9dd276f947e4819bc7dbf68ba90cbdbab481c097d6430919b47dc"
