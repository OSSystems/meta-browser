# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f459ef8f79b3ac1e8b4b33d4ac24249a"
SRC_URI[sha256sum] = "ff443f148d953fec02c62cccc080d91b3e8c326f86e73e810e6ecb62c0827eef"
