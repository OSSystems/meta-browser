# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a833ba40fd03d54f95c1abaeba4adc44"
SRC_URI[sha256sum] = "33f9903eb36e709e40cd9f498fba58d8212f3591c74b34e4014b758987d948c1"
