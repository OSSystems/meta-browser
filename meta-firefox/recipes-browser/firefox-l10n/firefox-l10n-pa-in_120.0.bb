# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "df692bf227d6b552aeb0b6500070eaa1"
SRC_URI[sha256sum] = "2a5fca6efbe44dd2f325b045865b9e5a4d5d5cf9357a19e3dd65eedc26164301"
