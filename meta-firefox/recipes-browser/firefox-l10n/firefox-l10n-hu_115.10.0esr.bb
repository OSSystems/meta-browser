# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ff717d8c564a963008219da63a1aedd7"
SRC_URI[sha256sum] = "0b5ab1b5558239eddeab91cdc3fceb6988005f61d78da33b842f0d13145c350a"
