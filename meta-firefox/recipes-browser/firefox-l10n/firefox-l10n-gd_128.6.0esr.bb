# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "350fb5447dad76f95153926687ba2e75"
SRC_URI[sha256sum] = "6f8fb4eb6adacb1cf1b603e87a72c188dc9c023ef6da79c49b0a69a7a3e9edf6"
