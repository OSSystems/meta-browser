# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1a126e9dc3116b8b7dcf8d14d265742e"
SRC_URI[sha256sum] = "aef64a56cc2759f55d9cc5cb82d217527bfe2bbce2d9869ec4ae092a9a722496"
