# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3a11fef703ef79283de079fca1d0f020"
SRC_URI[sha256sum] = "7917569b9e38214a19b2bce1a679379c5aa272479f3032d5ec009e3d19100a29"
