# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e3244d365006a6e57dff7db3c90e5e61"
SRC_URI[sha256sum] = "97bfad0709cd3e36b1656fb72b0c3dc6ee2f7fa632ce7b2bd36377e11ed4bc3d"
