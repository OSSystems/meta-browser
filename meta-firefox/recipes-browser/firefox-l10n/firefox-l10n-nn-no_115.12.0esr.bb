# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7895ac60defeed5b5b0775f987c2fffc"
SRC_URI[sha256sum] = "03a13d9775305f514fe8de9ef35427585f19b0a66b3de01a03ba1422adadde19"
