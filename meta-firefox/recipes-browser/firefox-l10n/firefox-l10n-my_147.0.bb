# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "be3d1634a250ee0f9191a240998a1d29"
SRC_URI[sha256sum] = "9694b4980053f08d55a249a52fb2f5d2ba9c3225073a943fe5259e60f29d0029"
