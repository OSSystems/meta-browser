# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "5d5e90f8773fa6e3eb83d87a861d663e6daa5c9339d131a0741e4a096acbefce"
