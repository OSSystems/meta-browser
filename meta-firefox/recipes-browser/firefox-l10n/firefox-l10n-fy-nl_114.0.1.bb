# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5bf6ead5805e49ea01dfaf7aacc01c19"
SRC_URI[sha256sum] = "50fc61719d5205f28c8218bec50dd7a5f76dce820d24ed4475c7e9ed32f0d3e8"
