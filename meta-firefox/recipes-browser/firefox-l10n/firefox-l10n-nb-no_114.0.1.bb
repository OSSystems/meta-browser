# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "90025c496e7f9c0ceded56dc508ea7e0"
SRC_URI[sha256sum] = "758d5e4034ed89bfea3a2d76ab66886753f88b8e40d3038bc7c3408a1c26254b"
