# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f4f6ed331a33daffd59e91ea6c85dc0c"
SRC_URI[sha256sum] = "600e1964b2621070ac2530ae8f6c9f2d63b3026003df6cb15bd30a44117058f9"
