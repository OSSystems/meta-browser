# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2d9d4d2441846cd477fd80853ee0d377"
SRC_URI[sha256sum] = "294dc5652e36dd61172814ca5989519f5542809063b7450cfec7e953557d13fd"
