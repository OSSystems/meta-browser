# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d33322ed4c26af60815774dd469f1db2"
SRC_URI[sha256sum] = "7e12b194c25eeba61136e949c5e28f8827a30fb2c80bbbc6889caef455759e69"
