# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9484c49c9d414632e878463e5d4f9c12"
SRC_URI[sha256sum] = "798bed7030614ee85edbe9a5c2712f8558d64fb259776a061a2ffe972f11ada6"
