# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "00dbc2a5dffa05a77a72ce3a060cc742"
SRC_URI[sha256sum] = "ced332eb16fb363539cffe3779c15d4de1fd6b4769d2c4ec8d7f7ce07d06e09f"
