# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0f4a492222d437970c16eff142b9fa5b"
SRC_URI[sha256sum] = "4abced0503791af145a8555c558448facd535695d8203d120fc0023900f040e2"
