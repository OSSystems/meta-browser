# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e574e7c4d929f5a26f6e796f18d1225b"
SRC_URI[sha256sum] = "f5d43388ac05468bf8bd266ba5a61355b8834ecefc53ddbe314e016471059c82"
