# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e14fc22db142973b9c22b140ea738b8e"
SRC_URI[sha256sum] = "770d4a84ca062634ef070e1e2cd2a658fde3854b142ddeaaf88a114da052bedc"
