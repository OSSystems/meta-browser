# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2c92d7523bc198270d1e2eca17b9db59"
SRC_URI[sha256sum] = "bc99aa8a2ec9cdb1435e6daae3c055b20480c332ee120b0468636c486728781e"
