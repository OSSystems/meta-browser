# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "62def5d283ecf90af04b57da4a3fe096"
SRC_URI[sha256sum] = "21e8a923f0fc073a7d9d0000ea6c8b692afc1012d4a2b2936f6f46da1ee5d5c8"
