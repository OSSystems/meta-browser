# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8fbe1a91f7b1747ddddf44d229e12504"
SRC_URI[sha256sum] = "232df519e9c8f251f900e862789cf2c1fc54a56ce342f47c45a92017784482d2"
