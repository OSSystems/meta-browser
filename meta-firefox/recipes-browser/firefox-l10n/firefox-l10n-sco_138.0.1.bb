# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f662fa27a079e907148d67e8e3de1888"
SRC_URI[sha256sum] = "8256a83b3d5490ea0cc3505037fd6ecbfd2d558300f0cb38201b247e6cfac457"
