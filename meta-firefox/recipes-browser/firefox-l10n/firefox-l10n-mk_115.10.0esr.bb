# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "419876e86ea37a66a0252e6bffc863a7"
SRC_URI[sha256sum] = "46bf6d54b03638375c39cfcfceae5f203674416c7d1570e8373112de8b354e8f"
