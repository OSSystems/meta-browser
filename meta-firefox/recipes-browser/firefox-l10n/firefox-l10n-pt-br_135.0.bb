# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3bc9ddfaa52bb9c21885be88564230b8"
SRC_URI[sha256sum] = "5611ba980ec43b905e7b9aa04e0c6009ba686f910f084747896c3491b2eac9b9"
