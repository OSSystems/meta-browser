# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8bc3830c973156944c30be8d7ddf3c21"
SRC_URI[sha256sum] = "75c146ca45d1881ae1af4495fc9d53c93d0cbd872ed8ad7e97f993ce49d89f23"
