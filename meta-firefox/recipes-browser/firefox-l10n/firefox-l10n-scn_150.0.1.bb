# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e0d9436eb9fc38682c7d87b95fff6807b47eea4ef7d7886bcb73ee02e3de665f"
