# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8f8110b29cbfb4350d2b64fe33d7b57e"
SRC_URI[sha256sum] = "a3ea49af3a0fcb8b15069cc147d696b51ededfb0cb3d9d7742593c4acfc2a497"
