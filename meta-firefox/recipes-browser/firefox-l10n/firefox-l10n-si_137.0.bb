# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e11a3db2eefa76e13561fdbba04ccf66"
SRC_URI[sha256sum] = "b8d1b4cc7306ec23f9ec60d24e6e063d4b69d1cd0c97ca197294c624125b4090"
