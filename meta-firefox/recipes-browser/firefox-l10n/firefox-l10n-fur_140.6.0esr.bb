# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "483de9ab4e30738c11cf8fe8bffed3c4"
SRC_URI[sha256sum] = "433fe677ece9cbaf3d0a95b44692036d3b5fc07b421011cb7988aa02a28269fc"
