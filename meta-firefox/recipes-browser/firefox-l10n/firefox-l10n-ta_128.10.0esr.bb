# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "81d7dccbf312354e0bead7bac2c0f2ab"
SRC_URI[sha256sum] = "ed113981dc0b06b8da776978d2d94ed1e27ccccabef541eacec4e27f1ff15ea2"
