# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d30cc4a51bea1177e39f253a0ec5f5f0"
SRC_URI[sha256sum] = "1338c7e9aecbe80f273220761ac4030f25436b59237080bc1f24bee3ccb7709e"
