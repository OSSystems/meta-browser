# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "5f449da5e5efd697c80e06760cebe088a0717557d2ee9ac7df84fddeb0fa7d7b"
