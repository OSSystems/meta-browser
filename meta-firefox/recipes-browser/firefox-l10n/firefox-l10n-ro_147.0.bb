# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2cacdb6705075fcd42bf1528674356ca"
SRC_URI[sha256sum] = "6ee88025a3ffbb36925032126e32f66a90f8bffcf4d78f260b45851306cd1846"
