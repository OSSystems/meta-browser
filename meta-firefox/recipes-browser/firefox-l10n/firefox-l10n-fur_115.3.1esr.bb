# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b16e14bfab63199c26cb3fc3fe4cbe78"
SRC_URI[sha256sum] = "7509c29005b307d5e3aea6524b0d715cb83da1adc6065f2cf49dd9b5636a3539"
