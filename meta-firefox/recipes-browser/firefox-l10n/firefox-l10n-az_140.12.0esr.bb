# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "833b105c91a140b4c29f928d8afec5bb77b7d16f6e0fdfc3e16507954fcdae0f"
