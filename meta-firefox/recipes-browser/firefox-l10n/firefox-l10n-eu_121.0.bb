# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e3e1c3dedcbd1ab7f4926898636173c3"
SRC_URI[sha256sum] = "367b3ca09a2694bc0cd5bc66ae9be2f82ea176ce403b18fb1994cf25c2f94113"
