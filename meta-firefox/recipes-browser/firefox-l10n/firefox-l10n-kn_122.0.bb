# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f2ffeeb3693046b2a59927b0dac90aa8"
SRC_URI[sha256sum] = "39b93546498cd2c0f84329702747319e03732a7b24ded64e5b9af6202e36b556"
