# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "29b5f010fae80a8811aa18151d656661"
SRC_URI[sha256sum] = "71b0dbbe839ebc220842eaec2fa375d608fcdf1a237aaa8686208eb96eae1a95"
