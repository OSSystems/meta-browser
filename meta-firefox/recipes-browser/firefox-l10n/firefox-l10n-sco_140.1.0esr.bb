# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aaf3042146764d590a79f2b9700941f0"
SRC_URI[sha256sum] = "52ce1a1491c3f32c0b1c1d42dc04d9dcd9f503d4597b2d928d5c3672a01fdd80"
