# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "de3947e3400516b7d83908c4a790e899"
SRC_URI[sha256sum] = "c60e962dddfdc182fbd522221242fe035224a562808eda5a8aefb795dab0ed2d"
