# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b76bf88043b1d404e621df31ea8332a3"
SRC_URI[sha256sum] = "80c062cdcc6b1d2f369ab87265d6ac782f2c253025ddd9491713a8c855da1030"
