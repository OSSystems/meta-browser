# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c2cad39526ad387d845edb45ab74d0bd"
SRC_URI[sha256sum] = "46904b63f27b1a6a3af74b16afaf4b650abd9b940b9fc8f2dd04b2328b72f757"
