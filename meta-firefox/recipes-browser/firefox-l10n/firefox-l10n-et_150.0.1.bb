# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "6329e3b01139651c8cbdce5b44781d2b634f22b2d06d6d03a4118b33f5852869"
