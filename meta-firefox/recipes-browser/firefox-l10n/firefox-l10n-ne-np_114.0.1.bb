# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4a416acb5997f493b8d854d4140e551b"
SRC_URI[sha256sum] = "3703851bbc302e5f898e584bf1846b0b126681ce708b899c6a96c6813ee1d44d"
