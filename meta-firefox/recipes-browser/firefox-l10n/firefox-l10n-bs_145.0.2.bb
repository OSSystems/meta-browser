# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a24af47ced20e8a4e53273c383e70cd1"
SRC_URI[sha256sum] = "26b902757b15633798d9ee05f033794f7885288ef4de1df41d0076c9ce09c97b"
