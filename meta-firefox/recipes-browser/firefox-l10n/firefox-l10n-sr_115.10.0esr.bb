# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c9777b60c3820491655bbeec6a8d94a2"
SRC_URI[sha256sum] = "0ed86b11b71297399fd6d5b132d3d8ca7916b93401aba63a24bd10dfc752d245"
