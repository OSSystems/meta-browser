# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d173914756ce9a24bb0a8d7cdb6e2f0b"
SRC_URI[sha256sum] = "275cce5040528841b2f20e681c6c2bbc24d87f8837e0a0f646f874aa6fe87cce"
