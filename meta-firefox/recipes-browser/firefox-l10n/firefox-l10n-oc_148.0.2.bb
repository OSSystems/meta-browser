# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "29307e5b100bfbce5538bd945feaecc4"
SRC_URI[sha256sum] = "956d8ef75f63bfeda1931d2d68e2e27116c653665c5e07908b2a65de96b9b393"
