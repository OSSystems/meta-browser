# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2b47885c4dcdb841395bae150ca0eacf"
SRC_URI[sha256sum] = "1f818b31a864310b3b726c7203da220c79f5300a0dc78d77c407149734f91a67"
