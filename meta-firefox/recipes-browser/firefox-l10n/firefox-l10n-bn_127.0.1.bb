# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "64e2528a1ac4c704fbad53a139a579c2"
SRC_URI[sha256sum] = "b2a52cc32cfbc12167802fc945dc53ec1140fbcbca14f4febb1b5aca709c3716"
