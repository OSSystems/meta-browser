# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "bebe34f23666237bfdd4ff64c3b1198b757566a62c128b08b6d49eb1ff89bc46"
