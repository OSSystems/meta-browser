# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "39f7b65ac76faf7a6937507b3871e661"
SRC_URI[sha256sum] = "8eb87b7b7a868fa6a567aecbe455cfaed836f4633523049a9ec9fa52331c96d3"
