# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "085605c0621c5a1decf1a624467561b5bda80dc35541ad65093afc8dfefdfbe2"
