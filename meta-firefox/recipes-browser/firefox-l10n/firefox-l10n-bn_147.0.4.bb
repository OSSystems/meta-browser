# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bc109ea99d06782bb89ea893b55abbe5"
SRC_URI[sha256sum] = "d73e6c422ca628176801dd379060ac877ff0d159419684ea617982c834fa1899"
