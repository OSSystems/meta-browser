# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e290cf57f800e2c3824cfb812d34d521"
SRC_URI[sha256sum] = "e02dbc6d92c6b77096bdaaafd1483ea7c76babf86af879e6d7f91d3daf082395"
