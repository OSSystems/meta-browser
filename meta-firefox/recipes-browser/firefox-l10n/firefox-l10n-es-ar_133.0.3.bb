# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "463e82b145535270b217cf51b2250cff"
SRC_URI[sha256sum] = "a42c3e698d0c7f2b31800531a60b0a202f4b2b22d23a1f29da7794f0d3811502"
