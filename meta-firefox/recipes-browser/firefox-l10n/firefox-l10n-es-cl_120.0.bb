# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e450021b147e83151b62701d78615b47"
SRC_URI[sha256sum] = "08aa78c81ea722d9f9a61165c79de954f71ed77c12c043c023ab9ebedcbe0318"
