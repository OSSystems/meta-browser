# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f76cc678dcac9145529935a457d4ba8e"
SRC_URI[sha256sum] = "2c1212b0b09149a712f3e146246db29615e766859a34e55df0b338fce630de67"
