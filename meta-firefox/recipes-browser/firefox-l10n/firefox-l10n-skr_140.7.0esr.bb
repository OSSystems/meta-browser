# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fcebacccbfb146e6865020f159b4b3e5"
SRC_URI[sha256sum] = "9d8961617dad054761571c674de4cdeb1a144000fdf5f4586b2517e61dcbb5ce"
