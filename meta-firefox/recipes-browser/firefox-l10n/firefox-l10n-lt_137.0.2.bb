# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "68dc3fe79879b4faea749bac92e84467"
SRC_URI[sha256sum] = "b1462d60776824e855c7cae22b68aeb9230a52f25d27f01097f6d45be59a76c2"
