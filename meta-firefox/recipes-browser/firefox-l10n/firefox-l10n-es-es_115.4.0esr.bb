# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8911e62bfbeb1788aac313ad41d229ea"
SRC_URI[sha256sum] = "8ffa63e95634267debfe69b4d2493de6fa5e50afc26f638b4d55c2d4e7a98da7"
