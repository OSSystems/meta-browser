# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3a65d52831f79bdf61ed20b5df1d6b45"
SRC_URI[sha256sum] = "777860df54a22bde04d78338fd3d69d6e1bb5f03eb3a61d93d90bdcc8b5f2526"
