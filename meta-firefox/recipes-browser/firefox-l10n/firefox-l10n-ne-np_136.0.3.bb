# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e5c227e3a9412220fca8a31a116edaa2"
SRC_URI[sha256sum] = "689fe87e5b68f1e0924abfde65ec53d0b572826186245a4e07d83132fcfad88c"
