# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "700100598197313d5a8186e638da5cf3"
SRC_URI[sha256sum] = "ce9a45308af7843da79d8883eb5d6f8b7d3b35c81650756da2423b04b877321e"
