# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "36c7611b867bcd0d5f4f08abe3842baf"
SRC_URI[sha256sum] = "c33d5872785c02081c5b3c09a0225168c354d1efcf7eb44e964830e2f5a8f340"
