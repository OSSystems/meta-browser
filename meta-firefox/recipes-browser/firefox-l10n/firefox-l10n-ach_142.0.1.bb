# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8d3445718503f47c64678c43a2440196"
SRC_URI[sha256sum] = "3a8237c9b440cf600bc4bf50a9cea341e0d88174e819cd7b73c64cd5be0db113"
