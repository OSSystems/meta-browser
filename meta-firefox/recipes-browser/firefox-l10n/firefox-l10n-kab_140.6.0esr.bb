# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c047185d422ee8302c7fcf084d825b78"
SRC_URI[sha256sum] = "5be55f36729f0522584703021994b028b1747ed9771dd00b5626269d6eb7eeaa"
