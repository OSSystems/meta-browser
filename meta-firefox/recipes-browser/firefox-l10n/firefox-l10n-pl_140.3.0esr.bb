# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d834b1ad4411d84704eef6530fa98b2e"
SRC_URI[sha256sum] = "160dc328b1a109029551c2e8d7736c8c11b680bf8e12a6644d394dfad02685ea"
