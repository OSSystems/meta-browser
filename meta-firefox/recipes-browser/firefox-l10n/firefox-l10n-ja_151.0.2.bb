# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d6e6917b060ce9db371b1b686fe8a900321cad7e77714adeb9c9e59278b6e608"
