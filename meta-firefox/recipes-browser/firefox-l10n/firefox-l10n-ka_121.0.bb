# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a396d0d37e45050d40ca8a24f5c138c7"
SRC_URI[sha256sum] = "59e079dcea6168772919b87d8827d44b444dfee37e73d0d612b6fc4174d98397"
