# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3cb55c5bf5c8001cf3b93580197c0031"
SRC_URI[sha256sum] = "4cdcdaede7a0524179f0dd7c824f0b6ba8070dde0b069820a14ffcc1e6896354"
