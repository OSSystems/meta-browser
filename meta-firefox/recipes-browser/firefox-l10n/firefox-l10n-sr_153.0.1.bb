# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "76bbc9a90092a4da3f756b25ff7de2e259e9a474bc63b26bc139eaa6de24fe99"
