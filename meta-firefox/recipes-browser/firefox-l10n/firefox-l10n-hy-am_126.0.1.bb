# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "54cf9d3c1417d9bc15f1bdbf369145f8"
SRC_URI[sha256sum] = "8a8935b5a83ebcc45343f2fa1399ecc331d1f4e1b2e02215571a2705939054b9"
