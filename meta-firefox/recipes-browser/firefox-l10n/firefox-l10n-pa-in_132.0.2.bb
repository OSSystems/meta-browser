# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "51921d6557ac6447dbdd6ab4a3a39f0b"
SRC_URI[sha256sum] = "eab3e01d39543fcc7abc9701de79dc6ea78171c757e0a002fd6a4e699c67e765"
