# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f56929235171f509a12610f859d7f642"
SRC_URI[sha256sum] = "e5ee0bdba17edd1c62a942bca90042261e84e234aee3228bbcbcae1cc63e9caa"
