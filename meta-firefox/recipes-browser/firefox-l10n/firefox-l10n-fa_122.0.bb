# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f6a15100e0cd7db70a34a22f3d9ae960"
SRC_URI[sha256sum] = "0c43f42d259f879ed55a5590d6325e0735f284bbcf94ac63687334f8bd4a22f1"
