# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b9c2f653c17b1ed6681f5087e2ff1825"
SRC_URI[sha256sum] = "e629c2cdb05d4bbff492ea29f1019659f81b825185ea6c4531571f07cccb5096"
