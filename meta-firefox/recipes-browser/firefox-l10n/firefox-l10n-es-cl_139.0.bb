# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1e5f673699429945cabf96e7e3415edc"
SRC_URI[sha256sum] = "fce691bb3cd9f9625392ac69242126e42381d396347971df957e9ffd1885673f"
