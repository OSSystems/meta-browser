# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "69b95ae41607fa2f644f1ebf186fa406"
SRC_URI[sha256sum] = "e15c3d8c94f15398308acbcc493513ac73b0c0a768b450c0206a65d5b20e1a2e"
