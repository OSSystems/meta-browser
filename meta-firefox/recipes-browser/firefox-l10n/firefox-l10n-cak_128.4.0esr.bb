# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f2b93386e98a694f56671efbf8e6b58c"
SRC_URI[sha256sum] = "ed96dabcb8c1bac603a1c13eeae87c8e8ebabb99c447f629b36499eca9268d48"
