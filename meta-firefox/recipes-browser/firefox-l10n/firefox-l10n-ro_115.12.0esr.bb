# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bb8120d5cd6da97e0e7335bbbf915d84"
SRC_URI[sha256sum] = "f3df6fc8578b496e8bf6e7e7864869ad1ec09d950d492802ec3a0933fa2a0e52"
