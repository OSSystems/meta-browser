# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "00b38dcd447759bf9583b82f37c8963f"
SRC_URI[sha256sum] = "624b1e717b66b369c9e4451312ea36fe455415d6f0da03a7c72fff659dcd814a"
