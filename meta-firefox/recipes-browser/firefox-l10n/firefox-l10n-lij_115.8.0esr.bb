# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "39bf65e8b84edfd5d85058a207ecbdcc"
SRC_URI[sha256sum] = "2e043759d29461c396e8decf89d5117b36fff771dc71de0f27401b3bd63a77dd"
