# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b0f6b87b312c2606c1b3604858aa8b79"
SRC_URI[sha256sum] = "0d7c67ed7928afd3bc84c516e380f2283fae69e41ef0219a8808f7534c944d76"
