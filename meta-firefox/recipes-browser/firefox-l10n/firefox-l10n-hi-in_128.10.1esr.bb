# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "17b8652b492def2a2270afe8484308cd"
SRC_URI[sha256sum] = "fc8865cb2e71341ed91bb6d65a9cd87e1831f7c0122cee15daa80bcec9fb318a"
