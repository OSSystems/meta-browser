# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4aa4d166b62117c65ef24a13c29048b1"
SRC_URI[sha256sum] = "5b8a7c0d097ded8b5dc68bbf655a65791d00b89736d46aac718a3e93c23fb508"
