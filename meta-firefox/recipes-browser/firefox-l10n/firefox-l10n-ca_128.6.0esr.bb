# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "be2c20afd0bbaa97a9fdca4325e8d66c"
SRC_URI[sha256sum] = "f365826bfeafccb3b9152a74d98e35f0ce8d99cf523a380e840c4d0a65da3624"
