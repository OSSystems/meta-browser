# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f858a5b6a5cf07d2044a0f8fabbc8a91"
SRC_URI[sha256sum] = "4b61e45d2a3321ac9f5e89b6f76c0514109c2a2607094327ec646228722581bb"
