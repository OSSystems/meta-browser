# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "890f55f96674118d6fa9da818cd8c2d7"
SRC_URI[sha256sum] = "0ed2328f85c9376e7bedbd01fff14afbae69402fdde733021b2df91d8b2eed06"
