# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "af3a5cbcb675afd8a611e88ef04fa22f"
SRC_URI[sha256sum] = "1de7dedc4e4b0c2b79e87b3eee835c811b1441b3fdb36caeb5ad8eb2af912add"
