# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ebad0c39c194588016dac60091de3f95"
SRC_URI[sha256sum] = "ccd314462237bf5df34ae0cb722c33f5e280aaf340a9f3c247377d5f4c075348"
