# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "35ef14dff134481a31b91f6d99b5e286"
SRC_URI[sha256sum] = "28e7a24cdcb69535f16d0484ac8b940ed2249f8744fc8bc7d7d1802b2b7deb99"
