# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d81b8e7f790f6592a070cca44bf4bb8c"
SRC_URI[sha256sum] = "c5890ea91c710f289a3b1b0987033b7cc76b877cf9e4a56546f36cc7a0c8ea8f"
