# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d8ffc58950957828f10e67cf8dcfadbb"
SRC_URI[sha256sum] = "413baa8fd91ce5e8610e5d1198c73655d33a97a1865fde7f3cd3aedc58b7803d"
