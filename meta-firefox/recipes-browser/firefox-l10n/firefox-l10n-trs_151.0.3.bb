# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "decd7465caaea7fce6a5946204f5bebabcf83c9bec1168b2e46714e7c07af827"
