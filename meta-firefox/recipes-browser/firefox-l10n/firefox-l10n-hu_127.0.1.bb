# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1271e16bf4efac9ea0326375f20f156a"
SRC_URI[sha256sum] = "cacede98546258165a29bbb4a540a91df1a632bfb1f8c8a1f534d35d55bfbee4"
