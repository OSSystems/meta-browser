# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "48d5dd02c8bea0c7678916e5683849e1"
SRC_URI[sha256sum] = "70d43bf892db47bb5f8a0eeaafeffa5c433c1789087289769f343c5e51cad00e"
