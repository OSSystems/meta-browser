# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bee5717868517a8839bc60d43652d5d0"
SRC_URI[sha256sum] = "76c1d744ba6d81d6f02e2e71adeccee36a0d99f8ebee2984c570988e76ebf6c3"
