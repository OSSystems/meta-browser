# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3a34c71cd27b9d15d96dd163266b7db2"
SRC_URI[sha256sum] = "bc546c3073951d072cb4f445516563e939acf8ab5a1d3522de11c50dfeec7bb7"
