# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "50ef217abb57bbba018e693193918f6a"
SRC_URI[sha256sum] = "1197b96fdd69d273d9bb0590b35cef642da385cd80274957ab1ea88cffff17b5"
