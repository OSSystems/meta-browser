# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "13cf40d31e18d2adff8e36fa5f63f085"
SRC_URI[sha256sum] = "59e216264df10ea8dae5e4bad31ed526a1ef49d82df04f0896bca132f00d7a0a"
