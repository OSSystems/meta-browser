# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2903f1fd74005a870a36bbdaf6ac4fc3"
SRC_URI[sha256sum] = "9dcca6698a786eb588caa64ade917f6bf40466f40c3524a21d2237d8e22b9d5e"
