# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3bcbdd876230992b716cae436aae7aac"
SRC_URI[sha256sum] = "c80ee579fcd9c6ad2b9f2a6107eb4ca9c746400be4955ce5a8019081981ce1ab"
