# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "691213c9a45ff071ba49bb1be6aa173c"
SRC_URI[sha256sum] = "2740916271b0a5aaaaec109034a4d39ba030fc686dd803ba186b46679e8197b2"
