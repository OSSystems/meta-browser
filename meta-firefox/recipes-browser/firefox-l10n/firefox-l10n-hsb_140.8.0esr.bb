# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a16cfba9631bf93f3a3b19de6c8bd42c"
SRC_URI[sha256sum] = "eb834af6cd5dd5b4184731ee3b6922b48393a790ddb7f6b30005cff62f3b9900"
