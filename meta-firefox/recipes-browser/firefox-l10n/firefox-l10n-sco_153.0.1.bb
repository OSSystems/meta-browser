# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "8d517b32318c243b32eb806a066063cbe912a38bdc2e85bcc030bd1b8b2ed9b4"
