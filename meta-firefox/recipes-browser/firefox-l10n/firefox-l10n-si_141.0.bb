# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6a820fd1223e80da57163c8545c9261d"
SRC_URI[sha256sum] = "00ed60c8f4e323c7082ac2344477ca1924ff91da8b4155de8193979d8bab38bc"
