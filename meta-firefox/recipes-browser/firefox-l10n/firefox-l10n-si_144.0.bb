# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "63ccc4d3fc32fd80defed788483538ee"
SRC_URI[sha256sum] = "318665dbb142c65b62086f8b85bcd2544fdabdb0e6523e7cfc75edf5cfa527fc"
