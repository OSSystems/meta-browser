# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8711894c9f70408844eb6ac20c8deb2b"
SRC_URI[sha256sum] = "ff4f0c29793fb79822de9a6ad7d84a37386f737924d340a535d847f88a40b5a2"
