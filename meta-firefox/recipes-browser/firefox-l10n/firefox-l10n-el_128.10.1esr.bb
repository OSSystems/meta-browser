# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "18a646a2134495248982b174ec1e9e9b"
SRC_URI[sha256sum] = "a4df743b777cfc5f89722fc4cd3c7a64cce94bc962a7ba40cb6308d8a3366925"
