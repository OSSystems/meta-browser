# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2f5727912e59322053cffcbfb3cbbe58"
SRC_URI[sha256sum] = "34cf993b07a508a232fcc4bb1501a4df9c3d97f50a03d61e266709b079b1e970"
