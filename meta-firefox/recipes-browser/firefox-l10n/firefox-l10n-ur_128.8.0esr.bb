# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8b86ed3db97c88fd9fa0803cc28b5d14"
SRC_URI[sha256sum] = "e533ca06a0cf479af1bfe0ec4b6e92b5831262ff4600d2fabd3d325d63a82ea9"
