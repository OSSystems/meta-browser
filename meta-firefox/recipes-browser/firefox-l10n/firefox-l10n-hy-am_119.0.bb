# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6d668bfb3e7ab2c4c2eee0e20291bf44"
SRC_URI[sha256sum] = "afdb27ee9a5d1564179fed4234c709c705cffb3bf7473a882a8b12638cf15615"
