# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7e60a2d28702a8fc0e0d1f7465be35fe"
SRC_URI[sha256sum] = "bfbaf9d5edfee15f8f57aa15dda69bd04b0940a9c1ffb7a8b7715e692e64419d"
