# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d1b0a3eec3a6b8cc695a518c1e1ae4b7"
SRC_URI[sha256sum] = "3dad94707feb20370252d56e8d903b012cf949ec0075eb0affdf831f9c8bd748"
