# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ae9f46eff200fd2ff268a5a5950f9db1"
SRC_URI[sha256sum] = "97dd8166bfb2a00fa5f07c56c12ad96c67000b92cac418302d4a764a340bc114"
