# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "edd97e53835f7e79d9ac54048d293d95"
SRC_URI[sha256sum] = "3b5103edb658d7c10deb97628375266cd63d9c0d5bd349a642a96090dc651743"
