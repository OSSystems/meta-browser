# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9cbabfa64d741af2ed429ff450ea5a9e"
SRC_URI[sha256sum] = "3923f440e5434125dcb4007f28ee014a7fdb02d9d55c4220ab3318ce2d4df78b"
