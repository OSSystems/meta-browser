# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "78c3e014b9a467fbcdf5dfa3d067b933420ef0993df777a7e0d2532ddedfa14f"
