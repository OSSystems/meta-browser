# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "be51923a644029c54a9595208c60f65a"
SRC_URI[sha256sum] = "2801e5a4bd672ef21c412debe3ebf97297c4afdd2d57adfe789e349ea4ac9998"
