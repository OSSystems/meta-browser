# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "382b90e33302cebdf787467e1e251c77"
SRC_URI[sha256sum] = "b1a06fa8e2b17832e4768d2f23122d49f1a993de5d3fdd0a4cc906ac017a0c40"
