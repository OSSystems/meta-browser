# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c9c7eab14e4de274badf2df6b2dd8aa0"
SRC_URI[sha256sum] = "3f3188c83f80398abf698fe0fb89d8cf35e7346708365a874560ac53c877c001"
