# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "836be4abda282da6fe4aebae4a3c5117"
SRC_URI[sha256sum] = "69c9a3b0a784bdd8e74be6c0e70448fed56b595791eb1f1940415d138d2a1dd4"
