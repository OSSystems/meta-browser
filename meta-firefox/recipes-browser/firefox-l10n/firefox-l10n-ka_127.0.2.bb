# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d76176e41049a8f2f213cd8ea4124c23"
SRC_URI[sha256sum] = "4c022d1f85f8eda8ef6b9bd887d72081a38e33987859954e20bebff984496ff9"
