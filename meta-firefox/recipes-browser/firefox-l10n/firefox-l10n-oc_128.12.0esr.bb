# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f0d222bee8845d42534bd703b50c4174"
SRC_URI[sha256sum] = "3015115e81d979b493a3a2b69a6e07a0cd179d6afa8c53de48125e559b7e4a8f"
