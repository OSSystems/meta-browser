# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2dfd4ed12a3e8daf272f89f952868ca5a5dd33ff142c2d25c48a437c497d64ae"
