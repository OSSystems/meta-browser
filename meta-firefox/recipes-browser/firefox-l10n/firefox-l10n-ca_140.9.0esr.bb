# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "37d3c442c7f57ea95019504979ae72c6"
SRC_URI[sha256sum] = "86ffab416f3ea86d9d9a2167cf6088773fe4367886e9898be17fb3acd6809bf3"
