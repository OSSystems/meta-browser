# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "253fa92241a989000cac2079c69644da"
SRC_URI[sha256sum] = "36c33f27125d242b7874b88c536b8eafd27b40011bcee2d3e49184348e8acede"
