# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ccb1e1c6b2cc182e7561452c9157f5f2"
SRC_URI[sha256sum] = "799a6a6e653f31d5f2f62464075c750c967098f6041462c9ca86107f2a984d9d"
