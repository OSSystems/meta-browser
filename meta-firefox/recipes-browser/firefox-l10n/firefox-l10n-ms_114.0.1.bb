# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db6e6475225a18777f769e874918ed05"
SRC_URI[sha256sum] = "db1c229a4196e62c46271d17cd2bad5371fc6a817c3040ae4cd9a05831d3d210"
