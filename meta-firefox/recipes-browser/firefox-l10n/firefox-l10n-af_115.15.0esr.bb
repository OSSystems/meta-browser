# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "94bd11087104345038d8b6c322324409"
SRC_URI[sha256sum] = "f4d2f944709903e9099a4a112ee498ebfa18362e71e57492ef535baa865a6946"
