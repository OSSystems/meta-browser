# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "571825662c51b75d4967632b7aa785ba"
SRC_URI[sha256sum] = "79485cc8d3149a7bbdfd08484dc3076a923fa619ace5e3cd87c06cd798ac08e3"
