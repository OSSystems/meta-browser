# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6eba7038767b87ef0b02179e0be02294"
SRC_URI[sha256sum] = "075dbf476404ae9a4be4b4758dc09e3d809c7a0d89c2026af0144314898daa91"
