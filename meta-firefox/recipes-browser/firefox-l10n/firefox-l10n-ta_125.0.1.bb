# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "134a9c211047c6d0a51d801d2b3be4e5"
SRC_URI[sha256sum] = "dbb622d28bfefd2026a56c4e4124456ca05a3f09984ef05496ede2332972f398"
