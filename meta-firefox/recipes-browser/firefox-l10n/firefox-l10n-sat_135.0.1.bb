# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "120f8f0aa5bf494907363f3a339538fd"
SRC_URI[sha256sum] = "3f12094e875a34b3419c9b7e2fe417365c32460029b42399eb8821929612c370"
