# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "81bf00961202483c99643a2bbf609aaf"
SRC_URI[sha256sum] = "9efa28e6bd689565f5bdc94f7351308df3f0da38ecd65f6fdee632e2efd37d64"
