# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5f64d74b6ae8dfa07fb69efecc08aa4d"
SRC_URI[sha256sum] = "b008dfc3025ebb95c2683a29b1cd2b8d130f7af75235b24e0f4d818d2b546dab"
