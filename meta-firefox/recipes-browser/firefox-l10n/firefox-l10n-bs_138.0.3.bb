# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "752eb7286740e390399327eca6982d1b"
SRC_URI[sha256sum] = "ade202c6ac5c5ee736ff031aee0691c975fb118624b9ce15de40f2a3a97d88c2"
