# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e47f26bab036aab9d297da98858888ab"
SRC_URI[sha256sum] = "485ec040718617a0c9e8939598f57d4482c431a5e428f2df616d5755e902ac61"
