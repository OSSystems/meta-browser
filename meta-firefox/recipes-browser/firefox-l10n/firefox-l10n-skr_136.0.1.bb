# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "841f274e7ddd3b764d366a3978b9ff6f"
SRC_URI[sha256sum] = "f60d8ccc48397c9d19e1139470a5c7136d054e808fac41f9bf03a72465743e70"
