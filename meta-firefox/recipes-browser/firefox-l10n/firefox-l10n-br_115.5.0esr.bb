# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "37e9439d54028df7150c4e47a8b002c5"
SRC_URI[sha256sum] = "f37b88d8df6c7c50a2455c91c41f3598d5d48c04b8e527607403dadbeae0649a"
