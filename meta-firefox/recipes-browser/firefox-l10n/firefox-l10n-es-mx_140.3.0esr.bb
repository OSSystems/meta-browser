# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2ff65c7f2c4d125f3ebd2296919270c9"
SRC_URI[sha256sum] = "fcc9e0da33391232a660c37bd73a31f94ecfc06a8e86b6c5e41dc5a5c0f44ed3"
