# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2e090dd047a0bc90e81bbdb9f9195528"
SRC_URI[sha256sum] = "9004ab70abacba88929739dd17fba3fd5d17061073e41a5dd1f000a90ab3cfa1"
