# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cca27f74c878c4871d051b476ecda4cb"
SRC_URI[sha256sum] = "0de9918b288fc14007a757e5a1fd1a53629e28fbc78cfb69afc575287e94d930"
