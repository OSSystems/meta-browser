# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "40293c08c8c749ec0fbdc28bc7360a8a"
SRC_URI[sha256sum] = "200b7212f400e3081e5be79e44d72911ac3a577b8a1e61d4b67715a70c8b5067"
