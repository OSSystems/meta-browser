# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "84ea42b131496a1393415c719e1859e5"
SRC_URI[sha256sum] = "022835ec51b806e9fd76151470e3a3611bbed3b94083bc7ab35d23d012dc0d4a"
