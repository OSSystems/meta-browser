# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "204b96770c4399a85e504ab929c54dda"
SRC_URI[sha256sum] = "c8265b3f70dc72f8abd796211ae33fd7a15d52b72e8af70d6d3adadeb874285b"
