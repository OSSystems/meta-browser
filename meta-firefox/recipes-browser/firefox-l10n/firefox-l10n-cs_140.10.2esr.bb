# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3633bea3471b373168271ab624a18e14b17ec740a4e2960600b4cd93f862343b"
