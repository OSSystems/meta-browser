# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cccd6d14b46ca58278629fa6a2bac826"
SRC_URI[sha256sum] = "d9c640c8488fba2278ded8b1372f33b22e178b518dbcb9ef9207bbfefc35c3c6"
