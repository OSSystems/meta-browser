# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "5cd6e9b58866c9aef509d63905ed70d98aadd557826fa832d001e9febd8b8c23"
