# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "362f21284dd941406d3a6073408546e3c72aa46fa5cbd744daf1f7fab2bcd2e2"
