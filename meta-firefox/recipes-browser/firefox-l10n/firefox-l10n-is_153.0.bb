# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "15bc13b6b0cac1de9fdc44bb9474b0825b8a3baf1917439c47cd3caa0bfe984c"
