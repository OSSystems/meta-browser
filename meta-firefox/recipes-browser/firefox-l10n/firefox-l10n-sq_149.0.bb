# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7e6f551b16986e354a7e2a240d24ee62"
SRC_URI[sha256sum] = "ae192881f9488ac346932b8f240dda54f1e31a29ffb92b180be0cb71e7371ad0"
