# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "54c49c6a4ff142ab88f013a9eb87597923657295a2b2935e6834c854442b0548"
