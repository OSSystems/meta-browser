# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7fca46e13439ac057d54ea3241f7da7b"
SRC_URI[sha256sum] = "fe1a43aa7a636923ff218d58576d72f124bc300ac4d39cc480d37f0354d7999d"
