# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "34b381ba8f842d872159d0cc1c345070"
SRC_URI[sha256sum] = "2d2681865b536e159ba3cbcba777bfa2542ff26f3cbe2098d22fa8eae4faaae3"
