# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "36416c493a03cbe8efa56c90d8367bc9"
SRC_URI[sha256sum] = "83c2c98fb9e50c889b9bc5aa80bb4acb3b93de458dc1b73394f8ff3d54147844"
