# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "dfe69d842e9e29ab6029cc010b6da80dec63e0a6bc548ac7b483b27973da60fb"
