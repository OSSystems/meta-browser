# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "297a871a95848dcacda735b6994d2f66"
SRC_URI[sha256sum] = "82f1b922efa44d50521c105fc357dcff8f5a5656a22ad43e0071957d3f0f8f16"
