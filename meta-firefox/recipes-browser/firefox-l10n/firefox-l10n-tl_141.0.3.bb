# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f91c25f4ef1d2b1d3975ce5b1aefcdd3"
SRC_URI[sha256sum] = "6522887c3a938f3deff0f796572721bd888099e3233f339e1509fad5abdb1b20"
