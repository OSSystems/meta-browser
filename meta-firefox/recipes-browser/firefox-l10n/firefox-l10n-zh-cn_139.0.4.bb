# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e21ad184f36e517e04c4fed7219a9b6d"
SRC_URI[sha256sum] = "84a6cc8f011375e162c7ce4585cf1980afc8a93d4ee1db379f49ffef39874305"
