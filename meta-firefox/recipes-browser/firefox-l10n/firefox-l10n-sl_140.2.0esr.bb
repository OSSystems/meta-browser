# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bdf9c80b5e21b97c944ca9478a3332b9"
SRC_URI[sha256sum] = "32cb6be6da6f1479dc89d7f1527be48c6d352279aad4d4b7e9f0ea04aae0c337"
