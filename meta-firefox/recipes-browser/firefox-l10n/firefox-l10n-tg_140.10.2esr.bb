# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d1a4c7183068e00694f10318d2a7892ebc04a68bdabd3222995c60169ebb7fbc"
