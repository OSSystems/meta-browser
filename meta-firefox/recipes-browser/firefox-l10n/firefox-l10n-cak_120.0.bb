# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a625e74e3ed16a031f38e00fb087c5ef"
SRC_URI[sha256sum] = "b1f7d6daa21b4467a55875414da59c0bc82d8014c54fd186176248ff7147630f"
