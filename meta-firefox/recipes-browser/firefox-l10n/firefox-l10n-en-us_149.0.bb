# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0240fe497f86aaea680b117b73c0fb46"
SRC_URI[sha256sum] = "f6ced6b06c708d6fd8d862ae011866bf6fe757d04225ad601d91714959884781"
