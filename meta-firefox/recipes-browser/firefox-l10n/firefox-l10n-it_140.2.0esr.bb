# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7ac37a86d6250b0bc2b537937cdf3126"
SRC_URI[sha256sum] = "25b4b3f9e80e7e493477cfbd737c66f8b82c2d102ecbbfad0d49e48fb46dc514"
