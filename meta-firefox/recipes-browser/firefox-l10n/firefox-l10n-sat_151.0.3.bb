# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "b1dd568a3e3c105093c8e3fa8a22935138e1fc0a5136e73986f6f81b1fcb1300"
