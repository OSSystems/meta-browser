# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "f3ec885d4a5007a296ef10c7e495548b3c8be74fd2dafbd9c2bf629019e234a9"
