# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5354f4584d73a6f4c61f958e78084d86"
SRC_URI[sha256sum] = "391952ba4cba61fa2bfdafc13c3adb3a85ecbe8e54e1ebed4da620d70843f8af"
