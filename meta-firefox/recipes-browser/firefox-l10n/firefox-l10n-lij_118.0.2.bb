# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dee4896824fdd9dc1c6df5274be6237c"
SRC_URI[sha256sum] = "53065444dfe7e24ed72393e2410d8e129212017e2efa7f8bc3a303a135e0f85b"
