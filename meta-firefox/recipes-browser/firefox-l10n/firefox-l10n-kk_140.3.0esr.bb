# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "565274fa8ca87ba608591af05a010e2a"
SRC_URI[sha256sum] = "3549c788af23a13df9a2e2e411a7a7895dbb03b79e83a614c1ee28ca59b4c289"
