# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ef973e6182cd0f0fee0d5fb12257f49d"
SRC_URI[sha256sum] = "a3f4f003964799955f138a854bbb484d20b379c8be8c3fa1312cacfc411b560f"
