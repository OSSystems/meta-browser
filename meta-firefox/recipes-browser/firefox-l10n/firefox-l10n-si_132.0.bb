# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0b645c36139f5dc0195637e0ba96c95f"
SRC_URI[sha256sum] = "24892012367bb1b694e7d33503a117a233d64f4db8bf5421386df130341c4833"
