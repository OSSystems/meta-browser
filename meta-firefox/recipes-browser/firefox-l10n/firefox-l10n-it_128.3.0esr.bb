# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a769470636bbfd448ddd5dbcba03eb30"
SRC_URI[sha256sum] = "5e38d5ec43d79d7c422a87de3463f6e072befe26acf32b7373bb0050f27f3d21"
