# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "10d54c8629bc332f21cf285199a4e09f0eb3f3ea85b6525442194fd0244740d5"
