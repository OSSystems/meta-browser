# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "23971d5cba27dbaacff95074e829550b"
SRC_URI[sha256sum] = "4d5f99c038c3c7007b52da563ddf6740ff9910a4e3302f88140f6d158c6af00a"
