# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d80a98c577a2adcdee376fff9c96d866"
SRC_URI[sha256sum] = "6978251cc731cd576bfee39ea2923cd0bbefdbee463e69471b23ea9feb70cf42"
