# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "888437b58f23aab7441e951cad3a362d"
SRC_URI[sha256sum] = "7e5c154f6e5337f5a941bca29aed8668ebb10407489b44940f0012065296fbc3"
