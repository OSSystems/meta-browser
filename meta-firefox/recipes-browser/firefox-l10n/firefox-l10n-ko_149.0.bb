# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "55a1a027bf74f678bf40d8d2f1bbd1a4"
SRC_URI[sha256sum] = "0016429eee902b0c6b857739db279949d637341ecc79b90132e8af0273e0f4b8"
