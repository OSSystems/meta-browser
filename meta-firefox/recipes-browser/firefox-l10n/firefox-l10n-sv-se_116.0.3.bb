# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9dc03d09dd8ed1baf0a054b738008dfc"
SRC_URI[sha256sum] = "acc32933cfc1587b9509049d3b1e4a33761d6f88a487dec4a349baa65160b1e7"
