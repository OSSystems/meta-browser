# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "616414ff1ad701e07559648dc57cea43"
SRC_URI[sha256sum] = "29e3fbdf8342aef16a66b88e4c5a25fa9c74e973f8353bf8a865d310f1af03d4"
