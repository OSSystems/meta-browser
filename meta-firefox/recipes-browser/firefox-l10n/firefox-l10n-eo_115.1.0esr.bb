# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6e816673e63f4ec3af85086eff4c6e7f"
SRC_URI[sha256sum] = "e224c7bdbd86e295b2dd0fcb22b42c74c847165ee40ffd309a7fef52fc303a6a"
