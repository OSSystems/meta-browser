# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9b9f2a583369e4341e669370b5a3ebe8"
SRC_URI[sha256sum] = "fc4609d0e079d49bcf5cf378f260bf4402e423263916152b04da102551032ebd"
