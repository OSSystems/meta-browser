# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7a7301264363c943415507f0dd503b66"
SRC_URI[sha256sum] = "b4e2bda4ce94608477c480b6f8ebb382c48b7250b1cefa1974581488619b7302"
