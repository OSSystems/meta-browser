# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9996724b1d4647e3384923a61ccc9ab7"
SRC_URI[sha256sum] = "fad77785b616122c510ab78f1003427cf19922a7acb3cf9506323872b232cc52"
