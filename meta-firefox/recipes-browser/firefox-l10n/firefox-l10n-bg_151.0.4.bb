# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e1f100b140ee9e6172f206854d61a91fb1ea51bae1c086ff4d7387d4634a36cf"
