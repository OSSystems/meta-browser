# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4d007af3e1b9279073e440a74d2d1e09"
SRC_URI[sha256sum] = "68ac12f4df3a295a76c7f2f90dfb450e828148e99724b08586ca75b50b369066"
