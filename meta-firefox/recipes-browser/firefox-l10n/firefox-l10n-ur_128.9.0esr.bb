# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "813b1794d38971711659a86b1e19858e"
SRC_URI[sha256sum] = "0091d96f9c94d76d70bcaddf14060858357e700510e1b1d050c0231cb72c0a64"
