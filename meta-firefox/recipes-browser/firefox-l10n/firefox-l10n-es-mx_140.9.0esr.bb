# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bc3520207e110aa3551d6026f53c907b"
SRC_URI[sha256sum] = "e9ff5239e204e65c183835dc143ff5185b4c4508db1ebf7f3ce9825686980136"
