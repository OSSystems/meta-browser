# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "69a58a4c5d91027b1c5b26cd28f315c7"
SRC_URI[sha256sum] = "19cf809bf7cc6eb8f986978c8cb46cc307ceb394bbcad2e1431de10a061061ba"
