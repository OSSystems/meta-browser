# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9d68bb8756f3287fbcb39722ce7c1b31"
SRC_URI[sha256sum] = "9aee7addaeaa95ab45c9982dc49d0c7e57fc7c48a069abb561d40e1d5988ec85"
