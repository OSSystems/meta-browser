# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9dc0a0df49a2998c46f5d804b09b9d99"
SRC_URI[sha256sum] = "2bfc604c0acc9e0193e81a3feb35551697d0ff7298b9da26d79d89fa11599fa6"
