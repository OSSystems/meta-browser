# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fee7b777b828ceeff2333045e17567b4"
SRC_URI[sha256sum] = "0329145aa545c9c43a64b1414e0aa20f67129c785a096c3e88b4fe55f94d40ab"
