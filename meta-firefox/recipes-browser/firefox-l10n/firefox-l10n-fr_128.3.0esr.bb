# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cbc83445f8c10df376b3345c38d8583d"
SRC_URI[sha256sum] = "00da53c466158cfe286df1eaf276b6071b2e16c3932cd442b166bf8549542e26"
