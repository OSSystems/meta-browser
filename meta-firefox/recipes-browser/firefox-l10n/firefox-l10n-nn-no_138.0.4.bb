# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d59e0c60353ca445dd496873912d9117"
SRC_URI[sha256sum] = "4f5dc33e46710b6069e7a9e4a208fe651e2cb0246fda8de20b86ed9c2f89863b"
