# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "45d1e79f4f9d871652f8907ded0462d8c68f797ef1bd89030ad47cd6983d9b8e"
