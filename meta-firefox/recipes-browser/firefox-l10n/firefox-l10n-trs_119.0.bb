# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "26cddcfde1a8d0cd0474d9a4062d5761"
SRC_URI[sha256sum] = "d3aa1a6a8c7b68db6cf8084714c278440c478c5caca2c7623377e27e2e571064"
