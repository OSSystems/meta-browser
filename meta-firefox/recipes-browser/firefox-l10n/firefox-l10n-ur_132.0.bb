# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0819fe3b7203808eee42cda044bbb765"
SRC_URI[sha256sum] = "f511482d0df00654efd0090facf3c720b4c3884282c7d3cc8b9cc8d679cc2bd2"
