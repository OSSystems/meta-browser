# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d47c5cdae19f86e74e12ab3dc6c56740"
SRC_URI[sha256sum] = "81dcaa67f1a570d662ed9429f22f5c514600c522a812eeb46fe5380e74373c73"
