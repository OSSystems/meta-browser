# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "61c71ccab7ceb7025722036917112ff3"
SRC_URI[sha256sum] = "98b5e1c7c9cd8992f7cb194900d6fafcf0df30b2c284ef0e0531fa16ad6d0607"
