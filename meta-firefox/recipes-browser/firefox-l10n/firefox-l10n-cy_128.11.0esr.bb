# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ba5944e1fc76f12c918aa13014e7bd17"
SRC_URI[sha256sum] = "f42e7984340b8252f88497eca4a1dd0cc301021690e467efa9d8e5c185af9747"
