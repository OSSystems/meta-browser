# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "47930d1682dc6a36671f0381619aa77f"
SRC_URI[sha256sum] = "491b13fdd6ed8c5c5321d5ab4b0fa21472cc13741b5700e2b74cdaa6abb4171d"
