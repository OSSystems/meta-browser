# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "854f5b0880a5bbb8c7ce0e55b27041be"
SRC_URI[sha256sum] = "84014fb5931a785a5b3613cb3e287000e9d7be58cf25340a5ecbf4c119b3ccf6"
