# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "26502dc8cd11423fd829b57da2c443dd79dff7dd27996b495e677db1d4301ba8"
