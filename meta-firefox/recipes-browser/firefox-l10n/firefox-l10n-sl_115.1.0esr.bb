# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1d31d08ecbafdc1522a11b7fb4abf972"
SRC_URI[sha256sum] = "49fb3fe7801ec95e526be062dc4c44c2d67addb4cfa4db5b5fefa7d6d405db25"
