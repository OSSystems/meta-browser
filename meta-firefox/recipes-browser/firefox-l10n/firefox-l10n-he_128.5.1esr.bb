# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "06aa5755597237f1cbab33901b2c3068"
SRC_URI[sha256sum] = "98712227726f1d943f836a768e251370ffb292994830676ce9c73da79f7956dd"
