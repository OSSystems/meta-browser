# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "709a35f3500816260b905707cf86e284"
SRC_URI[sha256sum] = "92ab0112ab68114d2a7b106d8f44e8d90a150000271c9672a125a7b86ed732c6"
