# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "030cc1ee7be6527406cb384ed5f25f6f"
SRC_URI[sha256sum] = "7fd1fdbd4e4916aa0bab2b9e38d01f3364c11de13749d58b71fb81d1bcfa1465"
