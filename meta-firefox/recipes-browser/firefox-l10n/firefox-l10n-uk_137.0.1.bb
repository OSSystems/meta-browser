# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6c8c3a0bab66ecf44427899098b6a9c2"
SRC_URI[sha256sum] = "65ea6fd1b02befc5486840e80cf11706ad3c751e5e65a29088e0472d34467316"
