# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "56402586006e3361235f0b9be55b94ca34944a429ed6e6676ceda6d66a69e696"
