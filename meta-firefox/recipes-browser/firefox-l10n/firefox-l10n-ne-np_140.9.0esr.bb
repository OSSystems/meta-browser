# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1f0f9dbe23964e3c575cb6ee6452a0ab"
SRC_URI[sha256sum] = "d114847fa7223c793901434378639101c3b31fb35c6213d06f00f8c1cb627112"
