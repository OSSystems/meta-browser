# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "134f87573e04ca7712d83cfdbe81bca4"
SRC_URI[sha256sum] = "02498c3dfaecdf7159171ede9d81e09d236f70ece8a78a359fffca35c9120e1c"
