# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "003eb9c1f777abf6746d7afba8d8fc8c"
SRC_URI[sha256sum] = "7969fbd6719394834b30a4cd44864d03f222306f40daaa2ec5039d0adbfccb5f"
