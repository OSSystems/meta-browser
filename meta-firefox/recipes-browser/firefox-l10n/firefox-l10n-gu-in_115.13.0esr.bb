# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1333ad2334b957354759cd478bc11f20"
SRC_URI[sha256sum] = "c30ed96b4e5b6ea6c604fcf89d5726d2b61da3570231d106ac0baf466a4a7ef8"
