# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "44f088fdb169ba530ade7ba8cd62e142f6aacc25c7c42e6abac9548b6de1981f"
