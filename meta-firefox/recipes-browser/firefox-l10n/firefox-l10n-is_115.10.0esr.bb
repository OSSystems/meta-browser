# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "43017682c3d2add3ea9427a68b7dda2d"
SRC_URI[sha256sum] = "a1f521aa41c75ab17f46a40c5201ec736f69a4f49ad8c3fda8bee8499726a437"
