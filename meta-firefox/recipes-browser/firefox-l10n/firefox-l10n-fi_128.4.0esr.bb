# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b25bac9b974333621adb2aed192eeeb0"
SRC_URI[sha256sum] = "f9fe78d0f689a071d95414b412bd9b216cce1e4dc2a972dc29126d2f11a75c03"
