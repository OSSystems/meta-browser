# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5c1cc0ca364dcb36b6a9c41067cc216b"
SRC_URI[sha256sum] = "ce199e785b5958e51d4b2e037e87b5f80de27c87503e90a949d84afbf4bec4bc"
