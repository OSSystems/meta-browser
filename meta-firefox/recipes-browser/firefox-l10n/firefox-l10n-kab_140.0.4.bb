# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c3b4aa83353b6a2b66e9e63826666cec"
SRC_URI[sha256sum] = "36ff74d495e35447dbac8bf1a1274005a214dc3d9dd5b5b9f17965e297816961"
