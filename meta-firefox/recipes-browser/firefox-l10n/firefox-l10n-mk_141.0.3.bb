# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "130ce7bbc89b65a69eb683c29152407a"
SRC_URI[sha256sum] = "e44727e491128b6a8f046447c19b4f71a05523e7c5cd82088d51e942310703e9"
