# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e8463d8756068fed9da1cc611a0260e0"
SRC_URI[sha256sum] = "cd0c52ecae12e7ea65aad15c1d36a3d3e2602b40c5ef7ee5456a52ebb2b62160"
