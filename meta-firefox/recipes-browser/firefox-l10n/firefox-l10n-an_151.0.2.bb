# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "0e85e629bfafc3e7d6f4a54c4004abde86a90a56cdb602710a0dcfe0c31dcc36"
