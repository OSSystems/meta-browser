# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "93cf0e00e51453d7c42efd1dd926461b"
SRC_URI[sha256sum] = "780957630e22c54916e3fd7a8f72a1b20b86204506f1cf51a12895e803a8c3ee"
