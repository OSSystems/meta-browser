# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "81cc98d0e338a92fdd5249d4b58616e4c3b572492c6785e40b6eeaf8d0dc49e1"
