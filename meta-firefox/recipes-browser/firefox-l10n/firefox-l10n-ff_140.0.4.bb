# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6d3eaeeb06f6bfc9322cbe7e100d6d02"
SRC_URI[sha256sum] = "31f67a6b206b776fcfa4a17ee11838e61588b7c8a2c5f1e47cc0b1b22c38f282"
