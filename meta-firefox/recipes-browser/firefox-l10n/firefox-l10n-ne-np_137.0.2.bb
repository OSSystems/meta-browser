# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e0d39be0467ccccfd3626520ce120216"
SRC_URI[sha256sum] = "00ac447b4efb67aa867f677ccb3dee2353fb509c26d32661c4fe836d563909ea"
