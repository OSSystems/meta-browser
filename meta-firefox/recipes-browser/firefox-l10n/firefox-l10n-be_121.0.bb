# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "18ec8f07d392c5406aeee6593d469348"
SRC_URI[sha256sum] = "4fd8d430dbf5ca2c74d21db49364cb44052eb497ae48828bbec840cb1f8ffc06"
