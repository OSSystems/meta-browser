# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "10ee0619d92064bb9ca0fc83eaf140e92bab3def388bd88aaa30770d990b7a76"
