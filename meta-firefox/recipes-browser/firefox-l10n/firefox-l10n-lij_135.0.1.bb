# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "03a4c62d917ddd08d4bda61751bb21bf"
SRC_URI[sha256sum] = "9127468e3ff1506313af5e8d579030ffdafa9ebd245f84367125b84b533c2187"
