# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b179dd6093f3d0b321d58dad36d51eb3"
SRC_URI[sha256sum] = "c5eacafab7adc204be52a3091b2584ce65def5491be816f9bf9e58e6a5f365ba"
