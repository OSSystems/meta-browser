# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "78654c126b888c20d3524731a7747347"
SRC_URI[sha256sum] = "8cbb19be279ffafd4a6b884d46c69462de4b933ee5b98e1eb2b5b95e55f33cd9"
