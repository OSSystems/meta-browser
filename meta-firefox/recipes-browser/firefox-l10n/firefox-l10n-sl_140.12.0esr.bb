# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "befbcbcf621084057867486df4e58a8a375dcff4d9df2b673241ffc59904a024"
