# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bb7ae5e73384e5b40de92d18df4cd6fc"
SRC_URI[sha256sum] = "d9363f52186d61f629c4ab848999d66b31ff2cd76858f6ff9c2e08a9f639aad1"
