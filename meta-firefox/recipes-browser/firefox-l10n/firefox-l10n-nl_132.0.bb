# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2b1bc8102afc56eda4a092c8983054cc"
SRC_URI[sha256sum] = "09f42d48525181b5e29715f0aafb3e9ab261843791ff1cda0a810d5569754df4"
