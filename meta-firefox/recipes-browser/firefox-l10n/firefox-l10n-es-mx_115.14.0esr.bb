# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6771a8471d69e4bed92a9c189258bea5"
SRC_URI[sha256sum] = "1890bd9bcf167bf711020b6ca87ed5c476f8ef7ef8bc8db1379134993b2fe67d"
