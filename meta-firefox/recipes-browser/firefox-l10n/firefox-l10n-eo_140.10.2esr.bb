# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "9590d056cf39ed2fab4da2be22dc1060811331f09253594fb3c9fc210d84e2dc"
