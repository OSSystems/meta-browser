# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bec3c4d834e38a17209da4d134c9d073"
SRC_URI[sha256sum] = "fc8d38c118a32f78f9a63e2419db6fc8c7fdcaefd9dea689ce1ba7bfd1fd0607"
