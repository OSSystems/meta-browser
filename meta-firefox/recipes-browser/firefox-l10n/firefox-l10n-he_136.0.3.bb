# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9c434df7347197e6e916c12fdeed9027"
SRC_URI[sha256sum] = "5dc54e6abe17346721279aea7689b77b9d431c115f54aa7a6413086800159a32"
