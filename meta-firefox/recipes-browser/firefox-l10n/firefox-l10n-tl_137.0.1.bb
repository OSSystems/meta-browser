# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "21109219dfd47b8f9c6ab609ad3adefe"
SRC_URI[sha256sum] = "562c2a147c443668a004dc006b794e38bc54e07c2372616692bcede86f507977"
