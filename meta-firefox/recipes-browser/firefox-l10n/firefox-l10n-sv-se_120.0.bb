# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b406fabc15265f64fffe8c99933ca4df"
SRC_URI[sha256sum] = "e3c39c4c411969da5e61152485830fcbb0f2314a0e4fd4c69efe55c0d4c6e97b"
