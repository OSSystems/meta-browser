# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d80fc856bdd93931d236a80d197f760d"
SRC_URI[sha256sum] = "4d8e3645229471ce578b90a79c85941a7f4d39756a9e8ce3f65f7062b17767ce"
