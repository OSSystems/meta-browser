# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c925ccde023b5d8d37414800acd2b1b1"
SRC_URI[sha256sum] = "1403b213554a699a6b7df29d08b564ba51c32c3defef9cbf22322236f20b310a"
