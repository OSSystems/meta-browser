# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "468a3f90e64a38b0e392752b954cff03"
SRC_URI[sha256sum] = "00988efcf35fedba81501b47090c931cd1622b7934cb3355fc0e0cc49b2d8d23"
