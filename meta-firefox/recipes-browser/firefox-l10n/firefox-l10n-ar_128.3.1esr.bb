# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7a32436d2998d7ab5fc0f06f61bde59b"
SRC_URI[sha256sum] = "6a2ff21c9dbaffacd06d20a4c15ae4c240db855355ab4494a2fc1025e2d7c422"
