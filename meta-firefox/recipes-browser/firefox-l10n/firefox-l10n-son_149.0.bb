# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a230a53e8d787f9469ccc3c1ec2f43d6"
SRC_URI[sha256sum] = "811f99af6695cd752ae169b6873b18411c138bb55e1cc6018137d760c3936335"
