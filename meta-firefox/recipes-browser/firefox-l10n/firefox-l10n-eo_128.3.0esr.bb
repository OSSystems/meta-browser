# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6dd35bec93b2cc637d77a9e7d9143986"
SRC_URI[sha256sum] = "7f2377233e01d7772f0be919de28830d24ce447450517cea10c13d36daf174ef"
