# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "78bf9cd662c7d8c477a9da708eb09b0a"
SRC_URI[sha256sum] = "d3e3925ded9937554d67b8ca37ac784ca048901f5f73e7af9b6713cea1180e93"
