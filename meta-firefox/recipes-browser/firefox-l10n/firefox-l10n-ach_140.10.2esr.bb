# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7b5cd75f1ae57499dd6d9a479908efd4de6acc4e92c45e058fa369d85b0fa401"
