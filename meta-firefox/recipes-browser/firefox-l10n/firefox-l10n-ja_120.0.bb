# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "71c8df044741a4b483db1c2b6c27a033"
SRC_URI[sha256sum] = "d4a5af38bfb0c67c94241a6ab974728d5a66fabec17768b5f7a8936d1028e838"
