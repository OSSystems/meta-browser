# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9a2dae41ebebcdb4b49d907047edff09"
SRC_URI[sha256sum] = "455ac5dfeba7a456b61cc8e7a2c1eabf7bdefde88583157bd45654760e15be00"
