# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2502bf3215a7582fca47eb8dfb042eda7206ea3052508a09f5dd47d5545f28bd"
