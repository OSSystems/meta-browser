# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2686de1a6fadc3ebd4563709453c4381"
SRC_URI[sha256sum] = "1616cbf061d84ff9722852088a0c3e0a5e61b95241f8fa4e564f7b8c6361ee47"
