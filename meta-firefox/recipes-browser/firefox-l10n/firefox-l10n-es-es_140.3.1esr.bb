# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1ccb7d054ee42ccfa25be4bfa840cc5e"
SRC_URI[sha256sum] = "47e0d11ca2bb57d4c2ea164cbc9007e3f01fa60b6984c5b3380db98600185932"
