# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6532275bdb070dc9ca42e708c6822bde"
SRC_URI[sha256sum] = "6da29d282357c481004c269f18dc9274a09c9df2569c8a58db276db020db9059"
