# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ceacaa5febaf2e6dc36dea7bbbf1576"
SRC_URI[sha256sum] = "ef4a91f53be658ac6e274d365bf23195bbf3eb18eccdd04076a3986e13c78fdc"
