# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7797651d318ed7e35a9621c20c4f88d9"
SRC_URI[sha256sum] = "04b7ab7f0fb86c6b12c940b641d81d7fb35f105b8af3c225c92b393933812b32"
