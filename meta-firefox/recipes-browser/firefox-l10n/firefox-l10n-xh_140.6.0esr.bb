# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9bbf5035859b212a63dc5ec54ccbefa3"
SRC_URI[sha256sum] = "f24de02c29567325c8cd85e72ca185474421baa86ea3843730c4c1569b2938fb"
