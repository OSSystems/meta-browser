# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "87bef32032d7d71293b86e1779458c7e"
SRC_URI[sha256sum] = "b39ab64094543189eab1dfec1976d74550aedbc656aa808cb6c302a352db3b31"
