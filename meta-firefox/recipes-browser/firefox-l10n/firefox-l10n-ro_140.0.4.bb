# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "362ac872faea712f285ab00c675f14b4"
SRC_URI[sha256sum] = "4bb285ac718e21313e5d08817562edcd7b0420eaea0354dd0adcfbfc7de17924"
