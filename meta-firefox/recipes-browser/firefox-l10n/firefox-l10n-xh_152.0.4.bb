# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c14a92277f8af2a4fb8ecfb979dbd1a178a2e2e799a345607762056976d7fb01"
