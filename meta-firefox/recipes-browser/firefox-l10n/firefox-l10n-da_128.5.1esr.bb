# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0ac9d59de9401444ad7861a9c1ee2f94"
SRC_URI[sha256sum] = "55410e8dae198ff368a1cbadda849666b65439be13a531581b1ce649c0f48b70"
