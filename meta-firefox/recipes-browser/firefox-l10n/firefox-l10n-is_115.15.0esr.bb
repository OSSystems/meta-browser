# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3012b15b09cfd056a25cbf8e000b2f16"
SRC_URI[sha256sum] = "5776e908676b153587b552be323682a6a7f909c962474c098b76efc2e653cf64"
