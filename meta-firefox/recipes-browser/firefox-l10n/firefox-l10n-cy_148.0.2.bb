# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "391f402f3793274f2ac5f07db8fb5160"
SRC_URI[sha256sum] = "16c3cd5ae0e4e4ae6a251430650b81e7c42d76562d93d92bc1ea517971177791"
