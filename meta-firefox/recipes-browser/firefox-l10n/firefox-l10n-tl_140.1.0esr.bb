# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a8e39fcfac7bb32f735ad8233d3db2d4"
SRC_URI[sha256sum] = "fd478c52b2c0a7c5b9bef633c7b0e43556769e3ad9f20fdcb8f445bcff75f0b5"
