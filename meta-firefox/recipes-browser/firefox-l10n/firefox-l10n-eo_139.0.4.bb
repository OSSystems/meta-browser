# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "782795c317c98b292da99a95436ad5f3"
SRC_URI[sha256sum] = "ba5b15c4d45ed63f260a0170a3bf51dde2a2e4d417e9f90dca46c51524695c9f"
