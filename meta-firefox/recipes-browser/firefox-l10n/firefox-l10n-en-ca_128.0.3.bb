# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9798a55fb8f57cfc9d3a12b1440a6115"
SRC_URI[sha256sum] = "e570223f120640f0b2c0fc0a029290c8aaf7e10c3df28413b224e3494c714047"
