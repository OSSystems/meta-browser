# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c758b948a88ec57fbe2106251a0a2f313d750ff80b44002b0f96af2136bf206d"
