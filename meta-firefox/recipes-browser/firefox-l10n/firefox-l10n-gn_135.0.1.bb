# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0cc20cafd92746333515e4c91d80c2e7"
SRC_URI[sha256sum] = "59df49c9ebbd200d01d99cb001a7fd5c95f00812b95a3e4f7110d306d756e8c4"
