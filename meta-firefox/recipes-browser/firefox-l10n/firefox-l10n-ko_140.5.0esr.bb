# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "92085c562a2527df37e95b50603c26d4"
SRC_URI[sha256sum] = "c24fddf0dfabbb67bd02115a6556dd0571b3309e12b2f519587033e40814bd88"
