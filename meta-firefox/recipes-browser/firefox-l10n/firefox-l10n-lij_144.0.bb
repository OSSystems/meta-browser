# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "99a7ee21e24520dc4bfccf6cb0acc359"
SRC_URI[sha256sum] = "55a70ce8091fa288edf1ad199e29171b6f540c0bc6c4c6d598c52b18396de44e"
