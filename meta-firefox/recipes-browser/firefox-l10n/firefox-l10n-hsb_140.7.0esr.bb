# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5e1b7acde2b786fa6538b4ade41d2827"
SRC_URI[sha256sum] = "597b35f941e4be4540ae736a473a3174d76b6425c1331ba495d5cfe77297e8f4"
