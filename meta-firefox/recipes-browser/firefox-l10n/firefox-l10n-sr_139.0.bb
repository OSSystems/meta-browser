# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6bcbfa902a09dc28a5fb3e4d1b485c25"
SRC_URI[sha256sum] = "9f00ee9f0135c83835839b33dd13114115c9de75ff67e5e64c6b0e9586976d40"
