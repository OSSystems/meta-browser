# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "569d60d2deb5d7693d7625d6e8f34554"
SRC_URI[sha256sum] = "a9892bb5926c0c676376d44c5869a975b5c6d519823ee1476573e5eaa8a4b288"
