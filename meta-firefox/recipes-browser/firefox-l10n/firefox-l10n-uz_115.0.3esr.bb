# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d51f581b08bb07cf6c292831835d0679"
SRC_URI[sha256sum] = "e924f27b3769009996e4a83fd2eff4fc62513ff46e496eceffaa9d2e8d3c02df"
