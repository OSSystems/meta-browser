# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7cfa4218c44d465e57f6333098f34255"
SRC_URI[sha256sum] = "bcdd94d5af73368c8e81697e40d11c92960972b2ec90d8673c791ab213327555"
