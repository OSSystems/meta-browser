# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "59a436b3bd307be3be5aea6ce77a5c4e"
SRC_URI[sha256sum] = "f4fb6f6a8673dcd04433b6b6028558705215108297bf73e9843c5fa103806513"
