# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a28316eb628eaccd7b8f4d44b3454502"
SRC_URI[sha256sum] = "41a9c00683aa7ae28e2730f2eda3be3182999019cc2ace62659f6212f50cb656"
