# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2a832e501f8329e4538762a4164aea02"
SRC_URI[sha256sum] = "76b1bf5622145efe761cfdba74d38dd947907624cf2ebf77fa7e68f0c20c40b6"
