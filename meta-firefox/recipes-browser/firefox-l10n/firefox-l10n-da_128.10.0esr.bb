# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6a6cc44ce86cef547ad9994be47ce577"
SRC_URI[sha256sum] = "bc49c5baaf17102f58787e30411e383b91302a4518a465a69fec4d8969cdca7f"
