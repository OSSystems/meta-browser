# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "05249fb62518e3a1a58f465826355ffc"
SRC_URI[sha256sum] = "abd7a9f28e0ef6ca2ef7f3839ef05385971049a321a6841d2c10acb6f18a7dcd"
