# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "20cb348aa032de718b1a0799b08fed04"
SRC_URI[sha256sum] = "31c0de60e5bcf34b09197c3b608880f9b6342b984635f24fa9e6f4777368acc0"
