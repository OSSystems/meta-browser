# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "8e00824f1ebf8ca09f634f7489af0ed4784e40e17d28a6d276cf36f5134a7545"
