# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "94312c81a3ba048c1fef69ecf810b492"
SRC_URI[sha256sum] = "a56fb5374e436d1f0ebdd1d70a1ab117ceef31a035bd5110d0ff1393faa23a8f"
