# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dbb84060da5d25041e15d5fe23d931ef"
SRC_URI[sha256sum] = "4c5568f8ffc1c19c1ff7fcb64a25ebb70bf5d290b1cd68e63dadf27e2c63b8ba"
