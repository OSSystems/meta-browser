# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "19fde2275903419668687eff14d608e4"
SRC_URI[sha256sum] = "af0ddf54568984244585fb79e5ace8b66133f916e670ddc29d56cf14f346c8b5"
