# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4978b40a66b5c9ebf1d7eb7fe5156b4f"
SRC_URI[sha256sum] = "dec14b35cefba7aff24d8bed07a8cdaf5e4ab50bd3f212bcda7f8c3b0e100111"
