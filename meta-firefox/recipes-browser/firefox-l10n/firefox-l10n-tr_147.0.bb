# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cb84938223576e53da79f78cca208e79"
SRC_URI[sha256sum] = "2da01115c8b35a185d6718c9666412503b37510ebcb8210bee20ac8d3aad8fe6"
