# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6bb5450eb738669e645eda01a3f24bc9"
SRC_URI[sha256sum] = "49d481e4ead48634d0f41d634e11f83d3cb3847dfbb327a1ac4da061e05bbd15"
