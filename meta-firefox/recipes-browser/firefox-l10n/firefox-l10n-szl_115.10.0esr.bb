# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c5aae928828a013a3197b433e8bf098e"
SRC_URI[sha256sum] = "5774229364033b8f7d7472bd947a4452eea35b42ba1d7e9b09ac8935298df137"
