# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0e6922620d9c6c759635820e95496297"
SRC_URI[sha256sum] = "2b1eb86bee579186be082f79b5332638b0bf857571aa9bba6f77071c002029d5"
