# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4d5b0d98ce27935f1921ac34134af82e"
SRC_URI[sha256sum] = "75487b57497f1ae3094844022d1f548fa588910bcd3d0daf567ebe6cf67f04f4"
