# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "07f0e9c8bf6059b1d0f1c40023bb4de3"
SRC_URI[sha256sum] = "33ea597a84ccabaef2bb7a87cb8ba854379917baa8da991ae29e5382327376fb"
