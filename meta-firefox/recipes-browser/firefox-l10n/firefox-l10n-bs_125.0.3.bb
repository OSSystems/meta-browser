# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cc5ceb96e3b21f0213088db2021c5c16"
SRC_URI[sha256sum] = "31514fc5a6e8d9ffff5272ce47988ad13391532500746e5ee79c79de6914c791"
