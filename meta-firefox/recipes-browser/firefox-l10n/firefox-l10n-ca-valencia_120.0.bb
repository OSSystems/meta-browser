# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d6d5e9ea81ba595b27a6a1c74540a612"
SRC_URI[sha256sum] = "8b36980740297b650837cd4696edce9be16dcd63f322a46528fa4e2ff021c610"
