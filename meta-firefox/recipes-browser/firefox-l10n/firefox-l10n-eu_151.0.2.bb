# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "124ecba8b43c17c9c816e61ff5742d2b2f374fee391045a083cd0af1a56b8a09"
