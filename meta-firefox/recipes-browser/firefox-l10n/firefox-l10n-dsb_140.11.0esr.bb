# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "0be7219d7fd0eadf1bfcf484393198b84b92dc6af505ef2ec4aa9b2e1d1f4698"
