# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dc5c95d66886efb1e65111bbda30a21d"
SRC_URI[sha256sum] = "d9b236839c113c349da9e728fbe3e8bedff9a9a3ef8c64fe3df97a32a08402bd"
