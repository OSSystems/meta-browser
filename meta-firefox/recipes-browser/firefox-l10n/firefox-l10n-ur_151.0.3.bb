# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "31025a9fb875a3861f256f9888ab6f09070df372a20d52061bc39598ca95f261"
