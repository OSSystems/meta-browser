# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ebfc4fba9b77fd7e77b7519bbac121a7"
SRC_URI[sha256sum] = "ccfd5a92fe1ac06b6f4bfe5548ca056069f697fe8645e1fdff67b7a386e67b3e"
