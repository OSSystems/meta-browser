# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9922a57c5cf8dbd32555344700c03476"
SRC_URI[sha256sum] = "7f25bddad77a986ae8d396b114291cbdbb44a58208726ec8a4dfcd1e7fcc7c10"
