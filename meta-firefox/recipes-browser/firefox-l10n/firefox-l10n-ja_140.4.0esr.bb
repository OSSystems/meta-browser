# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5227a3d0a9ed00c6b4aa9c43d57d6a7e"
SRC_URI[sha256sum] = "d2ac8088e0c951e146400573ebb72894696eefa8e9c0572f560d8f89ba195321"
