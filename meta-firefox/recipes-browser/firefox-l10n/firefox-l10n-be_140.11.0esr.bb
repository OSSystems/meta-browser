# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "322e513bd38a7303a20521beb93d02ca08d0cb4341c5eb44741e976693794f19"
