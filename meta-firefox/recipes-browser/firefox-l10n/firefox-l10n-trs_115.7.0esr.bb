# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ff490ec0111134b99dbba4ac71484211"
SRC_URI[sha256sum] = "3220beaae49b86436a92ccf26480e3dc0c62572e07020ae1b587b57c2eb26a51"
