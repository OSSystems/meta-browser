# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "45c8c05de10ed8f8b19020506b66f526"
SRC_URI[sha256sum] = "e420811317187bed3dab5d7e32379c5c965512a01a1daddc836ba0ca54261548"
