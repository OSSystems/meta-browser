# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0457420cb0723235e9f4466792c18c6d"
SRC_URI[sha256sum] = "40f6c05c11d4938c1667fee5182a0c20fe7dbbeedec25b83efd030671e52ff30"
