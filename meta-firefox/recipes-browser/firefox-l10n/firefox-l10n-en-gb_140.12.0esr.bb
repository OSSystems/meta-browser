# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3de2976c5a97242b6fe91a75db2e32fb15a1f1fa2ba5ef6a034b94e019bd18f5"
