# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2313b2808370335519899ade858daa0e"
SRC_URI[sha256sum] = "8605f1157b33159edb28d85f0c0a90be55d85ecce2e8513267c18768e218e53d"
