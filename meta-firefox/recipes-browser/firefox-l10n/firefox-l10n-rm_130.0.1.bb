# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "605e6f71addd241fd0a9705b31a88f60"
SRC_URI[sha256sum] = "becec700ad59bf38a6ed584850f76a22f55a925c9e6acf72dee989f9c392e244"
