# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "67a0ccae5da02d008e21abc7696f68ae"
SRC_URI[sha256sum] = "ddf055119989fb69c63bcd8c41397010e52819453870c2dc71de5474b76e04db"
