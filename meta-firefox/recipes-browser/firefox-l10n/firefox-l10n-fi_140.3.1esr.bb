# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "276eda4c488ca2f6ff5278925763ded6"
SRC_URI[sha256sum] = "6ded93b17b9f81b585c311bba9c139ead3df5a88f769c11f44f7098ab3a7c970"
