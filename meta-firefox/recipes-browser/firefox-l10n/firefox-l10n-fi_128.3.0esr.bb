# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4a2de641998755c8cc370e82be551f18"
SRC_URI[sha256sum] = "a075cec861dcebd7588b3bf25334d70947e819f04a4558ec372a20d1afa598ef"
