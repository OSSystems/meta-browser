# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8d3c6196ba0ae795bace5d5e2f3c4c23"
SRC_URI[sha256sum] = "7ac7111f16e5e7567e09d77dfbd38f17ee8dd1ec9f8aff91503ce465c5b6b947"
