# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aa3e6b18d6ece6f8947e259002533589"
SRC_URI[sha256sum] = "38be2b09d97b6aecd01f9aa3e15201d61a3f40f765e89e8d8dcaa34bdc84f6bb"
