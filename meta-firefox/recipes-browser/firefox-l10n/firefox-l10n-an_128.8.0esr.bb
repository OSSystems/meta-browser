# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "edc3a7caa49993b6eb37aa4005933933"
SRC_URI[sha256sum] = "3fb34ad0f39b78c49456143d8912b73ec2d12a8b23be17620f8efc208c3b426a"
