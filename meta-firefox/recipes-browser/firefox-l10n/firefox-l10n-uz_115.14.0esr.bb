# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dec82da06bef1b101f1142f5c23cd1bc"
SRC_URI[sha256sum] = "0342f6a8904332ac15d9635d621a5f352972844b7936daf23f64f4c5e92206b7"
