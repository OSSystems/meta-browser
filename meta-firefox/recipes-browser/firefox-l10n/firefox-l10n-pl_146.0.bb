# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bba65aa5b9c9dd09c022d509143b06c2"
SRC_URI[sha256sum] = "8729563188751e53619ea877442b00a7c53eb186b088c101f42acf56c22ec25d"
