# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "eb43482023c7a828ea8899afa9915f76ce1d5178461e7a43a173df6c6b2ef83f"
