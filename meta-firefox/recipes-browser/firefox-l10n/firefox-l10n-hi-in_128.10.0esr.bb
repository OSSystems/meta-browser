# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "68cb364f416fc9bdf3813d2ed513b1cd"
SRC_URI[sha256sum] = "620f73fa9d4f9c227cfad1dc1cae39887595fb9c290038066d224a486428ead3"
