# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "6c4cb9a65a4517167b7da42bf87b04b24b755aa3aa1735ea95177058aae165f4"
