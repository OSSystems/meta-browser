# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2b4e69e56a263d5d7bec322fc073aa57"
SRC_URI[sha256sum] = "55e14b771f95fd0d34fceaba3d9dc625790243a5bcf3eb79415982ac92bc8b56"
