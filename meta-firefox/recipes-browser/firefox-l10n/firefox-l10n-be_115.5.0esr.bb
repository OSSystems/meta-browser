# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "02bafe8a0c45d7539f958623fed45fa0"
SRC_URI[sha256sum] = "a66388b2ec538d4bbf517500d52860dff3add8c3b50b141bc3a94ed1819075ff"
