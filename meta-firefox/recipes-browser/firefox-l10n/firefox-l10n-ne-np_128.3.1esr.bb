# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0467f508ddb8b731cd36b2faac91efd2"
SRC_URI[sha256sum] = "46bcaef231e0dc7d1c1e297ae10f990dc6e855583bffc19cad276b9e83d7e80d"
