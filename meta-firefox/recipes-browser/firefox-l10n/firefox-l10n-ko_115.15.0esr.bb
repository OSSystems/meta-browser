# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "77c3023d1587a1beaad741c9198c77bc"
SRC_URI[sha256sum] = "c24b741a2968506add01c891646d16a8454a084798326141fc4e4b9d8b40e290"
