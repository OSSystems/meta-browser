# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6b2a2d774c12800767d706580b092d9c"
SRC_URI[sha256sum] = "031d7f7d77c211f55e4eaf316d276308ed3ad990daf1bf7b01d9a1776bb979cd"
