# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "38ec7f97d8901476db099c98cde292ad"
SRC_URI[sha256sum] = "1d49f6478b188708462eafe03f6212330572328819d5d051893ecf67e69e2d4f"
