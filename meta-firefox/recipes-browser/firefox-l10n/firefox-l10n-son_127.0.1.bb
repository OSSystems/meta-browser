# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bc3bd856a6c489757b32d168cdc0ef36"
SRC_URI[sha256sum] = "2af9e17ce087ed134e2946fe8df09268db3c13c63da96f05f1a1341b020ab17a"
