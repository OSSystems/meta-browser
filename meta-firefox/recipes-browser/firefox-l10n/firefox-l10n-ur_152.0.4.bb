# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "21849779b812c565e730c1df01f15ca7eeb3c06f36552ed763b58ed0ad7f9a9e"
