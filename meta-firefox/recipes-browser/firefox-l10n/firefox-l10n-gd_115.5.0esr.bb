# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d61bb075f29533a3e77e892e4df77b63"
SRC_URI[sha256sum] = "6ddf611ef581de44fa286e71f7285c52077905604fa9df83a1c8f196095b25ce"
