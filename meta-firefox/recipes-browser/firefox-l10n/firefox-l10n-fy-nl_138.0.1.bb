# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ee50751dbc45aabfff8661c6edd68760"
SRC_URI[sha256sum] = "6f953efac2f1940c6e608615625142195607c42a1b5ba5c14095a59e2c543116"
