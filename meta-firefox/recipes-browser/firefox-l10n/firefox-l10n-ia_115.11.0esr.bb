# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4be308cad488dee581438942c5965ae7"
SRC_URI[sha256sum] = "75ef78a73258f21685b9e51ae2ee76207c950cf8b53362b1f20f2b35f695e2df"
