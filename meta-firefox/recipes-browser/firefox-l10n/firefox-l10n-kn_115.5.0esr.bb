# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5db834f0d584c62b5a705890115465d2"
SRC_URI[sha256sum] = "5a0f651b9e8654d16c4025c025bce46b62dc3cad47afbf30bc97b2c16f530ae6"
