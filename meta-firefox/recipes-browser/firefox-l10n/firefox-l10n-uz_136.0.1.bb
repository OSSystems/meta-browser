# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0f5b2f648e1897029df4086af33b3a71"
SRC_URI[sha256sum] = "1dc66e9e17ae3dd7a5845462e81331f5f409db1ef95ee6860a618def9591b8a2"
