# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d19ad5f43beea40960eb8e7e1973a70b"
SRC_URI[sha256sum] = "a3abb45429b7136517756114a959399f4f270696a16a0d4f5497404c4d7b7eb4"
