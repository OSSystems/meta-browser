# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b67778197eb32da4cdb75f52b24ea5e5"
SRC_URI[sha256sum] = "7963baf5bc96f75223daf938cf00e8bb8cab114f6edf07c832a4d8f78f3510f5"
