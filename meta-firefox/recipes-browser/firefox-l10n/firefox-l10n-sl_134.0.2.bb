# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1bf8fc2a7271b01b4b888c44deffde2a"
SRC_URI[sha256sum] = "6863f21ad9b86dd383176f6192498a3e13a6aeed0ad505b2d62e0582ac6bdfc5"
