# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3a1db00e70d3f62f6c05c443000b7dac"
SRC_URI[sha256sum] = "b1524577e64e3e8feef29aeaf34e32afbf14b20f5a8ec7291fb8371e997d0503"
