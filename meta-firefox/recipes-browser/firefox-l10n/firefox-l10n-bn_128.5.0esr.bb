# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d0d39ac3cf0f47b507063a9bc8bc96b0"
SRC_URI[sha256sum] = "a763ae4b422ac932510a205fef7550cf79c90c0b6bcbf842187bdc37e95693ef"
