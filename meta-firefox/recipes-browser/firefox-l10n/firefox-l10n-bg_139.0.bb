# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ee4bf80df5eb3124a02ec1fd4f4aae63"
SRC_URI[sha256sum] = "69b438299136f69ab573a4499bca5b28aa6667efb2e624420bec60e9b8d7022d"
