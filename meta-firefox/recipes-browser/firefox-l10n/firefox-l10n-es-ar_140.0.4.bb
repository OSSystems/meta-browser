# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9566f11c3705bcfec254e4502a90b76c"
SRC_URI[sha256sum] = "5afc9778e7e19b2fced02c00901a9c1f52b37a0244d970ea933042b5cbd6bde3"
