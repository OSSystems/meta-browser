# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c8b0dc477864494788b2e308d223d43c"
SRC_URI[sha256sum] = "62be9cca2caf9af845f87b0d3919ebf5a9f7b640c275c2715c93c57dda0986fb"
