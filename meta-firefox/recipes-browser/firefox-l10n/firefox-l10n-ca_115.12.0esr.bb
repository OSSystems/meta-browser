# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "70ca75aa10b9c58a67305c2944ee360b"
SRC_URI[sha256sum] = "88ab15dc35d4396295d5b60bfd3905bac0160c455efac58f577946a1b6b2ce61"
