# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d83ab4e18327f330057a5f5972dee8ba"
SRC_URI[sha256sum] = "043fc54d7cd1a6e1788d508274f323254fba5911ac88d03b42649a51f8d1da98"
