# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6c1008238792d07173db4a9f635ef64c"
SRC_URI[sha256sum] = "b02071fa9a79ae6a3ae47f212f68986eab413c128ffca5d0ad1244f7f83fb367"
