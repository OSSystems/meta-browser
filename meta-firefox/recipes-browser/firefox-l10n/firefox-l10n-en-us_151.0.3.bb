# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "14c530cfd00a6fe3a11fe843771da197f2b1c3f618e2e8d5cf94c9c39a09a6f1"
