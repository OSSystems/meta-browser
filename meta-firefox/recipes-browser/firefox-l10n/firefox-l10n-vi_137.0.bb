# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "50a1c7d626127b637eefd1557681444f"
SRC_URI[sha256sum] = "ec04f19eafbae464ff634e2189aacb0bdfc69a8b1a4db820899fab82060eff35"
