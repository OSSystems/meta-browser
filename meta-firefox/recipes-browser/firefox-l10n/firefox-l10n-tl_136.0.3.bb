# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5551d9a0406d0baef6ac5348cdd329d5"
SRC_URI[sha256sum] = "efc68ec3ced4b8cb4402bd0eeab53a066fe9ae6105c91e69d0abfb43df07303f"
