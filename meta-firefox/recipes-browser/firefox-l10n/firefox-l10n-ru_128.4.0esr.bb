# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "faebe2ab40dc44916b2f241dbf0add8b"
SRC_URI[sha256sum] = "373532f1672cd92bf8df68f09f53b0e7de1ea5b28e52da2ae90d921fb02af292"
