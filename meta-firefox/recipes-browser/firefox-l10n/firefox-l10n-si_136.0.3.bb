# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "46e92acf761562c7b37461760a2e770b"
SRC_URI[sha256sum] = "bfe0885a2a5596d391888cfcf44ea7c1e8e89bcd78e83010f6ba67a9fa820ddf"
