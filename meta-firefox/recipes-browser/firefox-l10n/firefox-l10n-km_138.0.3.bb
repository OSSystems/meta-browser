# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d87ac199f1e63366f728637cfd1e23c3"
SRC_URI[sha256sum] = "35d07b44be6a2112b8ddc672b764f1941a727b5db48076128e4da89cb194416b"
