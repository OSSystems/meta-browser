# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b54bb7d10db25b59aa641c56d3b8544a"
SRC_URI[sha256sum] = "7bf44312f50d78df2ffafbe79283da6f740a3906741c78ef0a14563802e96d1f"
