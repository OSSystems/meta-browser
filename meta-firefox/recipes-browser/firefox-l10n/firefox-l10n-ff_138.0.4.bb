# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f5b21bb2455f95ae9ce4cdb0c163e411"
SRC_URI[sha256sum] = "7590acfe347a95b9ae77035b11a4d226427792991e9326111f89d7f371601608"
