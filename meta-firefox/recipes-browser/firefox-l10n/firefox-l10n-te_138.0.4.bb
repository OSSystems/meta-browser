# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "51043f4897e30b7dca69bf32ca010a17"
SRC_URI[sha256sum] = "5e91de314cd8e2c649939fafc2cf4ac4418f10c4e5f17d825e097c67bbde40f2"
