# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0af4f2368f19020e9b42382025908918"
SRC_URI[sha256sum] = "21d4143d265ce6fdec2423a59035570e33d5bc0077934a5b877663bbf458d45d"
