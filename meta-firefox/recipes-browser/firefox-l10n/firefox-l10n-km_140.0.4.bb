# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "20a26d73db0a69e8b6af039a1457332f"
SRC_URI[sha256sum] = "e5cb47ae7ae803ccde14edabce69d400976aea3c8dfde8ba362c3c32b8d6ba24"
