# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "62f85f5a7c9c790aa1579094229e4571"
SRC_URI[sha256sum] = "f0c8e2f9dff0899786892699a920d429d4617505132d857bf6aac251812c38f8"
