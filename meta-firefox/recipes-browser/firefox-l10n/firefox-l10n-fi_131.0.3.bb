# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8a729c29fc6ae58f27d8a092df46245d"
SRC_URI[sha256sum] = "49bb5f4c61d1a2f50fac2aea25024a6832d572ba95c6fa7e6c328600d5633686"
