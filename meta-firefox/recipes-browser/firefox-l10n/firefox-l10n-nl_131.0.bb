# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "03ee8d69bb918d34650486d52e9c5096"
SRC_URI[sha256sum] = "4f61ee56aa1f5d899e6fde6583830c8ad06e454e2f41307086b14908796b98db"
