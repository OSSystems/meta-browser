# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7560b75c7d8a10706cf918b208173b46"
SRC_URI[sha256sum] = "a792a9d5f204acb17a62291e90ec9cc496bcca7d2f07b73556f3cc7b637bb145"
