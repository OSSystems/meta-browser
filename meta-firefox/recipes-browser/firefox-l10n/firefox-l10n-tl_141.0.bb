# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8fff84fae5eed8e5a1ff0419ddb4a701"
SRC_URI[sha256sum] = "3074d4c09e3194581d4324e46ee9251030fe5a84a04f0605194b640de9a91fef"
