# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "26c9fe099f1091aa0ce416ab85c4492f"
SRC_URI[sha256sum] = "c2b84cda0ca5f04287651a76abf713f3bed9a9ee6afe6cfafe0a3efc202da3ab"
