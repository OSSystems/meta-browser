# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "220c0db32859f2b0e95f93ebc887aa5c"
SRC_URI[sha256sum] = "5c822337ba9c116cf22121a8a312660b9d7f3f9ca5dc699c720cd868c5690b16"
