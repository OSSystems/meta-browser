# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b53aa55c45699690589bad4711b6e45e"
SRC_URI[sha256sum] = "a8846e8f89433ce773818c5ca9d8557773946ba1825a506c1b3b13e530c63b0e"
