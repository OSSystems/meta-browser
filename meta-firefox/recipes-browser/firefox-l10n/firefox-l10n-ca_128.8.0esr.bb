# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "42a6cab32fae35cafe9e252d91e56c26"
SRC_URI[sha256sum] = "296673c151a5a3f44a62640da97ac358bab3c122425964b9c11d38499daa5aee"
