# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5a947fcb880e429cec56fb10a41835ee"
SRC_URI[sha256sum] = "f36716e8a17b92ae47d0565c9adc4ebdc2a3a464c36f06d9ef77d67e6e95a7db"
