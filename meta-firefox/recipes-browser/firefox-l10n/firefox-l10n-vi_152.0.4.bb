# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ddc634a719a5ca584ce160371344d61520cd51560e86d5cbe0b2406d26cf93dc"
