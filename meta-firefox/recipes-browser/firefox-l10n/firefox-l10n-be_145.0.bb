# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "792943eb783270074f99ce61ecca66c7"
SRC_URI[sha256sum] = "98012fff67f58e47dd8b31c4f9cc78641c7374a338dc1d19d32a8c6a10e55255"
