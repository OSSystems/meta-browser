# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c6a2d8a87cf949420833c7660ed2d638"
SRC_URI[sha256sum] = "d8da5d8edea3d76f34c3a094e7e3c9a476731ca0c891f35a49eba1db0d9aecfa"
