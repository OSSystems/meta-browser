# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "8e8396614f6c442a934f95bb72fea145adbdce7f568f6e24de2a20579ecfedfd"
