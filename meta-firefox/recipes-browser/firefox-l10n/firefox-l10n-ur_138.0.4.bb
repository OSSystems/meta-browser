# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "58c442dd0a639a3313d080ff0c6ef998"
SRC_URI[sha256sum] = "1a6da3caeb78c65828606d111506ff82e58acb03b61b4baf2da9d5135dbcd8b0"
