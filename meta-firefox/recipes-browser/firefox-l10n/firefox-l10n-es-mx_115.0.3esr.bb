# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3bc6a42b638d87a13f8a52f39c15ff1e"
SRC_URI[sha256sum] = "786585954a9b64b4b6bc94828b34be39d9ff157e1ccc32c0931be572d27877cb"
