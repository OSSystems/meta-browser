# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6ae830f92dc449978bbb830b70c552e8"
SRC_URI[sha256sum] = "4065f86ede167a8d7e81ab0af6256ea97d70491be4c24f719dd46ed681a198af"
