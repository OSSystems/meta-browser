# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f966720bd8477de9bd1f13432616b024"
SRC_URI[sha256sum] = "a3fe652696277aaf19faa38814d4a0bfe1756f16d41d2010abcdf69c49938541"
