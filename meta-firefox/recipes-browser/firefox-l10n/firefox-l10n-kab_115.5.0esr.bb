# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f9f864c44cf099472b3067d84fadcea5"
SRC_URI[sha256sum] = "ff67a2c9caccce3c1cf1562efa87a79c1abe8cc99b9425d9a8c1122c89885241"
