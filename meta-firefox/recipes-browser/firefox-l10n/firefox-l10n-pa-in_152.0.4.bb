# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c96e18e002eb1bec3802c1071e7ee3a9c96f11e0068dd9a4a625ffb9cd094420"
