# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0e319ab011a7c2bd6cfb0f380bb98553"
SRC_URI[sha256sum] = "973bac3e3585a307ca30dace4f6483a96353b6ee32c542fce885ef257b154881"
