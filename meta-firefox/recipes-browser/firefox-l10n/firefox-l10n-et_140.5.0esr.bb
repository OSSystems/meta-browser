# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a03c968f08d828e4ed6053ced0e42fdc"
SRC_URI[sha256sum] = "fd9cad5e1e4db3b68741b4ca85893acd36707bc5c31ee1ce09a5002018deffcf"
