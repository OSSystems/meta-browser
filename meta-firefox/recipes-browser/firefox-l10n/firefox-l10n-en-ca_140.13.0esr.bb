# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "71b2b6a61f848bac15e62c76e9956891c667a774b6efec2ce9ad61b379edf594"
