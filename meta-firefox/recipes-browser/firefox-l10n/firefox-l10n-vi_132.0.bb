# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "68390d62582267f523fc103f8351535c"
SRC_URI[sha256sum] = "e8bc969291049d1e92df406904b6a799eb731a100e158a109c3491c68bf7da8a"
