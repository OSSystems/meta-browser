# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f33141fdd6709e0567149b0db91a4b9b"
SRC_URI[sha256sum] = "7f76dbf8014dec8dc2716064666dc7e3a2a0af56af3a94a02f39a9fd31138f57"
