# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f75e423d8e41a2c794700dad50cb19a5"
SRC_URI[sha256sum] = "4e7906b7899abeccf03c3cbf58acca69b696ee5b47882bfa1709655123615dec"
