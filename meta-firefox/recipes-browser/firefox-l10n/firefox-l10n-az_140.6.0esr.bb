# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a9be4073bd7ba00490d6e0f19f934592"
SRC_URI[sha256sum] = "131591970aa86e8a5ffbcb3bd2b46f6e84b6e9db5429ff4795aef332e6b60ecd"
