# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "69b8ce5f2ca65894d42c436be31240b1f8de810568ce6c8d8896c41121f7afa0"
