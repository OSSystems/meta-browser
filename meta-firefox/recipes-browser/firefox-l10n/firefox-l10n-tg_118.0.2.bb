# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6a5e77c49ad8609ceb605f4fc1f6215d"
SRC_URI[sha256sum] = "d43ab4795b8ec8874495b16572d3e35ed2093a769546fdf3fcb2e8e3c15fef5d"
