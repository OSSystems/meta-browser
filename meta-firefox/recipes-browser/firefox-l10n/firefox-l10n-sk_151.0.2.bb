# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e5ee094a10eb1356ca6dd0512ed52b87dd31dedbb66806109f4147029d770016"
