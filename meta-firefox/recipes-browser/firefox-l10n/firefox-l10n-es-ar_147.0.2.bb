# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "81ee31b68552621eb1a004b4dc298120"
SRC_URI[sha256sum] = "67884c83442962c7b06afa16399f0730efa8503572c5cd4cbe8edcfb4f3eb4a2"
