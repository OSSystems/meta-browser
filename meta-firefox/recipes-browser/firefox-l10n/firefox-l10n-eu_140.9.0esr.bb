# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "87bd1439665750199748f22756bd8dce"
SRC_URI[sha256sum] = "375e269aed844640aec616821ce863cd8bc5e0a210a5e6a6d4f08c81cb817121"
