# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f73df4ba04852eb78d7aec12f3d52811"
SRC_URI[sha256sum] = "cd9471806aa2eb3a8f7593aceed7f87347b53309a64248dc9d9c01626e056577"
