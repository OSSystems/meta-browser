# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "58995335ff94b9ebb1150d3e277563b0deac42b0737a29f31cb542243effb893"
