# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "cfc201b9d9a9490ee482659e81a558cb7e54404899dc0854acb254f2c82f0452"
