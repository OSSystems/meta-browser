# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dd937b0623cd51b4f07dcd29b0e1baeb"
SRC_URI[sha256sum] = "959e87f1444861ba567d3dffc40a062cd934fb7974cf65669ee5d9c01934bca1"
