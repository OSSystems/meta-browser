# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5ad4e5d7683d63a65f25267e0d84612f"
SRC_URI[sha256sum] = "3da449ea9e023ff3bc9b518d21793871b2a0850ded848a3db9ea419711537962"
