# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ca682d001a9859f79780e2ae2054c19e"
SRC_URI[sha256sum] = "fb94fd46aae10ea2a1a15a5e38de33f690a15667ddc8b9d30992fba5454dc185"
