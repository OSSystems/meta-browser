# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "98d8280852ca48c5ccf25671f5653ecc"
SRC_URI[sha256sum] = "6e1bf1aba3f0dbf53cf231dd8b5fcfb78afe90898a31e97cfc2d97e9a535d32a"
