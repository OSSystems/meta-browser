# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d39e031f66d0961a2e19faaf2a21dada"
SRC_URI[sha256sum] = "9110a8ebf7fe30fe166cff1b4df6c456917e634326d2b06c00da2d2e5f81b5aa"
