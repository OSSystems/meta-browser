# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "f5493a4db49cadb9287403439b9f64d7cc260443b8cec0e56f0818b843754310"
