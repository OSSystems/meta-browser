# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a1ce02d845931ffe64d8d1f4fa003a5d"
SRC_URI[sha256sum] = "99f4edd07a414fbf24c18745a333af9d3fa526a3320133233f75f475a066b4df"
