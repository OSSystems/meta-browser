# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7f1dd99412ad5d65c87e625130463661"
SRC_URI[sha256sum] = "700fb2c951124e1ad46ab52b7505de1474f33b4afb6a1e10be61b4aa33792aea"
