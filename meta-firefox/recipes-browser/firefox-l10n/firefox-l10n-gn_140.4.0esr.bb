# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eea9bda9b1e032a49307ee9af9f5e199"
SRC_URI[sha256sum] = "62a9edd0d5a6a5e11d07bc68de55a293a316457bd82c7c9a7667b9979e0ad769"
