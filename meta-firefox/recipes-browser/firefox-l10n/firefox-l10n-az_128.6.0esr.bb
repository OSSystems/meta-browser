# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bd7de6aee70af3d96d2cda8bdd6e309e"
SRC_URI[sha256sum] = "51a61e6173cb21c678df11c224e42d19f026f567d03a7ed04e3501fc61cc6243"
