# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "20e3caad05c317562a24d41e48368a86"
SRC_URI[sha256sum] = "a5bcf2b57fa1ad06ed40053670c0c599099f4dbe17fc378fb16159875d1fa87d"
