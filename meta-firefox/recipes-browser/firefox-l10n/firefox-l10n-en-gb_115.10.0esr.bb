# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b6d6eb81ff8bbefddbca7c29422e047f"
SRC_URI[sha256sum] = "aa67da034a4470e7dd0208b98f81047dc46d1961741d7147a84543786ee6f703"
