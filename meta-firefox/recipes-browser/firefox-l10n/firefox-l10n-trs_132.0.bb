# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c1be5d67e5e5f889858e070c3b6b62b8"
SRC_URI[sha256sum] = "d60edaf1440418911ffd26ba02c2abb152860aaeb11b56d62ba07a783ba2105a"
