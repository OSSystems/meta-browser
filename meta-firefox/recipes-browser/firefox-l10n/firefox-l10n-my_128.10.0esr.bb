# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8da96578103707dd23cb0accfd7860b6"
SRC_URI[sha256sum] = "7b2d1efa2f812257ac84833cb0adb177de102c9bbeb0318237e9259d171c6234"
