# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3ca872bf431fd93487fc8652f0352951"
SRC_URI[sha256sum] = "a1b8fd05e00a44c1c4b8c1880ee4b75ec2a7a98119ef7da7fd5d012478875655"
