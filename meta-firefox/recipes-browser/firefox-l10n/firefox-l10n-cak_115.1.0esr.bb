# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a50a2f620d5d3c232e7e7344791783c7"
SRC_URI[sha256sum] = "ba78876c8487ee44ca1f835586059d9d9c1c1f1c5b4a2d019cd04f6545633c42"
