# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b94031e04e6e62e847cf55c20c820923"
SRC_URI[sha256sum] = "12e92e260633e9a69cf1ac91a0db9f487e5bff093bcd8899357f3172e99e7159"
