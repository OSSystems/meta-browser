# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "825f79655b00ace79311ed0e2aebbbc7"
SRC_URI[sha256sum] = "9342b8a56c0e77ad282efffea77c04c0ad44aba6c98873122e92ea41f44c5b38"
