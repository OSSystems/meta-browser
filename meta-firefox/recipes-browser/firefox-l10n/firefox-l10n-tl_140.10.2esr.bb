# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "464de914ee6c5c24f930d2272cd733525f5392c694e3ad7b742aacaa17104612"
