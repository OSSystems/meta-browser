# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c831f9082277aec2e9babf44da535cc2"
SRC_URI[sha256sum] = "bc0164d0e746c37f106da06bed65ebebaeef2d96a2a5df25b54e720e7976702c"
