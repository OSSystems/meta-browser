# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "634a57ae67927d5e213a94d9568ba4b3e22d8054f823bfda7211df0e0e3e7492"
