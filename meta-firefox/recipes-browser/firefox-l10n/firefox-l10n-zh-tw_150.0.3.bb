# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "907c78bc28907e0022ea8ce87e40782534be3dab4ee749d01c78b381ec1b1731"
