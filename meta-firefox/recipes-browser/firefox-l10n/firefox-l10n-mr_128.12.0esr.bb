# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fc18fce32fc0d3cad0ed14a55f4dab88"
SRC_URI[sha256sum] = "9e52353620c07799689f217838baf76c2c0252cdc1c86f654c5be4dcd4fca15c"
