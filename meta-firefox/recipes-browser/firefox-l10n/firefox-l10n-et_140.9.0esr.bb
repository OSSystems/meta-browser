# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "296ecce0d033514fdd9bf36a9d90fb45"
SRC_URI[sha256sum] = "35b3c87ccc9662299bab55d489ed7c68210d205dd33a4a1e50c4826d9094f65c"
