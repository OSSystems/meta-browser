# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1c43a100a808c459b58c58a855c9aa53"
SRC_URI[sha256sum] = "df3a610c4043255be7a07b8c255a45b7795fefecca42c022e782ec38a4f22d72"
