# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9243579de70b17974991e4e82398c9af"
SRC_URI[sha256sum] = "ac5e5249459cf62475fc7a5150429e94d79636e3357ec75a7cdd5db5ff371ed4"
