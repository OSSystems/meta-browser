# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4047ca0a823570df3115da0b5fcb394e"
SRC_URI[sha256sum] = "20bcad8867aab21f925791844b9855d5e6209064f94866d6d225a19c6c6a2498"
