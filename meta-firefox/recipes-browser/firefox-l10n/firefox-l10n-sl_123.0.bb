# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "35c6f3f138906b3a9da4a7cafb5baeba"
SRC_URI[sha256sum] = "5961e261a6bf75f84ef53b7e8c1fd1a5b6e2fa72a333b605b3b2a0c70c837a31"
