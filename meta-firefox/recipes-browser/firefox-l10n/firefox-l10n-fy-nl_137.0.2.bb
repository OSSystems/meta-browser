# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "412a30f850776f15324b86f0a693d933"
SRC_URI[sha256sum] = "84b10fea4dc1fc8943aec02d0c6f15fa7f2e975e522c5afe1e584761811fc478"
