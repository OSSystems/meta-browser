# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "de74af86fc752ada56b4c31ef084147e"
SRC_URI[sha256sum] = "9bc9b967a88413f6360bc18b2327f09162d2e04f2a608bf52eb0856cec266a15"
