# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "58c4ad09ca85e1156285f31fdc2d6b73"
SRC_URI[sha256sum] = "f9cf16ad6ccddc9b3c61b41b57d4a21690fcf99ffebd1047e78a5f1e02a3a1eb"
