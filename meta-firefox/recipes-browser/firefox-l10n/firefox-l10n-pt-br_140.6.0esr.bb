# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "898bb91074ae150f8124f1b66ceac4cd"
SRC_URI[sha256sum] = "aec7875bf60b4d18d905e693e5d22f93843cc532955bdb0aec0067ad163c6601"
