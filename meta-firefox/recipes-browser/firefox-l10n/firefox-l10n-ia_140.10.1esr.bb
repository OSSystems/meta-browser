# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2875733a4c92d3aede200817c0c0bf7a2f117edc2cf2174ea19aa5112025a183"
