# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ad69fef80da29494cdbbf2a86ff5e61"
SRC_URI[sha256sum] = "220c8b6eedaf86b6b8f9d8d7e6bf5a2f7be6d698720eaf4d57b39c220275f293"
