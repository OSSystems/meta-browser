# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "87367305272c897e6fc2b6bfeca66114"
SRC_URI[sha256sum] = "8c36d6fd63a40f2e4d66ca161b996cb61098f8131ad125ed75820c8e88087228"
