# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "443484a922aac578b76da9a3cdf395b5"
SRC_URI[sha256sum] = "e04c4dc11f65ba0f9677a179eff2dbdf1b86a03e8f58d421ddd6f4f90da588cd"
