# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ac5c4499259a88f975b7d6076f050c08453ab5b532c39e1c70d57c29ef7a1088"
