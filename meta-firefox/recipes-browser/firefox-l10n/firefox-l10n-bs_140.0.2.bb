# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "773e71ebc3dc373189f1c15d96f4aa76"
SRC_URI[sha256sum] = "20f35b11d8a7d23201d890c8fcd14d80e994e13911ae1fc0d4703b29a114e3fb"
