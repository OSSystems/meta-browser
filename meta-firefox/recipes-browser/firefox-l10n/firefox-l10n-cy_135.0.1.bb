# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f5010ed868492d06adb8eec82bb142a9"
SRC_URI[sha256sum] = "c2452481a10fe1c76494d2232b56d7d9074492d70d65892748ebc3512f820ead"
