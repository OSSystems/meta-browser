# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "19393a1af3726165ba45a0f5261b9e21"
SRC_URI[sha256sum] = "af981c5fcae56c8c45e1c4ad659ff0bbd1fe6a201f7c55a55e133ea7bfc33531"
