# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3f43adf627dee461a3d2f129ce374897a088ed718e814c53fee93d1266dbdd9c"
