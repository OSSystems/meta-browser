# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "972be4aa4ba896ef5613eb4f8beb2ee6"
SRC_URI[sha256sum] = "e80490f499a3f32c2319b0995b33ff37cec2dd2cc9fe21e39cd1419315592edf"
