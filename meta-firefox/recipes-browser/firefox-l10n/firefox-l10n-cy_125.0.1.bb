# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "36ffb1f80e1515cfeaf7dea74527bc3b"
SRC_URI[sha256sum] = "9e36771707b84b03081f1b068a4088be69bcab7de129bd29a7dd692d69cc879d"
