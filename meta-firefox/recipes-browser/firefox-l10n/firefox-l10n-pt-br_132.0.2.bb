# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "111fe863cfc07b8286581c367eeac2bf"
SRC_URI[sha256sum] = "1276073a30e9df737bc3f61a86cc9dba0376e1bf50cc326cf2baea16a8a8ea82"
