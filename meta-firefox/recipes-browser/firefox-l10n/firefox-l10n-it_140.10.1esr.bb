# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c2212eebf310b283091b67ffa240330274fe4d6cc9adc9a06868fef8fd42c2b2"
