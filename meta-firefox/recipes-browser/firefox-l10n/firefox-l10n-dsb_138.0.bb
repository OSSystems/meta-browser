# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9e71153953312b7f066847536933832f"
SRC_URI[sha256sum] = "0e0c0d5dad6ed00a4227f36d8a30b9aa503e7e83a3f4f7b206da174ed4c893f0"
