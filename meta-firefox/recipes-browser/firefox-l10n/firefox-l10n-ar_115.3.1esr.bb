# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bd2b3c64489bccf990198f903565951a"
SRC_URI[sha256sum] = "5ffcf8983baf104b014bc05cc4c73456de7abe4ffca735c951b148399162523b"
