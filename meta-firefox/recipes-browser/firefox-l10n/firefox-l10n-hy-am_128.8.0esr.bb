# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a35814d9f5b78abbe1618ed9fea89ecf"
SRC_URI[sha256sum] = "6395506f70e2b9892af3b2d2159a794c33cb85d7ba646856ffff36dfe44c281e"
