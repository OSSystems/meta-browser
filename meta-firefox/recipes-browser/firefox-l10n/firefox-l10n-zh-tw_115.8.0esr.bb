# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d42a3596dd49ea26818bbe92170a8b38"
SRC_URI[sha256sum] = "f31ff3d6268d28212cff1edacd44a28f8f4379402b441ab7ebc3f632d6b5279b"
