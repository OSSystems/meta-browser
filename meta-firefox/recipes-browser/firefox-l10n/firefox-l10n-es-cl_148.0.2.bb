# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "68a8b18d8b6ea8a6eabe60f39bc81144"
SRC_URI[sha256sum] = "cb63ebac0211a2187b070655300e9baa542fb1b4e744e538462ae6f850af8d55"
