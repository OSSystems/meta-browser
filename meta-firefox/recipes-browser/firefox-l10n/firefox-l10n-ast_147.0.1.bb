# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6200a73ab9394508ce48cc62e0533242"
SRC_URI[sha256sum] = "721430b1c4c811a6c52e6ab6eb8383e53b5fcbd469f7bc23a2c3bc64124ced42"
