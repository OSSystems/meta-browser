# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c6d6b65589ff022f277a90c5f089144b"
SRC_URI[sha256sum] = "08bf08b10035e4ed8a1831836f13823860a16722cb4cd852571d14afe82cf700"
