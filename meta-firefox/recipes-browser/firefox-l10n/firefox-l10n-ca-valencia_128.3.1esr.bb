# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cfdea0081a341509bb042efca4db8ec8"
SRC_URI[sha256sum] = "3aed792e8d1bf906efd291ccd8bb4b5466820c900ec9d46c84758ad7998d092e"
