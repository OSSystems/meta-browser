# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1a1849478bfb892748d15c26453737c7"
SRC_URI[sha256sum] = "5af3c40e31a1b7cb4a04c5e25c23cf41c9f7e828ba5dc7a3881df3ab887b247b"
