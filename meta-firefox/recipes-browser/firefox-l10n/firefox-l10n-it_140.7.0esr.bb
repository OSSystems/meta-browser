# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "006a3c70fdbe5388dad95003740da3a7"
SRC_URI[sha256sum] = "daaceb94b846a7a5e3a18e84bacc150adc5622a82fba74835c8fabcaed2deaf7"
