# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b878c8c7e0de45169a1598d59ca53508"
SRC_URI[sha256sum] = "ec945033b6bf2aa6dbf708e2055bb293743c1bf293632b19f06cca794d147976"
