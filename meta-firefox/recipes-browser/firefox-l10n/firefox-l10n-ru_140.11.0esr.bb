# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "0ccd24fb85c7b96e92399a61e56e53f706c1e1d30bafb81b859039380409e244"
