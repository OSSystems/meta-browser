# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9af25d8e19c827cc37748ceaa83beab8"
SRC_URI[sha256sum] = "c39911285b0ef16148865ace81a8a90693e4fb77f8df6b3d6d7f7e847aa936b8"
