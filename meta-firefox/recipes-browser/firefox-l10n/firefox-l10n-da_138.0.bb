# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "43817fff75378f1b84952b817cd1bcbd"
SRC_URI[sha256sum] = "a985176bf4defcd8d83cfa4ba635e6cbeb5609502e4ac71aa11cddba170fba81"
