# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2420153ca342e19b73ec2941af9d8807"
SRC_URI[sha256sum] = "4498ae987f8cbf499f551947e4d0f3e75dfa3af6e7b96d0faad1971712fa2183"
