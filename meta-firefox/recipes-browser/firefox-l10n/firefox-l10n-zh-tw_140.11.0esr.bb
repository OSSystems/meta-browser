# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "39553681de9eb034916bbe0037ae3d357ff60e8824a66c9a16032479cf93ccb8"
