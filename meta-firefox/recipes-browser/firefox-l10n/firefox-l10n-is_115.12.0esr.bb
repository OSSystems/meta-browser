# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6da4573e5a00eee826e1f490555130c2"
SRC_URI[sha256sum] = "6bbdcf959fbfc9304792688f2e4fb3fda10ffca3c706e704b2d8cfa50de8a411"
