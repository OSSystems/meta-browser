# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "06beddc665278ba64f4494730a3978cf"
SRC_URI[sha256sum] = "a8f6f997845795e78b53e9b853df7198e929fb4623577a64e62ed3235c0b8e2d"
