# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5d84bad9ba70a9f7385f7b6731c6f4fc"
SRC_URI[sha256sum] = "7e8502ecec6552833a21cdd946a6ac3c8ec243348c009622d46bc29c83a9eaab"
