# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "297d640c84de2fcf6dab4eaa78cdcea6"
SRC_URI[sha256sum] = "471bb354e5319a89d9a90308bc178a6ec5f417649eecdb44df3357c3d554a619"
