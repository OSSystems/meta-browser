# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "850cd7734a3bd10781df4933f5374882"
SRC_URI[sha256sum] = "3a39775c5d25f770c08896ffa4740b62f38591ad6df1b3b4d711ba4ce109596b"
