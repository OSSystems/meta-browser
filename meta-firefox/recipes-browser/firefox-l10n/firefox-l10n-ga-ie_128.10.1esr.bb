# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4da2c6aa20f2302a52ac97e828c98610"
SRC_URI[sha256sum] = "db2a823494e09247d1af748d35bdcd4d8937dcbe8a372ec1a8689dbe593062ab"
