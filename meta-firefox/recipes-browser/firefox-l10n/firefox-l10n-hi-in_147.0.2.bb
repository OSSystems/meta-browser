# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dcdef19028f8698783a89172a0b600d5"
SRC_URI[sha256sum] = "8787b9b30be32657847a4f509111b973d040a6ed94f8e26b9208d7a7f0a7d5e9"
