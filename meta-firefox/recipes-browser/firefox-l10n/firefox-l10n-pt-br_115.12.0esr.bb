# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f0242a817ac0746185413b33fc1e363e"
SRC_URI[sha256sum] = "81f8054c1e1921e339bd32a887724daf02d38afbfb794ecab1595d13357336d6"
