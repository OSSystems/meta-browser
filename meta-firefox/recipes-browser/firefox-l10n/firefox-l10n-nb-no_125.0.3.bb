# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "826c2001ea0916c33d1a3c89682611fb"
SRC_URI[sha256sum] = "744932bcae89e099819553038c4e182ad09090e8a17234d3e32f7a1e33d3c250"
