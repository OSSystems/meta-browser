# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "37f3a0dfda6e583e04e7166661439a60"
SRC_URI[sha256sum] = "ee856e99c08de9368e373cde35dd7c37719a4fb7b5ff4c30944115e9d81ec7f8"
