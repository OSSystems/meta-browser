# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5db2fe116b898bfc0e20d6cbb45317fb"
SRC_URI[sha256sum] = "8902bc7653e618b30f35a6ffea8741a4bf6ad85d6785251bf75c2ba99f1d793c"
