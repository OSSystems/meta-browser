# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eb8a5b5ccd2e37b31f372d295b2894e7"
SRC_URI[sha256sum] = "99f0635268c536b214e221589079b6f6b4312e02539fa9a4b826e4d6732f411a"
