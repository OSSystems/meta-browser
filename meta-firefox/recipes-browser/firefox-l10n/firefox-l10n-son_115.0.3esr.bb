# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "74eee7064c798e01e9ffa959ac11f3c1"
SRC_URI[sha256sum] = "cd6c3a2006ed2642af2e0b246ac7496c962d09edd0b3439b3fe20a588748936b"
