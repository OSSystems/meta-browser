# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "67bb6e218d28f1faaeb609963fcf7afb"
SRC_URI[sha256sum] = "896bf178cafed86ce266a018cc7486ca73c09b535dcf74c39e0d2d5d683f748a"
