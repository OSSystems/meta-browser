# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bdee8af9fc4eececb5215f0801361b6e"
SRC_URI[sha256sum] = "092c479435cf997c71b9c4604489f8e277ed2103cf7ecbc35761ffd59dedf43e"
