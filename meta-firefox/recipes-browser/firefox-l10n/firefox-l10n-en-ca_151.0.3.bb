# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "8b2c14371d15d24808da6515fc8d8f6724236ae37d7ac03c6ee4332947534f18"
