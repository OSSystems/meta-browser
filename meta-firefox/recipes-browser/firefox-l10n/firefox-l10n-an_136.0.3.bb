# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eaf582953caa3aa3a0ebb5cd8a033927"
SRC_URI[sha256sum] = "a9fbba3bc4b1a8619ebeab38961f7de9b7565a0f75cd456ee3fcf5d5f3c24210"
