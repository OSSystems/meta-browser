# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8dd3080a171a847f017a9b3424a14ae0"
SRC_URI[sha256sum] = "b45b60831bb6769b92bc00df10296d8b3be430098cbac42adfcd7a940d42692f"
