# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "99c48b0aeadbceae9c35d590871314b1"
SRC_URI[sha256sum] = "3beb903f604e0620421971d21adb9532ed79117b6466b01940a8a942b09e79dd"
