# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "197fae9e19b577ea8208652cd92cda40"
SRC_URI[sha256sum] = "4452c19595bfad67dbd2d9bc9ae4597b916407507f415b73b228fd03a1c2588e"
