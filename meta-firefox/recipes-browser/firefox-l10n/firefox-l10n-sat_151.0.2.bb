# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "38f0758f117addf29908df2ab053f6a74342b17ad99b23f3ead36c035306413b"
