# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "eb1eaf25eb47515933406ca78b5f3d2e79afff30ca668f303cc35256be4873a3"
