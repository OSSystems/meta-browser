# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cf28a60bd41ee7f2718cd42aa5e93815"
SRC_URI[sha256sum] = "89f455c74c834599a8749ba1b376c361148c8902b2163e75426d63aafaec8d9d"
