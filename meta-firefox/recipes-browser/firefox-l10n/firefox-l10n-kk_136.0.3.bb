# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1b8d1423cade1dd3e7d7f678b62bb02c"
SRC_URI[sha256sum] = "0415829a3f40d3b9db23ece5011cb7ca4953df2838507445d8fc16bdf6d8e671"
