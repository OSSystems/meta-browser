# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fb177c7819ce4227c5f598d2eadc5bd7"
SRC_URI[sha256sum] = "8645fcc1136f803da6fadd252c597ab8ad0da3eb5290d60ae7eff93b0e790f21"
