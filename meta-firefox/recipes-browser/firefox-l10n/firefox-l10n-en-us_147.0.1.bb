# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5cbf3b5989c7505fbba89d58d2a74f46"
SRC_URI[sha256sum] = "d173c9f9470f83e808877f555be980a5be074ef16d5b79bdc12e19b0e904fba0"
