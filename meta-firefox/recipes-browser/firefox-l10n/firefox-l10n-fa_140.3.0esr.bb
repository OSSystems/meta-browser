# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c4f6363565231c18c30ad390f5bc8e8d"
SRC_URI[sha256sum] = "d45b6d5d050aff023f1050a459285abf15e6ee4a61f5f382e22829d1c69b5456"
