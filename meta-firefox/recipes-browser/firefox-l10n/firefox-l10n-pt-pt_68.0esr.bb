# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db3cd3c2b9892e7bcdfc2ad74c604e80"
SRC_URI[sha256sum] = "7b49ec9606aa94701eaf017be7d439e7e4561a05791c27acf6bd02dc89fc448b"
