# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c5c301d7cabdc7a82275366b741edf5d"
SRC_URI[sha256sum] = "ce0c9e9abd2d46c06e439320f443bef2569e307a741eca1cd9784524ed6fae0c"
