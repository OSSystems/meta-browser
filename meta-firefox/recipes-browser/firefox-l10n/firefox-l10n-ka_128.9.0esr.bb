# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a0d6f49231841c59b44393199c827faa"
SRC_URI[sha256sum] = "aebadfd6acb70acb6ca98967b117ddd5c3276cfa13e3eccf7540052b685b78d3"
