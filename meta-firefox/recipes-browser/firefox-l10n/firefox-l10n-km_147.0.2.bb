# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8ca7f6aa5e4fc97e49bd7425f400bcf7"
SRC_URI[sha256sum] = "645e42c765c187d4cb3ebf9d98f3a9b15e20b54518e713caa7406cb28ca91f44"
