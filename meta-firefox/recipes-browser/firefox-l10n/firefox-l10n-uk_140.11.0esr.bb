# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "a2a4d13682aa481c7ef3c23e6a521278db1b1cb9a2793240d97393d6079194ea"
