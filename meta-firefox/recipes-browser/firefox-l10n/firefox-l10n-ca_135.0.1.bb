# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2c84b9f685591c90773768fc24e5f61c"
SRC_URI[sha256sum] = "cefb24b77a840efbb2123b5230c345abf2b1014a757dbadc4c853a8772429cc3"
