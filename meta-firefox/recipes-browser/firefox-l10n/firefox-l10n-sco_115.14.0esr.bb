# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0fb4051dd2ffbb99d5dd2e4378043fde"
SRC_URI[sha256sum] = "90450fe4685da73570cca0d89e8a0e71c88dd78e4b5d9bdcabe7795d4d8518c8"
