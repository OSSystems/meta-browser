# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c3cc1ce0ef22e49b2ae53a0ec81c4d4c"
SRC_URI[sha256sum] = "b0c4b35508afab656ff29e9904429120f6b462968e0a43a9d289f295e7bc92ec"
