# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9a92255be224a0d7660a336003573587"
SRC_URI[sha256sum] = "17de173b4b8b4657bbc3d6c40fae4c91081eafe84cf9d4235cb91093a205bf54"
