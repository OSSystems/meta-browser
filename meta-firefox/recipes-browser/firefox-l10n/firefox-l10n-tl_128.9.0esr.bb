# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f1829a76d3dd69de80d72c3ba6d8ca65"
SRC_URI[sha256sum] = "2154af366df7688595b194558ea1f5f2201e34dc9eb8de93932e1a5da53440da"
