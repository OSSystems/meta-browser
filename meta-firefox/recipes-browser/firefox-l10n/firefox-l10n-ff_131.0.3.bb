# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8fc3ac61aa4230a9aef91327555a225c"
SRC_URI[sha256sum] = "c777eb145294bfb4a3003aca579c2053e1c0e4ff4609e1ef28c2f39c6a055d82"
