# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ba44513561dcc0ce0797f4d8fe18ed10"
SRC_URI[sha256sum] = "c67757b95b6da8b4d7413e3235bcc7d1dbe20928c459334493d28b73413112c8"
