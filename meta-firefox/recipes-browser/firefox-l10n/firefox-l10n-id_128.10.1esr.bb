# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "373c5b9c62ac7ca4d2d83751e573b130"
SRC_URI[sha256sum] = "447aff9b5951d0176dc3241839073b18f42a1ae3634e98a1127230df8557eece"
