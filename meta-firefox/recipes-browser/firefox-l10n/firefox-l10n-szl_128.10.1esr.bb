# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b3691a11a00233106c62510fac7ec14f"
SRC_URI[sha256sum] = "519943ecd99a1fdafb6c4f41bde2ad8641c29f4819212048ef0ba7e773732e30"
