# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2b52e263175aa6ee38d5c6028266d7a9"
SRC_URI[sha256sum] = "3dc03bc03b2ffce88153a34043e99babf479e021f42a244526ec84c84d934b47"
