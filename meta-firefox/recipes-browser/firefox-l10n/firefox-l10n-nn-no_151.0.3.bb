# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "a2924e3c63b2150afb0f8342b18897614108c0f147ef8b8b6da30d0ba5a0c1b0"
