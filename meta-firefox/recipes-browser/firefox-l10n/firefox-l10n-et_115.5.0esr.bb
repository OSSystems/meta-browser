# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5b59d5534b9b28f4e8e0b74a8b6271d4"
SRC_URI[sha256sum] = "f5017f8e7dd001769211008fdeae770b130317c1d5f6e49ff396c524496081b6"
