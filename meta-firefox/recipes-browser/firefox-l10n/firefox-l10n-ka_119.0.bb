# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6c0f88da666e8fd36ce98fc2d29f9aa9"
SRC_URI[sha256sum] = "dbc870adcbec073a854e96115f8965b3e7d27a6b0c7a81263a29a3665a74bb98"
