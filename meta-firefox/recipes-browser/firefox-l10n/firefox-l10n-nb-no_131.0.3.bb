# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "661b49e405cdb406faac097954b1a1e9"
SRC_URI[sha256sum] = "9004dcfe3565e376f6c0596c74c9d97486eae80c9700aa75c33697abd6ff864d"
