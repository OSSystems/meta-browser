# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6ff14e3d86eae629c88fcbdcd31d1d1d"
SRC_URI[sha256sum] = "9b2f11c05c7dea003643949507e3a87121f2d36f79e34461fe6699e80bd6688b"
