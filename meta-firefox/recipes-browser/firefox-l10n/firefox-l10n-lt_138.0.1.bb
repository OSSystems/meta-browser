# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "89bcdf7d6140ff54437491f14f5222db"
SRC_URI[sha256sum] = "ea58ee7dbf933bdce9b4987333494e4efe68ad83df65318ad86d2c21a22b54be"
