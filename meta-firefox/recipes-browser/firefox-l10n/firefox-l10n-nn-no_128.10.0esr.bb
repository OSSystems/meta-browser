# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "638b9648ce8167f486b829c7a728cf82"
SRC_URI[sha256sum] = "8c7683b7a23f70984fe3d924f4909aff1c484fcc82e80bf61edf75c1d7fd3909"
