# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "efd47e47d0c885c886e7ff9bb1c4b817"
SRC_URI[sha256sum] = "e5108a4e309d517cbff3833bd3cc9106d3aa4842a76caba46f1a2f2ca6e64237"
