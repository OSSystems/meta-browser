# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ac0104a1cf0786cee06e79966bbf69a4"
SRC_URI[sha256sum] = "87230a89af69a646bc0a8a612d2644226bafe9cd3ce08d4ca5bd7ed647444c35"
