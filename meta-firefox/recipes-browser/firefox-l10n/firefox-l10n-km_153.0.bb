# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "6967f95e16d77d30a40d288e9f8e50ce0c974a8f8e34a5d48151f03dec248131"
