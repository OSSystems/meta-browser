# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2e848394c22e2ee8277ffd3a45caf34c"
SRC_URI[sha256sum] = "3a47c935f55169dc3117def6797ddcad62bd40f9cc41b96cfe9c7aee2276b92b"
