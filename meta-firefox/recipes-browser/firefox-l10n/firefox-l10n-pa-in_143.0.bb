# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "644ecd0817f00cbb75e9c93457ef1350"
SRC_URI[sha256sum] = "ddd9234c6f73b0bccaf6b2f7c1766867f33e6f5ac79fa77ce0ee61e8a33f3dea"
