# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f0c73033b89d8e6d12847aec73dc9f82"
SRC_URI[sha256sum] = "b817cfd64dc985885a19b1802d6e41441052cb66f75c862216ef958acd6fe9c9"
