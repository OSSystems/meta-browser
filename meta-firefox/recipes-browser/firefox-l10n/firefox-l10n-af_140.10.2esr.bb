# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "89c0cd59f356d653a3bc558aea8d465da45ae59d019269775654395c8ffa6862"
