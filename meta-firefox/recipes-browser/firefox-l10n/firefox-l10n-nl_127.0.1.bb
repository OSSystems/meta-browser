# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3145c0011dc77658bce1486f9f0646f8"
SRC_URI[sha256sum] = "7abf8d767f8fb49b0a8b42c437cb84c21560b84ae5e6f1f2016456935608bd2b"
