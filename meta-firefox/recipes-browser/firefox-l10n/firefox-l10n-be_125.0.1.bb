# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ee260734f5da9b8c0f87e66764646810"
SRC_URI[sha256sum] = "aa8e0703490b008377ec60ec3a283a12d4de8d7a5b39b4a4993527f90ab064a3"
