# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "48e315c9c8578278505cc32194e6b659"
SRC_URI[sha256sum] = "cab0502821b53ada6005fe73436d273753b7682555806fe07fafcb7498a4ed43"
