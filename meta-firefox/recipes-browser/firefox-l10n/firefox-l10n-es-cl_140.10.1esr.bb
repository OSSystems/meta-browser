# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "1de527fe7c35ffee507393d22e8eb625bed9c32c70a6baf6ed8613b6ae791db2"
