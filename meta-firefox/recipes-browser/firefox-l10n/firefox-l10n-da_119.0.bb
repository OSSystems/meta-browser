# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "98724bd9b84f1969fed566600b46a96c"
SRC_URI[sha256sum] = "2c83d9a41ad14be18201e2697f6bfd2525a92d11b226eaf79b3618763e30ede8"
