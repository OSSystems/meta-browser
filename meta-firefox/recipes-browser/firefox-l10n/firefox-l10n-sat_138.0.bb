# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8f2928aa366098d064460e66fa34058b"
SRC_URI[sha256sum] = "335a99a2ca53ddf39de5d2fd8339709e1785429e1c2424386a4cc9a7909e7d4b"
