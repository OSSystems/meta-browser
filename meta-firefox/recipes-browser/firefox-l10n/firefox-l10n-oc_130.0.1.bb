# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8c9ed4343f6d106d4231039d13ee077b"
SRC_URI[sha256sum] = "a559b30ec62fccd7d126369e85c3efd5824e666e1758c2b0f64e6b1b4e52df23"
