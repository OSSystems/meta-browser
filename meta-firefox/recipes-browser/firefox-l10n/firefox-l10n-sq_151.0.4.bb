# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "8a262438a646a96ece091915fa4d7e5062f9808d5b68246ea19ef2eecc105a4f"
