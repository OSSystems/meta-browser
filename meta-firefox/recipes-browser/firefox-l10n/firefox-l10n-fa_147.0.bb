# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d96e8340b0a345d98f1bc9b67b9957ca"
SRC_URI[sha256sum] = "2208f82cfe573e7c98ff47df795df148d5513e0ac477eb43d324dc8108ebb9d9"
