# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b24e587887c8f7e36031684f680d5311"
SRC_URI[sha256sum] = "4754709d4b1438f1c6b87d9a1abeabed00b340d7588304a7a4e0f50df27b83ff"
