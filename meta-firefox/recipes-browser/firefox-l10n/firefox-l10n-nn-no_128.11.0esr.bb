# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0bec833db177a2ed5df4ef39a5ce304b"
SRC_URI[sha256sum] = "3fdf864974ef66eeb5358101eafa4f030d3bf19195490f43e536178a5900c375"
