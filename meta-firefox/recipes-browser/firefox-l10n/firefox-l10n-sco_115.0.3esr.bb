# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1ac35950eef9e4a345d2a74d921a086e"
SRC_URI[sha256sum] = "1568150f6a466554f7bc0c3798c372d41de5d8194e28f610c6af66ca42be831f"
