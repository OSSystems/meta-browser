# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "42c6df6f03e98e174597d8fde0f762a6"
SRC_URI[sha256sum] = "da47c3ab45ae0b3cd4f5240682baf99d805e0b65fbb4fbdfaa27c14a3409f4ae"
