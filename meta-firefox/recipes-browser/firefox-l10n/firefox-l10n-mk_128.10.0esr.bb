# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "58d3d24709d975b6e6369067b72f397d"
SRC_URI[sha256sum] = "dca39977ad4191d4e6a57c0474ad9d1b5b5f3c45e1edc89a3d66bda14f1bf971"
