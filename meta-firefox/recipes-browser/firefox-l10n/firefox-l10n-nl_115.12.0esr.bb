# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "984726abd49bd04e560014d0915f0556"
SRC_URI[sha256sum] = "e2f4158120d0b0638bc44e79ed5cf8507b2a228b4296b8ff3eaa7d33e9d61da4"
