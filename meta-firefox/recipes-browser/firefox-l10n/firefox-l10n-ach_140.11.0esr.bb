# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "285014638897f6600586e88e291e22d2a3d91ec66d016aa7384ab41bf1af2b44"
