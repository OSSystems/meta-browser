# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f717f5b351dcaa3cb22e20c39568e5b7"
SRC_URI[sha256sum] = "08900a462ea707c0af5576e171dc42ff1b97f0ef5cbb9fbf7cdc31a801c7d92c"
