# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "084f4f7e96f3064e35c27705968e3694"
SRC_URI[sha256sum] = "faecbd632614fb36baedf58fb318d169a59a0e862dc12cca46f11682f9b7b88a"
