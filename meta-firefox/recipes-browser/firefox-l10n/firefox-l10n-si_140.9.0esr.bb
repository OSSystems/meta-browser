# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cdbfab2c5161bb22659a6c134cd265f0"
SRC_URI[sha256sum] = "645c0f87ef4de637a291276419dcf051ce43581429641d8e1fe2d72ef3980a7f"
