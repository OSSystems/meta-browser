# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6dc68e20a2a628f3525d78fc1fbfab96"
SRC_URI[sha256sum] = "1ab6a0463ec17d180fe2abb11a1d751b6576032c5597d5145b218962d3cbb86d"
