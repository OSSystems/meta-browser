# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c362a388ebea05b373d49c3935f1698f"
SRC_URI[sha256sum] = "bcda5517df60856652b1aaf4ae17b4d40009560b1fecf2da5abb1f1a80e99216"
