# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a346d0ae801b0fb65e0be82546097a06"
SRC_URI[sha256sum] = "1805b154cec1765467ea0eae3735a88113736ae5bb86e29a53ec7d586a2bc416"
