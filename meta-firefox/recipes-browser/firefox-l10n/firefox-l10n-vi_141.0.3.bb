# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eb5b2c6b3fbbea0dc120d9ba462d9252"
SRC_URI[sha256sum] = "ff0b5508704b0a83c9787e8ed404e82b381aed5778211a1cfdff61db73cd31c0"
