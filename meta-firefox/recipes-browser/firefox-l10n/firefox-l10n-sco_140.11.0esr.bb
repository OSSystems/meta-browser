# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "bba316239dcaa4b7ec069341bd69b318e9641853a1c2091514c6cfc98178fafc"
