# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3d45adf12f59d0a05f95c363937232f7"
SRC_URI[sha256sum] = "72e82728857a41dc222270474f38d255fc63887be11942bdcc4d580091ad1b8b"
