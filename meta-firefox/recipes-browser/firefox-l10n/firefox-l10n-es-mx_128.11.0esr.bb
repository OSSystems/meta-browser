# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f341d2506e9c69f2aa3e12e2f707b116"
SRC_URI[sha256sum] = "f661025c51490671897b2ab83eca0c392c8ab1edb0903859ec14614936acec89"
