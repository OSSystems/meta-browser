# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "61dda3f20b26b57527ee69c87395d944"
SRC_URI[sha256sum] = "d0b5bb53208d7a410e988ae9d67e4db306a74583b521787e6e8f3148c69b2dac"
