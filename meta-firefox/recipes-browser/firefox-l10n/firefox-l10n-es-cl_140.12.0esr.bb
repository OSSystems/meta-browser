# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "5fb46222fc84de67bafd98f9b78627a6625039356db428b5e73953fe9df53682"
