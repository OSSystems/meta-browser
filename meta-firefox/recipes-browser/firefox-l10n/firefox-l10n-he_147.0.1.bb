# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6443a282c9ff87b50524e8c23bf26895"
SRC_URI[sha256sum] = "d1848f81f8d9efdaa105016429d42ad1d3dab6633dda8e161a52a2bcb2ec2a37"
