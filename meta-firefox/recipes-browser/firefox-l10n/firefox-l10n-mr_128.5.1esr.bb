# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ca151fe7148e6374b0cc446eb442ca6b"
SRC_URI[sha256sum] = "7686a708718945ce7ff43ee1a182c6283279e0488f6c9ebdb6d781b1bacd6e9b"
