# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8d780fcaaec0654d937a319042db3f47"
SRC_URI[sha256sum] = "5773cbf4d964d83a7df1e637601fb8882d759b6733418bbf41cfb7c030509210"
