# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "644237e6c2ee2acd3d2aee2b6fbf7291"
SRC_URI[sha256sum] = "bc9acaed68b0d8065358ad317669a1a10f9fec66810d2677d9c9999683730cd4"
