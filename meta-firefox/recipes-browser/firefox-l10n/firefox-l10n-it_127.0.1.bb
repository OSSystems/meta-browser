# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "460b4a50917a77b59781c230374cac14"
SRC_URI[sha256sum] = "80a1e4e118bd82a023b3e13c5da888cbeab1497a8e5b4d76359e55fd5be4cbd6"
