# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a925d2d32987299a1eb9d250fa088f86"
SRC_URI[sha256sum] = "ff6ab5f58855072b21b82006d99b2537c121620e3d715147e1ca3a4c47628d21"
