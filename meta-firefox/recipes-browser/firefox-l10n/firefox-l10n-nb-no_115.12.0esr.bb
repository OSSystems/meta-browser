# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "32c9903e69f7a1e4ea8ddb93cb342044"
SRC_URI[sha256sum] = "8840c99d3482ce4f4e4bdc288dfc1587450cfaf600ccea813abe10a69c286f38"
