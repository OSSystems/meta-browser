# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b2ac6ab42a32b9ddeb6c09029188a991"
SRC_URI[sha256sum] = "9d675092a8a60fd6897f0a2404ce32995baacc491c849f42bf03f72e19a503e9"
