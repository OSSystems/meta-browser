# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8a2e3233316e1727a693f7291b962a40"
SRC_URI[sha256sum] = "f7ebfcd95e28bd170916c4ee5f9959e26be60cd5522c2e13cea75c1a5ef6585e"
