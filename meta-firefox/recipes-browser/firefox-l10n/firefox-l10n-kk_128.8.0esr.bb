# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "00f3ff87890f94b45261b3d60a52f3cc"
SRC_URI[sha256sum] = "66e7cfc4a8ecc3d24b481e02b933ce628e90e0412022a6f77bf382a166343b2e"
