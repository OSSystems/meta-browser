# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "837210c04483f39df71ea67e86b8bd1d"
SRC_URI[sha256sum] = "8008991b01c72f9d405160d08e568199effc664377deee006e43a93117356488"
