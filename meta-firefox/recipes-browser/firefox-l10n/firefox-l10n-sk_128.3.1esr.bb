# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "60fd8d596d34a7c9a3aebf539bcd12e3"
SRC_URI[sha256sum] = "b53c5309e8fecda5b90ad94881c22627cf92bbf2b4fc01c491e819dc04d7df61"
