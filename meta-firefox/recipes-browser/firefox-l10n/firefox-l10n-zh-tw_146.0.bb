# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c43715af98ebab97de658d98f8786ae8"
SRC_URI[sha256sum] = "de34dc6a15b545bda9479d5454a85bf1527ccc078d7720f59ee8bc94a777146a"
