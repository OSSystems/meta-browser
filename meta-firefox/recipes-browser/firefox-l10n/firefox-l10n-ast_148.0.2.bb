# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "235bb596d572af740e3f15dbf12ae6be"
SRC_URI[sha256sum] = "ef6ec9711e90fe52b1565f9e985da04dc0a7e4bb1b69241ad336318a584a2ecf"
