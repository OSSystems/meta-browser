# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cdf9ae20fb5d72af0984e0d8da982b78"
SRC_URI[sha256sum] = "1e132dfe22c9b28a6fce0348c809babf196738b68b64b9d949c7316e95e6c34a"
