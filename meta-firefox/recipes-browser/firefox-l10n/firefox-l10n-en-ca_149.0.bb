# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "336cada8deaf362a9acf40a3e495255f"
SRC_URI[sha256sum] = "fdf9bbc3f3df8008a93cc72ff2daf005705d1a768c50159c07dd5a6423fbf6ee"
