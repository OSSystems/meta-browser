# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "25163164a432ae6c0eea793b891864d7"
SRC_URI[sha256sum] = "6b29405328379bca9e424a7ffdc93ab4a35d31082078764217fb574d820fa83c"
