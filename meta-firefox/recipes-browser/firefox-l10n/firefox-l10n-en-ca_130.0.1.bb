# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5f21f30e5e9586fa1e048b027018a22f"
SRC_URI[sha256sum] = "d708ee50f6ed139e8b85dfdc4b3ab11ad7b12a8237dbcdf0850f0d296455a18f"
