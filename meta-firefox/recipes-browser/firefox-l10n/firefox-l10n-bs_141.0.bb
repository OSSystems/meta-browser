# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c9aa474e6d0314d950ed3a031ab2e0a2"
SRC_URI[sha256sum] = "268a831972553cb7bea79dff868aa93cb6d2288153c574265479ab06103a8213"
