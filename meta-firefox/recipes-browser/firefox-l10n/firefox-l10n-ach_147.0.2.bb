# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "16fb3035801cf8ee2da4b613a975f79a"
SRC_URI[sha256sum] = "7d7cc8b75043637577bbdb476b1fd366bf57049a5a2a5ec516db7e25c6f0dce0"
