# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4ce0c39f3d24fb46b97e78239472513d"
SRC_URI[sha256sum] = "0536ae1273b2c45cd52c89d98b2d99e0466a43bee0fb0ceb03ade6a35230f580"
