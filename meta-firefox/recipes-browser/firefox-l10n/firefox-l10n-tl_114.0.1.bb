# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c8939e7084d1762ba83c70eb7f21ed45"
SRC_URI[sha256sum] = "b45aeaa8371d0f9fe98226fe8a6f57175af35195fd56f4aacfc001a1f89d8e80"
