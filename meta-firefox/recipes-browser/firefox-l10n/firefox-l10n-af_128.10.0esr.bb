# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "293a2967cf6c4cc6bfab01851c1f0c57"
SRC_URI[sha256sum] = "6ccedf01c045d8d8e834e4d8d7cb752980fb19e2419288aaf06f8e14ec23c1c3"
