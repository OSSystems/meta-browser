# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c58bcdeded59890070c09ce7cbda2151"
SRC_URI[sha256sum] = "4f15f5c862dd29b8226cd9af49c18558a05b543ab537699a68b10a45557ca27b"
