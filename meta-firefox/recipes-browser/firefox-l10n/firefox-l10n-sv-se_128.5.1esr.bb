# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fc83fa60050ff0bce4f085d3f0971860"
SRC_URI[sha256sum] = "66763c8553296e093f3c19b40e9b546faef76f07923af3d42b01c5bcc3200f08"
