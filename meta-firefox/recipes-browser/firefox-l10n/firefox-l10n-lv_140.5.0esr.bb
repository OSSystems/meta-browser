# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1966cdd3f11f687293708742afc8b0b0"
SRC_URI[sha256sum] = "5dcdc59a2126771ac418574d25efdebe26455b64c0b8913453c0cf063ab8b525"
