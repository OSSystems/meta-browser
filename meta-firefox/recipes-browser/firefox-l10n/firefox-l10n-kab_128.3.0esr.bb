# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d3d7de75f3bf23dc7999913e018e707c"
SRC_URI[sha256sum] = "8aeea864ae48cc13677551e2cb8e6e03d8bed401b708b531072b4eb4d751251a"
