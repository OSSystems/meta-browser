# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f2d2444eaed6006512258f369c46c9de"
SRC_URI[sha256sum] = "81a1570915234ab3d5139724a9b31c00e64c141405ec102e87093f1ed0152c13"
