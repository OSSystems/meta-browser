# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f1356e8d161101f39e19a420be1db43a"
SRC_URI[sha256sum] = "0ed06154e012148059fdbb29c9e0a00794ee33ba0fafc575402f4de11b8d12d8"
