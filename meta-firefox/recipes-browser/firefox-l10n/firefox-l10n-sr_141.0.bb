# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b7e7986d2f06e1a510ffcfa3e7c342c6"
SRC_URI[sha256sum] = "9a9a10c466d454ee91952797e716cacb845363e43a61f04e61c66eb1141b845e"
