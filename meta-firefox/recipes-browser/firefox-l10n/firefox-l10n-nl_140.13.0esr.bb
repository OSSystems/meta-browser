# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "f706184ad1582492a7d916e27ac9463e949e9e17c87b319dc0d8bd4cbba2639f"
