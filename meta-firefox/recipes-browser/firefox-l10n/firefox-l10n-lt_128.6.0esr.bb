# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b57136334d75bb9e2de6bdf9fb20205f"
SRC_URI[sha256sum] = "cd79599ff3bd119064120d72de0b69a412cfc2669f145bfd29987abbedbd1a3d"
