# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c77db52ac433ec245cc316e62bec651c9f6e739bb786e8a10ae4941d5cebe19d"
