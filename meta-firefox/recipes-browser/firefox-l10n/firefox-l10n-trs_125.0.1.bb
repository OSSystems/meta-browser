# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "76214f96772f85dc82bef231c7aa748e"
SRC_URI[sha256sum] = "5510d6d3cb4ee8793181e5b476570a5e43f2d9e21b6fe8e96f5abba0d34f05ed"
