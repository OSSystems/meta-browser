# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "72d6d14f1e5afde4315a225461960e14"
SRC_URI[sha256sum] = "61602aae3284351e2182206def7dc5f017984a22eebd43ec12bd2d9638c77c55"
