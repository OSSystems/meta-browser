# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ce112f97c5a5e49313ac98874a655543"
SRC_URI[sha256sum] = "9a02f5c14be79568238bc46413dcf2ba55f4b6022a544cf29f3ba7bec433ff15"
