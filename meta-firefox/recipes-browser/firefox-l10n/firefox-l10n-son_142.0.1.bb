# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7f5df7bf4e90df80bad1ffc4972252f6"
SRC_URI[sha256sum] = "3de8da59af2e55acc3a44c66cccba2a31305e66eec2531c3ff5f144ef468fca5"
