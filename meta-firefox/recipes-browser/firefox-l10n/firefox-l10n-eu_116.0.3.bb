# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "01af98ccd47b3701abc84f17019084b5"
SRC_URI[sha256sum] = "89e3363a5a966f495d97b0ee534f3ad7c61e14f8dd2d1a56dba3857fac1d3b32"
