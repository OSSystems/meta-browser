# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "230501b20ef88c2b41b1ce57835296f9"
SRC_URI[sha256sum] = "8f4984d2d1ef44c868cd9b9890a1b8b2125bfb3baef99072c6011edbf3e2c3b0"
