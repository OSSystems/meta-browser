# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "917a6847c58c963b918393b0ee86dea9"
SRC_URI[sha256sum] = "7c7549440295c5d66afc3c8d5c9f07e380c219751b5b284d8ff7fc5d316902ba"
