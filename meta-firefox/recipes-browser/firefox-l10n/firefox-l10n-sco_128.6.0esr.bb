# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8edffe9f3e4edf6cf0e6b47f6891e003"
SRC_URI[sha256sum] = "5c0cc4bf921da24ccdf88e9aabda2334369ea37569d475669616f0ed81a0c1bd"
