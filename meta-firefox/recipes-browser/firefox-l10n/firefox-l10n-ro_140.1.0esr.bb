# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0fe07213a9d7c795a167725dd1e87c00"
SRC_URI[sha256sum] = "c19fa52ed10f2c9d15298e473e176c3e662b21f18cdf40b26bc66824fdfc56fb"
