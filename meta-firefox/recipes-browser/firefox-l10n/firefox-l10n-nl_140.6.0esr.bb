# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0f626c3ed595a9c97c8eb645891e0a6a"
SRC_URI[sha256sum] = "a1163f434b22293bc52af5a4e27fe648c9399a6d167a13ecb83934778f4b0b68"
