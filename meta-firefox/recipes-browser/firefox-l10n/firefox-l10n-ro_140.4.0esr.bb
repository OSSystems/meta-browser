# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7d180b6a8f538f3f7836dbefab31fba7"
SRC_URI[sha256sum] = "8fd1e26bcb06f39a9a58b22370f68aa55f36dc023d8e09015656e80233a0c390"
