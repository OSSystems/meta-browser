# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "847ef157cbe0d14fb2d12019e9801f67"
SRC_URI[sha256sum] = "c4ee17e4fd5df9f77c47d8303fd5bb20aa5aeb7f95a745dd91607e0c12c89b58"
