# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d570623576b29621e12b00c83cbb5273"
SRC_URI[sha256sum] = "0aecf1ff1ccfcab716c50034a05b22ecb95d2f840944db55f5842a50f8d3d3e0"
