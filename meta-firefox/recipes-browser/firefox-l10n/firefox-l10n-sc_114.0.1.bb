# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4b170ef996139b0910d23de85af71570"
SRC_URI[sha256sum] = "6a351adb86b8901f78e60b47c4a8ed4a8e75dd965c46b00cec4f88096715ebc5"
