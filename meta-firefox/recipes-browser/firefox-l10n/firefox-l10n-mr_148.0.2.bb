# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "22334e85fe17487038f5898a155b0de2"
SRC_URI[sha256sum] = "986a4f15eaa9c3ae4f29a0d787680db6dbd639e301951a9fd64909ac7c147b96"
