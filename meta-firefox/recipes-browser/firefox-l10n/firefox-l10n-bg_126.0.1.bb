# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5794aef1a072116f9741c5e56240261a"
SRC_URI[sha256sum] = "5206e57c82fc80e7333b42318624bdf944877d39cd81124a1df992ddc52668ca"
