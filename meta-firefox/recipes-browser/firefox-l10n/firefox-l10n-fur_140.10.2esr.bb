# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3ca76dbc9333ca52a93702c2978f4714b6d3b3bed7c6c5985cb5a5201e53d90e"
