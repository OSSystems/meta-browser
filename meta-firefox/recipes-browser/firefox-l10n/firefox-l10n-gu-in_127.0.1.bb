# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2f3266472f67081853c9b05de79fb1ca"
SRC_URI[sha256sum] = "bab315d99c7ce3956b931517ff90f790c73d37f710b9385ac9f2951a67bb0bbe"
