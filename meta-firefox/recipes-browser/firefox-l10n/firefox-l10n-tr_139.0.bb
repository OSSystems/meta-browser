# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d612b84bd24e9c1366f7c33799228a69"
SRC_URI[sha256sum] = "8d453dd04ec8a82471af8c17b8e9b3608f81e054df79b5df9fb570a391b2bcff"
