# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "dd72a400720034c21198c8d17a6b48ab4a6afd5845317b812dd9a654647d84f9"
