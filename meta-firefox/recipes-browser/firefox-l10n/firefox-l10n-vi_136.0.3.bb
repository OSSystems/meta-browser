# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9498afb4f42dbeaa03db2cdba8cde12a"
SRC_URI[sha256sum] = "b045d7669f13d66ac070bb0cc058101bcecd415adbd286facdea85a407504ca1"
