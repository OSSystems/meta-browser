# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "522e68c4444da6cb699793e23ed7ceaa"
SRC_URI[sha256sum] = "cb865a1c3696a0443b7b310a777f49cfc0ff107d550f779d7b3607e9a399b667"
