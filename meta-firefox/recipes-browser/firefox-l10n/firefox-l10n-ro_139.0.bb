# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "301a699aefca2c3bc2a8adbe442efb9e"
SRC_URI[sha256sum] = "44ea97ea7f75a764c30b70f928a89a587d84a7229b7349ac7d337d764bcbc178"
