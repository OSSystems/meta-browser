# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "48632de6d5fb53e6bb4ba1017b57e928"
SRC_URI[sha256sum] = "d809b7b73902c5093d81c5746a202e0b250d9b6c6d3bdb79085d905a4d4a1f8c"
