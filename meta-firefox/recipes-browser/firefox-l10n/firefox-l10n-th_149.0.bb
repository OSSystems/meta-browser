# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "29cbd79de568d6a3b478c98992e7cd74"
SRC_URI[sha256sum] = "bde355f45667a580a5bbf1896d89608f6b0248d1561ab34d6a1c66aa65d45d2f"
