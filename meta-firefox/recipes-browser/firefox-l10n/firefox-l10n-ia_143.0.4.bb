# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "79ec87348121d859a07167462d56c5eb"
SRC_URI[sha256sum] = "555ab89dd064705ed371149fee8b48b929d6aecd5251884c6bb99d34e82e05bc"
