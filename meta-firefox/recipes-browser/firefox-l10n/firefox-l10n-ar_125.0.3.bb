# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ca13ed7ce5810263b8897f288e52d7b7"
SRC_URI[sha256sum] = "fbe068aef2bed761e854b3d926e13bdd731480f73a72fe7a57e3acbc81f49d07"
