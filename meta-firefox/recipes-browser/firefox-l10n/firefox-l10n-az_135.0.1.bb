# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5e5e42ad62d795cf90e7c57e74bf5882"
SRC_URI[sha256sum] = "d736db60e86081b7dfac7685bb6550fcd7d4d822ff619f0d3d53ec2c9a032e0a"
