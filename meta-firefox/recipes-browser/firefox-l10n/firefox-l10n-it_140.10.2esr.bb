# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "b57ce4e841758afb4563c1c5e884a248486bcdab3d01f99c4f74e8d88a5a2b62"
