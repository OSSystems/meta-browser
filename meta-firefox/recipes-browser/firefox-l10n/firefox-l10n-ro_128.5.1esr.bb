# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a10c060b555325deb7b4bb4dee9dc333"
SRC_URI[sha256sum] = "aab8e62dfbbb2c2fec78e7250a98b71f95fc228a01114953ec3d0fddc8db4c53"
