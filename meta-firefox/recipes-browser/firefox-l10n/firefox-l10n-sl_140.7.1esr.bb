# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "35dd10802fad75026da6b588cdc3b70e"
SRC_URI[sha256sum] = "aae548479fe30cc45d3ab82d41ab0c6bd6fcfa81dd2b580bf361720b8409ab51"
