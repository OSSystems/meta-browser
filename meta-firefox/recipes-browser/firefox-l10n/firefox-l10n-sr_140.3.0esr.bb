# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "16a97127b6459b1437633eaefc7c7bff"
SRC_URI[sha256sum] = "43345a4c8211eccb9de33166d6847bc69fe17d10beead1d3d9589394c0a92b85"
