# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "93ab7a3d1140f04025206941d1a4b1d0"
SRC_URI[sha256sum] = "168370baeed3d48e2c4dc601985bf177645f64c8b3c1cfbdd74f4fc0fecf28f9"
