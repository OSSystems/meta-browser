# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ec8164d243d19491767de4aeaffabf08"
SRC_URI[sha256sum] = "83aab0693107dd43896d4fe3dc37b29442a3271a8381c9a1d466c3101de13a93"
