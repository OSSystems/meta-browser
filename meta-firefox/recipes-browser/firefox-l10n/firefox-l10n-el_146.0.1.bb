# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a29b908bfccb16fe5649d58ae9d544bd"
SRC_URI[sha256sum] = "53fd20e6363aa14629e3398b94ca681d3e8c562c6d34f61b41ce5b034030ce5d"
