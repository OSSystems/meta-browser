# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7f6cb889e2bedaf9a36241500947d67a"
SRC_URI[sha256sum] = "a76bff7ed33f213c485a421e688b8500df5be7c47ed8c45accb360ebe99feb79"
