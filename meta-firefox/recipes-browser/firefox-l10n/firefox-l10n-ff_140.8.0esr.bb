# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3cb4847edb6ca02b796a65810e035b0d"
SRC_URI[sha256sum] = "f6aa7669ba30e9500f8aa4195a34371451777470a74f4b2fcd7e6a8826d6db2b"
