# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0017f1370944c89a0c64fb2e59d29ca3"
SRC_URI[sha256sum] = "03351c06921edc5df7b4ba299949f6146aeabfc93ab2d573c5fe64ed9963f6de"
