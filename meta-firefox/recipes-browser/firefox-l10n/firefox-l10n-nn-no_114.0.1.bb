# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "59dc87823ce0232dde4d478596439559"
SRC_URI[sha256sum] = "44c865859294d3304b9fd689b5d4445511c222973e037f5e4d7c54803e1a059b"
