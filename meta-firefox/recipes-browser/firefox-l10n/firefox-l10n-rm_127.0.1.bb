# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e5af7bc64c12262afcef4207fd136567"
SRC_URI[sha256sum] = "c378f4164ca72071d7e3537ac97c4ad68e2717e81408581ec9fa889087105ea1"
