# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f1e94533611ca3a0ddeb2434b757ad17"
SRC_URI[sha256sum] = "de79b55e19ab50f33c7fa4bbeffef1721ca1bb59642b297eab5ff56333426321"
