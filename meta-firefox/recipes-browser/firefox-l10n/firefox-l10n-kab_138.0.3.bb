# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6bc7b84baf158ab24b813c1d01187999"
SRC_URI[sha256sum] = "3ff4f0e02ffe8b4d6c6692f889209a9400a8c30cb72d19eca8f491dae4653c50"
