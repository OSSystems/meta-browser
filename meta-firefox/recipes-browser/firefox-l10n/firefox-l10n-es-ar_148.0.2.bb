# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "72c574c8f24bfb18a94fafd8f525b60b"
SRC_URI[sha256sum] = "7c89fa810a60d885a69b5aa573c253a8b87bbaf40722c84df92ec58237e98dea"
