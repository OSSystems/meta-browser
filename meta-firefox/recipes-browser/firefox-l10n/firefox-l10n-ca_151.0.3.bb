# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "64bb74a9e90dd3ef985d374ee3caff3a38d69cab4ec37179b7e63023d3a5effa"
