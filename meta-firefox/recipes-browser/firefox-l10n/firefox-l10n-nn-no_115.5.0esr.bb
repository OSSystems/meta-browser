# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ae5cf6828f83456620f73fdd9fb93af4"
SRC_URI[sha256sum] = "c73429a67c1504890a66ebec1d48982a93c62788c6da9a237cb675557619c668"
