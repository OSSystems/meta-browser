# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a29c4e58cb6959e351951e9a131d61a1"
SRC_URI[sha256sum] = "c7618bceac7a132e45b95603a4b5414e174bae96d75fd5a4f91fdb11f84ffcdb"
