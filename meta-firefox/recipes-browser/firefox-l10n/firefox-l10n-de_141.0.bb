# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ef49d4464bd080558f857c2b4e32dedd"
SRC_URI[sha256sum] = "bfa0b0e3b53eb1074883aec68e871ca81ead3e022b9b4ba1a554a37dcce48ce4"
