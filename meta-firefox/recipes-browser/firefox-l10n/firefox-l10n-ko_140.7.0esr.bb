# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "24ee52004f819059a7d504993da9b3ff"
SRC_URI[sha256sum] = "b3175784beef0d5a6f1939ebfd77c20ab5da1a59e58a3fb6cf46c674f1a6c101"
