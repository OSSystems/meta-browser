# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e247a6e1dc675256276492a988210fe0"
SRC_URI[sha256sum] = "1ab92cf11750e7aa89808fdb6a7078bf1b1ab5b668db4ee52c61bf1231931573"
