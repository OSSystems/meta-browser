# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "28b8bde933d4274f10d1eabc4882abb1"
SRC_URI[sha256sum] = "c3f448e7d0af9f844f14b0e584768fd9bc3ce526e1f2369b3edc4702d11c627a"
