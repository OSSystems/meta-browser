# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3464ac450427f7a2808efd02badbfd86"
SRC_URI[sha256sum] = "93ef40bcf82872126b2272523314898c9fc9483cada97b48195ddafe1cc816af"
