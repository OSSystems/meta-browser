# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3d2e3926c9927b56a92bfe2173a7c4aa"
SRC_URI[sha256sum] = "b2191ae54e0a177a1046b04ef5ab26bb6e02b7538da7e5063e8a39b44c46ce6b"
