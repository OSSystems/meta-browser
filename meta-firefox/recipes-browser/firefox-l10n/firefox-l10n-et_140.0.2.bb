# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3880b13e8818658ae8b425a27d5f002c"
SRC_URI[sha256sum] = "bd52718c6071034e6676b1c992c5778d46205243b47d02d3e371b7738e211fcf"
