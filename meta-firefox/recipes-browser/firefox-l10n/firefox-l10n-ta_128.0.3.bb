# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9b8fc93e1f7d1a4309f4a3c7fea04626"
SRC_URI[sha256sum] = "d1a12064bf777422387ffa73feee23dcd0018db9269caf663c774c959473d1d0"
