# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a91268ffe61f90c02e9c07d7eab2168d"
SRC_URI[sha256sum] = "7f55a01b40f52152f9b14bb3b797ce27bdadbac55bbc08ea272b71118163c745"
