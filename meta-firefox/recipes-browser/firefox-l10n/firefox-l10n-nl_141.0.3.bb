# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "032ce05778f4bce424a54ac1e5ae79b5"
SRC_URI[sha256sum] = "595ff99c3149a08074286dd7f3930573f8c483512ff7006b841e19a08f129ff6"
