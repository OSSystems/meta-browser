# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "a9bedfed567e21a9517d97c2b1a9a68fb7de5bee3a01e53a84ba49274169922d"
