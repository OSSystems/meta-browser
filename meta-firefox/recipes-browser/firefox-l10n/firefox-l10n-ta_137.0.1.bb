# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f93417e2adee6b3d48b42db1d883f4fa"
SRC_URI[sha256sum] = "39b6ef89476f9a0d9e9cc6e2fb6849954b2a2f4934ac6cdf8d7e7fbdeeb20992"
