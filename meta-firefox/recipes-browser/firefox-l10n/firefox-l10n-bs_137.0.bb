# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9f1b88f0958a7c5eb3e8d2852acb3ac0"
SRC_URI[sha256sum] = "b87985cc62774e14984b41b231f7998bd4d127139b3d1a180128af6c277fcee2"
