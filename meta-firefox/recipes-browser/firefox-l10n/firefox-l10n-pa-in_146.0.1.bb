# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "666ff933037011fdd6d269c777ac1b62"
SRC_URI[sha256sum] = "1d22443c64e9da78e677649f185819780a675c65b2bcbfc9a305f62cf972af93"
