# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cc00ddaf2082999ce6c8153564fe6540"
SRC_URI[sha256sum] = "4dfc817aebaf3f29f5321e4673940459a7c443daca02ed2135904de38404850e"
