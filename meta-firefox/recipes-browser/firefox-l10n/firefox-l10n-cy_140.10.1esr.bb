# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "508c43d513ee25a3b412057cb2db924b9eae391ea686cacb12d886702b5a1886"
