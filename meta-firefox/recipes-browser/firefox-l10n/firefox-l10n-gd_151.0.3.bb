# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "a8d6f7da0f0bad1aa583157dbb38f2f0baf70e732e9a65fcf74bdea8dc94d4db"
