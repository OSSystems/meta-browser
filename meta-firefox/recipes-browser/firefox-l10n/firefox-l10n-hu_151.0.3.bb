# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "11d3848c6ea5bc3ba00ed713415ec35a6eec82014300053392180f1eda19595d"
