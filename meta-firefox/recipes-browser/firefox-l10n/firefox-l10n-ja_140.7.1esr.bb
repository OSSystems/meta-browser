# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "edde22ace39fef44aff8e9608da81ab8"
SRC_URI[sha256sum] = "025f5aad9e7b2b559c9acc9ffed3b713dd42f6e9df9aec3d7c80207fd12485ae"
