# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "beae95be3f8665534f56b60238199fcf6a3679c7253e2ce74cd09f17e12a64f5"
