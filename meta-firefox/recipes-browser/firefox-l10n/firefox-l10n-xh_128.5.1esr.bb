# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a519d11188d59be0e94c0da1d80b7441"
SRC_URI[sha256sum] = "880cbdffcaadaf516d018502fa5cc96dafc689aab6befed3d747e1be7d474e20"
