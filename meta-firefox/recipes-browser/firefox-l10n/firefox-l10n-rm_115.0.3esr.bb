# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c9c7bf1ee2bc52b2c2bc7f85d4e3e4b5"
SRC_URI[sha256sum] = "2ba7bcfb9c65dd377e7a1207c65ce6a2f29c5fe96f2f0c6dac29d56c1b0e33b9"
