# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c613f3bcf24a5ae4a4d82c7700b1ecd0"
SRC_URI[sha256sum] = "269af50c4377e878a5b487168d44ae8ffee95432554f0054a448b6beb063b767"
