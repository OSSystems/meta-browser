# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eb42a3dbe5b26356ea3d4c9984c7bff0"
SRC_URI[sha256sum] = "14480068202933007c663fe2b1163d4aa5e405f010978461f2453e440898b858"
