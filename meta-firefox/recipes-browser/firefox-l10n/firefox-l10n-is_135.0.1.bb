# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8c789aabd2cea9fbb34225cdadba40e1"
SRC_URI[sha256sum] = "0930541481bc9c1b550af95b71a271a91ffaf7193e12e7d3734f8dd366a4ce46"
