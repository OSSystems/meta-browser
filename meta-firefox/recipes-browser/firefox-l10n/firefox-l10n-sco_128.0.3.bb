# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "007e2e73b8f0c33d819a97325f0012e4"
SRC_URI[sha256sum] = "d057cebb519a8d307eabf13b8af2320f1393c34a8c2f3f08fa8a99593c690cf6"
