# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6b979341d594eca6412a37740ad467ea"
SRC_URI[sha256sum] = "ca9dbae9785e36b61a14eb9afcdb577a81f6e40b9b8d440f45d30129b57db84d"
