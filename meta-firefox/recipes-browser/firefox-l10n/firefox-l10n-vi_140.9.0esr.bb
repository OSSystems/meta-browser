# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a022b07c07a04265ac0921e00c785fdc"
SRC_URI[sha256sum] = "89d9a278ccef3b0e36d24803a7542dade25cfafcb7169eab652ef40ce2b35b24"
