# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7f6caf3c3ce12491ae09fa60a4230c4f"
SRC_URI[sha256sum] = "e2b3f759b830fa89781e07601dc2e75f554053fdf5959916bc4aa77300f7a8fe"
