# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ffd07dde3ad94b9d742ee93852ed725a67503d5f0966506d97bbecbc4486a000"
