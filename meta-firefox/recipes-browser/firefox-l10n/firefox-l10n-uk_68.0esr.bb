# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ef0d797f6d8f98cc4e738cc670917521"
SRC_URI[sha256sum] = "9278bf695304a24941bc5aecd62f14017303bd714d2d163ed654ca1f4926b877"
