# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "24bf5dfddb70929f9739782e8572c46b"
SRC_URI[sha256sum] = "acfc2baea7813831196f65846e13a7e10e7c031cf57671ef137443b3ea2f06f8"
