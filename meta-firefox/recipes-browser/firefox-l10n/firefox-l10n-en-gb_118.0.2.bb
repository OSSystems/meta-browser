# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f47d8a62608cf1b29e2cceb66306e758"
SRC_URI[sha256sum] = "84cfb8f87bc90bbf4d1a84556c09dcd5ea8ca2a2fecc0955df621b51f7e8bcb4"
