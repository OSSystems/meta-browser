# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "052230df138df21bbe3cd673c560096f"
SRC_URI[sha256sum] = "caed4cf00f66162671a9039e875187d3270017a068cf62642650b1853f7aabcd"
