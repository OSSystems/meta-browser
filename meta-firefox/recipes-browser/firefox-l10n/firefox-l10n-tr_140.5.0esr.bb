# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "37d3292fae153b1c1ef9c2f04faf3a09"
SRC_URI[sha256sum] = "3c71e798ef623aee947a717126d304cb4faf3bbb01c13152bc8efe948a221544"
