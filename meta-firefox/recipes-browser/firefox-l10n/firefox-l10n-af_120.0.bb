# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "62a3634198a250f4608e32ce64d09f01"
SRC_URI[sha256sum] = "4b3d79157a3271a889bbec803849e1c209117a5f00f52654a65ce0336d4639a1"
