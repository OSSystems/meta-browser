# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "116890c8866c2b40de21de0c3502d114"
SRC_URI[sha256sum] = "1ece4b9f3500f436dcaf1fd488d2caf6db71db5b4792c317c4718ecbc209f432"
