# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c8651cc1140e8d263bb77c56b007c512"
SRC_URI[sha256sum] = "0cb3a4eee3b4f1b6bd46793e2b0ccc05cf4c6ff8db726828c5b662b5427a357b"
