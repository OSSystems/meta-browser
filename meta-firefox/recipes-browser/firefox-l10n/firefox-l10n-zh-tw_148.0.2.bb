# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9d460a202aeb38cfccc1a348aa5e0cd0"
SRC_URI[sha256sum] = "aef149ea3bb0a2f252f6d6398f4c4dd7172401cf98db11fd38ed92ffa0321221"
