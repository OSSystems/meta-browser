# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6e860552b591a14a1fe23db64a9b1fa8"
SRC_URI[sha256sum] = "475ac5c1fe8d07a665a365d2049d85188466b94dbe5e1bf42fa087fd2d63f4bf"
