# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2a76b04534306e48227c9bbc5d1fe21ca8a0f4ea18a97a33785a0fc42f316723"
