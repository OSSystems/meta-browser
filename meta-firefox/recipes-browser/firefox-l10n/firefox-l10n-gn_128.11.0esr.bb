# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b6533a91ee81903ef9c8ca00870b2c9d"
SRC_URI[sha256sum] = "23beefe2bd6abb9980ee662f1e1c8c41936658c6c2a9f0e178d6ec9c5c8d90a9"
