# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a625b23223c463016f4dec3ba1b82ce6"
SRC_URI[sha256sum] = "d7d037477c09b8f3cdbebdf73acbf4639385495453c43c6845328c814cfe6f8b"
