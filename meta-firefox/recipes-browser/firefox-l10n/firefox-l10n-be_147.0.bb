# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a1a2a3c5709e249fef3e4c430dc2a1c9"
SRC_URI[sha256sum] = "576e327f940ef1e502ecbca2941af223d67a0e8f9c4d02ceebd2293633500d74"
