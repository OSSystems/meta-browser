# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d19e09d9142ebb005abe3e2f3cdc6d41"
SRC_URI[sha256sum] = "ae9b7dd38431225bdcbc1f7238e7fd5111046368c4fc906b75c60291e56e7fb2"
