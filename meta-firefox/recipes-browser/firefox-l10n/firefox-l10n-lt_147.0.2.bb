# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "338b9979fff5a0d117c1e355d03e1b37"
SRC_URI[sha256sum] = "cd36b89a6f6a7c69633d6d778ab56895a78417779bc6cb3a03ce20288418a424"
