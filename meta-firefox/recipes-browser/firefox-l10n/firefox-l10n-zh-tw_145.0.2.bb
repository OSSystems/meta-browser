# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a52243bf6efa711e69e4685dce36e109"
SRC_URI[sha256sum] = "f6bb8abc28bffbe90afdb3e122143c01aede77a08e31d50b0bbd3440f7b32fc7"
