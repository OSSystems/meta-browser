# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "46b41d30a29e021ba8868fbebde964a7"
SRC_URI[sha256sum] = "a089c4977da4e8902c9f7c38e752bf8bad7dd334cec6a1155a9d7f405cde9a6f"
