# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c9dc1cfd39766244ffd7d29121758c5c"
SRC_URI[sha256sum] = "1df5196a113638c4968078b4c134348064d319b71d34f969adcabb676a942a0e"
