# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "958a52ebf3b388ca4c2b46d4f3d89a62"
SRC_URI[sha256sum] = "ee850e82f83c7c403ee1095b9f9459775e0a110974816f663831695d2b8e7e20"
