# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db4752a48033b2eb144e33019fef37c1"
SRC_URI[sha256sum] = "f65594087c09028680550a5c72a0d4fab737ebde573fb85669dfdaed6ec16a86"
