# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7a4ff3fc070711abb4cc7575b756790b"
SRC_URI[sha256sum] = "f964e7192f297b8f6b4c015a150630e126cafc0738f48d89b3020e7743f5317f"
