# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c908601d38ca8db44fc782a31130df4b"
SRC_URI[sha256sum] = "face3b86d7dc48ef013e48da6c6a9451afee0d6391090779abba025caee928df"
