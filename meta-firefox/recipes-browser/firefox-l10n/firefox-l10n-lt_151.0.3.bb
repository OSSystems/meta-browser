# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "6419803c9ceae07feec2db118e1481adfa8ab87930a9861e29ef684d69141e2b"
