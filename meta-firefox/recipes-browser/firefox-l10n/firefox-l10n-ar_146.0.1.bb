# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "69c5a76a11e50a636108116289193a6f"
SRC_URI[sha256sum] = "8aa0c09d7c8fa4ba0463f99cd5a42e149e79308594c137afb7d8e43bbc57e9f2"
