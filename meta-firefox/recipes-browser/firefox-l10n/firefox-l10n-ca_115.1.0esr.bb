# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4aaf59433d0c22fc99c037d378319b76"
SRC_URI[sha256sum] = "4db0c4e7799c91cbcb0f5b797162b2a276d1373a5054eadabb818a37d229905b"
