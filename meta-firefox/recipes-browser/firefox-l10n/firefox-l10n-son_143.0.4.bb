# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b32c30ec2bc77791191d081704ba8463"
SRC_URI[sha256sum] = "cb48d245701289bb96ea9adbca9519fb6219334a6f37522e4dbdad58fd893702"
