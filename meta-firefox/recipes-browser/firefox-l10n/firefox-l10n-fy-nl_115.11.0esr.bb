# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7c819a3b52be87671bf477efbeeeec37"
SRC_URI[sha256sum] = "f292cfe27c86b1ab26a7d9d9d3ff4c873653bf5adc0f02308c339a8fa7856e3f"
