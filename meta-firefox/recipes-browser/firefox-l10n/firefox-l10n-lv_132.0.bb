# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ee873c79300c4e403eb3b5c8b30ec13c"
SRC_URI[sha256sum] = "27831f859a971c85c03e51b4da7fef1d8d65959ffc5bb546e1cbae6a325a2944"
