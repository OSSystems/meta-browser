# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "09fed02a21e43c6ac690ec73bf30fa0b"
SRC_URI[sha256sum] = "34c63990263912693f82ea08abd754f2cd529469d4d3cd2362e63b4ec434207f"
