# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ed0f84f897a668986cd72c7a7550a4ab"
SRC_URI[sha256sum] = "4437556e2c80daa97153d566ceb55255bbd42c08fe6ef7d3cc363140c5d8f55d"
