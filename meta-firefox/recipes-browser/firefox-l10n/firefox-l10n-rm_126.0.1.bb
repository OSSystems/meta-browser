# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0d35f8fd80da7ae2d575c191bef878f8"
SRC_URI[sha256sum] = "485142d1b1c729b942ea495f8ed42950cccceb033c3ae455983ff33212e99d51"
