# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "195e4058fc99fe78819444aaae00dfca"
SRC_URI[sha256sum] = "50b21f2a90adcf51a68e1b698860e1ca1b67f6ca751a83ac556286586d14a08d"
