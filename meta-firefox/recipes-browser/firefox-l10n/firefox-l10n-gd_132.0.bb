# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8dba9ebaaaca8ceb99f9ac2b9dc99169"
SRC_URI[sha256sum] = "75fd3561792b11933d17af1ce3f6d38496c1850f8b97516d121dac6b4c9158a1"
