# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "03ab5533040aca48c4b87c82e93a3909087728d371ef0f2323b3cdd169fdcd3e"
