# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "16514e4d1af15da886090ff3718aec72"
SRC_URI[sha256sum] = "7bcb921ba6c427846d23c47180930e8057401d33e4cd3afec4d43aa422cec13a"
