# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "11cd14b5e4bd5e9f39e6a71990d0796c"
SRC_URI[sha256sum] = "331b8e843b435ff9a9c685a231e06106cc6be471f83a906114b78ba40fb5dd82"
