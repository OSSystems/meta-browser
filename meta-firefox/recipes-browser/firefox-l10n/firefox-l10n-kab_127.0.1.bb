# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "337a2f5498baac429c1786310e11176a"
SRC_URI[sha256sum] = "52f538f8c8efacd23af07c03295fb10c8e6cf6b8cad012ca672d7159b9e62827"
