# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "09d916380b553e62af58fead93270481"
SRC_URI[sha256sum] = "29d95f9f2126869cce17f086238f473021f4db6b4f067bdf49d1ebfc26c69005"
