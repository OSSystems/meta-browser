# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d1748792b44b756c0f9930712e223d4f"
SRC_URI[sha256sum] = "6ea4f7dfff64848f1e67ac9d390962799f497e84c553337a33362046913a35da"
