# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f95b3cfc4ea13e117985a92c6484a829"
SRC_URI[sha256sum] = "73c829bdb13028df607e5a29aef8dafb4c08b967093b1367ac0e2e4c44138405"
