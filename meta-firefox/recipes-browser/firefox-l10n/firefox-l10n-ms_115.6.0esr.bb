# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3a4c32faff5fd9f9e403a1c9deda7f01"
SRC_URI[sha256sum] = "80880f5ccf7499731eb6d23e177b4e275d24f310d2cf3c5429186ad92a0c0c04"
