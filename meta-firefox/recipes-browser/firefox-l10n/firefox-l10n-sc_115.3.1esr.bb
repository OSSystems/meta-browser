# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "83d9541d8ab9f048367343dcea17a0a5"
SRC_URI[sha256sum] = "e5d832472dbd6f21dee401dd4cd0e0f2484e9e8c7d912f01c53f3a94876434a4"
