# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "62ec0629d6a8ab60c69d76c24fd1de80"
SRC_URI[sha256sum] = "51551d9ae99d5702f41b0767add2ce38500d305c40aa99998a5a79f57b09fc8b"
