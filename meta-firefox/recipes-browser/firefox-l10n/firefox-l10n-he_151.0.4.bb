# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "5df66c030c02abda64606482f80a522809cc0e42d84e2bd4c2fa9fdb1d98024f"
