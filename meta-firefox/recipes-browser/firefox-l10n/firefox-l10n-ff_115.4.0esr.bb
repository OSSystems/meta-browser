# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6324b053d73a5f2017fe34d830cba4bf"
SRC_URI[sha256sum] = "4e2834cb9258f81ecb375b3fa6a76af11ce828b0235dda5d489b3c2be0c6a2b6"
