# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7d3b27d9bc2716d01f169387f5a36ff0b5e2181eef319c703fb422c1798703eb"
