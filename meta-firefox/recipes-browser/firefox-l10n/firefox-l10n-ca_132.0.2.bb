# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "275f6af29cd46c4879aa47cf4f953925"
SRC_URI[sha256sum] = "a982013350b3d7c7a22f91f1f2cc343d68e0da761cdfc5da4adc10805ce97804"
