# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c30221c40867d59fe404c353c05982f3"
SRC_URI[sha256sum] = "fed946541b9c7b1948128a4de4698d3000416e53ff29fddf5205921671c66f1f"
