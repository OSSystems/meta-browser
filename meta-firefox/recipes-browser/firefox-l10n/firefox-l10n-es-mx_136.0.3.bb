# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2ff46883e76c8c447ec1dc22af815c5f"
SRC_URI[sha256sum] = "8c856531ba5e3b4beb14da230e0e2539fb7fc003ef657bc90bf7a5a8080517b6"
