# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "034e72701dc2448ef9152d4f3d248b6f"
SRC_URI[sha256sum] = "7cf8dc0d2593496c321e04e536efc271a55dde56b00faf6e87ca1de83566abff"
