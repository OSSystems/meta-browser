# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "abb3f2e992062df147f90bf17cfb5006"
SRC_URI[sha256sum] = "0685f7e3d26c541084c1f516c70d1c1c9558e9d8c69ef6842d4d0f9d16649b5b"
