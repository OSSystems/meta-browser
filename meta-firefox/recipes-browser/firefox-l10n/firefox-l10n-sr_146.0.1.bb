# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "286148dcf9c29b69b4c2a0a75bc71f2a"
SRC_URI[sha256sum] = "b712e63b2999f3377138dc55b6b4531e4b8c30c5943249bcacbfa75c6901bc41"
