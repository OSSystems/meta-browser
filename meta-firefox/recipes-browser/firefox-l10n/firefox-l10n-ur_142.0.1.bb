# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "61d4204422a8b925597566f0be241042"
SRC_URI[sha256sum] = "922e87f72bfc276d9528fa953138b3ddffb27656ab2651db0841a39c57a7005f"
