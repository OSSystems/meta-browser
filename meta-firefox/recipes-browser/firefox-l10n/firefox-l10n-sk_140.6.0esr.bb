# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "de23c822800dea87cb1450f2c59f3e06"
SRC_URI[sha256sum] = "cb4ec0edb2abcd87baa715331de17bcb64afc30933fa2bef10237273c6804116"
