# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8e675e38a804b28b15919a11387665a4"
SRC_URI[sha256sum] = "1db641b2c9d177d7ad9649dbad154e9b5084cb81b57d889160ce820612d685c5"
