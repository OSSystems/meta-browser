# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6c1a7ef5c6a8f6dcd00fbcda59047545"
SRC_URI[sha256sum] = "31f7af69315be794e8935f7165c06655a5b826dc7dd6ae411488676941e4cc44"
