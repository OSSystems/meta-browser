# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d2cc67ffac018ae392c90f58956671cb"
SRC_URI[sha256sum] = "2f4eb67fed30e7873f9bfe8a03fff12020d367f765ac0b95f67e52f2ce26448f"
