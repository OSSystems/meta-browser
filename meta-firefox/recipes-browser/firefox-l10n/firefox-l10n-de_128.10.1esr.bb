# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cc76b3bea138efcf7b8f697f176205c1"
SRC_URI[sha256sum] = "23b3ebc2196c5eaaf1bdcc22c4fdf1187e6ec4343a1d67e33da486e7833c9ba1"
