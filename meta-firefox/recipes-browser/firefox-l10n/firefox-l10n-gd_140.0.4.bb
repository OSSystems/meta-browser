# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "618252b2d8c3e194201a023610e6b96b"
SRC_URI[sha256sum] = "7b4fedc8d2a44245e676ee7e5b674bed9605642882e517811fff819531a239df"
