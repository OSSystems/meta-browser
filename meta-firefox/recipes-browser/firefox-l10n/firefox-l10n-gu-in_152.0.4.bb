# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "419e25ef6b1d6dc36a2996cc45752237a89f377f3225df8619c1853133c96566"
