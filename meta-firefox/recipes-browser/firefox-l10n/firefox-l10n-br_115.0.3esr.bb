# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f818793574433a7159f6b247980c977b"
SRC_URI[sha256sum] = "0c504c10f8312b02aa5350024e223ca6e1e7046a7a4b9ccfa87bfbfc89bd9a3f"
