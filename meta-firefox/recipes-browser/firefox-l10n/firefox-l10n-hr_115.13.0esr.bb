# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ed5afcac2afbc44e5a533fcf11447b6e"
SRC_URI[sha256sum] = "5c1f479484e19aafd1338fbdeb4762de67ec29d64dd114ead499ccb0e753654b"
