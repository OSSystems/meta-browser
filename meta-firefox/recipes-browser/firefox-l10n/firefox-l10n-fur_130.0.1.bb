# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9cbd756ee8413ffd44c9af967a4adab6"
SRC_URI[sha256sum] = "2f0b780d9406c96b62553bb647699705d3f79d50ff78f6e4140650c3f325337e"
