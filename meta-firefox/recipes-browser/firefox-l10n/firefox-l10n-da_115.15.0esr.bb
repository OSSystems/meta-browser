# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2bdfecc9f751e00d47c001d368e11cc8"
SRC_URI[sha256sum] = "2b44ea091b7f94c6cf42fdef789988c33f8d35f8002a62365008dc36296a700f"
