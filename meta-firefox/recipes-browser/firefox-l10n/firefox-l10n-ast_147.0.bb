# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dbd89ddb3032685fafb4fa921621f1fb"
SRC_URI[sha256sum] = "ab6d133a57a5a0bee90128f9f17ebc0a54f5c1a67d06acc4a3d24ca86bf6f20a"
