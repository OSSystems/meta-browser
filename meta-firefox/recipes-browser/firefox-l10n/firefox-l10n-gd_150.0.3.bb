# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "cea55f879a3cc863d1bff3b610a2921447cfd1b376c257ab0f695ee86a405ec3"
