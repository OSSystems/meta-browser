# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9e75b778ec4ec623f8c3ddd8e1aea523"
SRC_URI[sha256sum] = "162ab3b9337247ba65b03b2d696e5f24341ddd566ea3ba3eabe6adadb1861b9c"
