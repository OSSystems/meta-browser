# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3f9bc4b75354684c192706186022e959"
SRC_URI[sha256sum] = "8e3497275b280dd5c4395be82bba1a4dfaf29407ab68d051ae98153fc4a7ac71"
