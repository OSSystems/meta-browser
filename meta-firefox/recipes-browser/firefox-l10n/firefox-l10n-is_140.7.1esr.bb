# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a430fb3adc7035e348be1f703a08fa34"
SRC_URI[sha256sum] = "fd70b527304e9e1ee0d7f15b1279619e1803c3dbfa2493de31e3a84c98403af9"
