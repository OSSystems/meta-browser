# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5d4ba09b2a3fe76c4bd1e704721a9bde"
SRC_URI[sha256sum] = "30c1fe1549208528bc853f0566319b1a22b368dba3955d972de3915a9a2e0c5b"
