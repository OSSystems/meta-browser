# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3a041ff9e0a52f224e9b8939fd304ce27cc1b67b8f6e5e1b329c709ee5bc187f"
