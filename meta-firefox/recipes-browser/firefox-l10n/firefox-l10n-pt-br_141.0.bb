# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9637e7296137928a5fa8f0df62a38e55"
SRC_URI[sha256sum] = "0cefcea905b20f9deac87fa22ef031e49d998e17125be7e26b9e2331336c0a5d"
