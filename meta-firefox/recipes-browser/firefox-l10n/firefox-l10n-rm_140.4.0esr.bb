# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "187d3d586470f6d24b25168820d74b35"
SRC_URI[sha256sum] = "336cbf46a346a65414566484ac4c2895690cdea5c38745f240b22527d40f6ed8"
