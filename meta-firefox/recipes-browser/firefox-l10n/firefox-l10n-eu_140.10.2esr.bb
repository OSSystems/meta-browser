# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "58e8215d7a19636322e09df59568be65733f9e925026e90851cef777bb51c8ec"
