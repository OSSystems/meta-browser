# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "17aec4a091659ac9bf5c24f54e5a320a"
SRC_URI[sha256sum] = "a3c177d6e16c1cfcc8c308dd48d8a63f722741630860fc8ca337627a5f0c9e74"
