# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ea9c981414e270c29978f6f52d7479a9"
SRC_URI[sha256sum] = "db9ff3793fa6698c2355f60211279abaf4877f8ca35e8c9bb7358f1f5fb1d7d4"
