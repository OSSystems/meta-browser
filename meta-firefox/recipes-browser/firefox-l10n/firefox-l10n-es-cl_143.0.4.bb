# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e87a89bf33f9d7c6c41c4aaf83587b1e"
SRC_URI[sha256sum] = "0e95a8ebc06b5cf5f195db50a5a7232c7656acb228a0d6bffb362170b9ae336c"
