# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "98517c3306ad8c88ac4a38dceaacb6a0"
SRC_URI[sha256sum] = "1c86430050f4b6ae376ccba2385ee4f81b1289263a00c949c9f608477d441d2c"
