# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5ded73732a3c145c92c915de42a11b7c"
SRC_URI[sha256sum] = "a620268c8086a6024a76ca3e5b65326c6af3554d6c709e60fa5ac27c87ce24c3"
