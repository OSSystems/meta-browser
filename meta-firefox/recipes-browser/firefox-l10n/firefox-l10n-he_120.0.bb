# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2a111e18cc9bb2ba817607bf02b4c3ef"
SRC_URI[sha256sum] = "73963c4f2f4d5a625186db8a46edb9bfb9228b7a330ad65e86d41ff7c9c6f5e3"
