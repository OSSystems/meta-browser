# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "62d9bef50478b3022f289cfab8809b0f"
SRC_URI[sha256sum] = "b6ac7b9844407ce7643ea7bfe34b6b68b998fa435a3c12450d2eadf0a41d308a"
