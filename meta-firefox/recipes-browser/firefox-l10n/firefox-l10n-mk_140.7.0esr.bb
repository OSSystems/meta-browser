# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7289ba90ad55d6e1f8ea0ea6f5fb8f0c"
SRC_URI[sha256sum] = "e3555b66ab7f1bd370fe33a78cac5800036f1c73a7076b33958f6f1d6030cbaa"
