# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c462011cd05de84705ddd97f415ddf40"
SRC_URI[sha256sum] = "f2e22b7aa0b21ba33a9439689de81859cd9bd87a18d31a41bab183dff589f03b"
