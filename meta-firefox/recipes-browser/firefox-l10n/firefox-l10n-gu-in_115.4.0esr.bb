# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aace9bd95e27c9c66f571d3ad5a0c2aa"
SRC_URI[sha256sum] = "f57414db4f441029e034d6ef1798ab77519d069e7578b66b3550bd81b99ab0c6"
