# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "533058f28608a09a77b7c368849dbee8"
SRC_URI[sha256sum] = "cba5b0e392180aedd45acee2b7349384716a6381dccd4b945a386c75713fee18"
