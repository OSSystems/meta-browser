# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c360dc7f95a6967a1071f94262d97158ba15900734d9f1dd17c310dbbd9a33b5"
