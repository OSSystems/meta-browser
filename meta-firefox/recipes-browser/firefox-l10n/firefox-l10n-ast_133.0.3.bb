# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "401faa984f00a2060acec8f2e00ba0e9"
SRC_URI[sha256sum] = "50af22c33a9a4b84cede84c832ec637df96b8d0fd763169073833927df8d4e63"
