# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e830d0eb20b194ae6dc2d1fc82f0a19e"
SRC_URI[sha256sum] = "a3764c48d58996d80c4d82e77ba625fc0e8ec43e9d2c37812e4ab6f248db9c1a"
