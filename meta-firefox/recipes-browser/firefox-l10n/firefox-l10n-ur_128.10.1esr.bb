# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d3aab2fc938770964b7a574fd555532d"
SRC_URI[sha256sum] = "87fc36c873839091c5c6dcb2adbc33af03a7c79178325595070af01dd19885ed"
