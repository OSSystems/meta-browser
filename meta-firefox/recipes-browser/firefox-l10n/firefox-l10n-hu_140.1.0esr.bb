# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7150dae2a2efcb94a539260151df7a85"
SRC_URI[sha256sum] = "e10d3a05e1f1cf3d0c4099f6cf3345159a7c71a338e8be59e791ff39169b2102"
