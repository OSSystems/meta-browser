# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "89e040a4658c4c71c0191ec7d31304bd3a838aa7eb6efe1656af3d9585119bba"
