# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "962753e3aa20bfa344da820f649e8520"
SRC_URI[sha256sum] = "5da0ffd316e203c71971380539f271e709dcbea9e1dddfbf38ee22e7e0a72e09"
