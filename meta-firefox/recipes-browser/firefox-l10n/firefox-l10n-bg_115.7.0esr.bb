# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "810fc3153d48f81edea88606b1b87943"
SRC_URI[sha256sum] = "2a48bc68ca4e3c7278e11123ae8c353aaf61869a099a802069f3748576f81fed"
