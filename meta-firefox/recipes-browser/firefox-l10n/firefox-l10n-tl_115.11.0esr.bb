# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "861de632c649cd034643932ecde48331"
SRC_URI[sha256sum] = "86c733623157db9a790d0b15a39f5cc363e1f998e97a09fa7fd7970031af1081"
