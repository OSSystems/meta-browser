# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "29590c03cf7178b770a00d280b787955"
SRC_URI[sha256sum] = "7f03f7aa342ada1f62c45ab4d44fea63def529da0e48e4ac4aacb92c058b5b4d"
