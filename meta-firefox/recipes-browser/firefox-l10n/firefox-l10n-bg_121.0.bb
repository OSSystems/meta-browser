# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "307596a22366fed1189aa7db95c6b8d1"
SRC_URI[sha256sum] = "cee32e2bbc4b419288e7f74dc2a486dc25c29fa1cde5938fdb9da7cd0ce496a8"
