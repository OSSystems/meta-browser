# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cd651cfd4ec6b3a5f632796c991b49f7"
SRC_URI[sha256sum] = "9e60b32e877ab37b6fb0c017ccf3fdf8d9eea710bfcf9beea7d702fdc932f7fe"
