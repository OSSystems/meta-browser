# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9c0dfb77d031d0ba1e80ff214e4e1cc7"
SRC_URI[sha256sum] = "d5565995421e4335956b2ba18ecc103d43f6934c29b83f3319e5f2e7c4e1eac0"
