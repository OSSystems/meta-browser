# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "02ade4e2aba7dc795e5942fe340c9a69"
SRC_URI[sha256sum] = "39703adb5df9b070487a12249cae49ee10b2c20b844b88414242913de7b88ac1"
