# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "44aba3c58c8a05ffc83b8755f6fa03563878a46279ef2e27cedf36b706e4d1cf"
