# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f3b3bee365287f55c470c26a05820958"
SRC_URI[sha256sum] = "a061875e7e13f088ce296308c001e51021a81a27191843bf61b95e685c4c0e4d"
