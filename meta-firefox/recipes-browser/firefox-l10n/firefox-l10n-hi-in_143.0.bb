# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7130b00b537ef25e06b5cdaf461c1183"
SRC_URI[sha256sum] = "1f88fb999ca01986fffca7f68d5d1328be716cef2d0a25afe34addfc8ef96e4a"
