# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b09d33a1535a82d46e1b21f706a694b9"
SRC_URI[sha256sum] = "a79afe6545498481653e6048593e44de3d7b7611a2518b917b650aa7d6b388f6"
