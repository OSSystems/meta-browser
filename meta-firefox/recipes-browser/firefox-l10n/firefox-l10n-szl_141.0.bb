# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "86e76849cd2c5a6e5f65362e236f27cd"
SRC_URI[sha256sum] = "c97bc8ff14b3b2f831690ae635be768dedeccdc37d95756647c66ab3051077f1"
