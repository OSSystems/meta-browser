# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fc6eae794e044403a6b383498f9dcf53"
SRC_URI[sha256sum] = "d8c5ff640054480a9200e43727f439c8827ae7798b47dab05c1db3c600633687"
