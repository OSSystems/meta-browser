# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "11c235ca3b8fe6f13f6a96b0688856bd"
SRC_URI[sha256sum] = "3723e0f7fb71116a5d4cf6527db9ef49389f43e418fbbc39b7cf2c05ca447ea9"
