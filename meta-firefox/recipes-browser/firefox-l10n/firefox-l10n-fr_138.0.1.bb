# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7ecf2a1efe5402d9ba6b2125b0363806"
SRC_URI[sha256sum] = "399be8342d0e6639636b92c741a3f55f64a19c61632d87dfaca741c52879e22b"
