# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fea094130a6eca44e023cf9472d0e4df"
SRC_URI[sha256sum] = "379b6a0f5166d31d66b19f9fd086d065f79dbb170714d952e6e0a8ee30d81e8c"
