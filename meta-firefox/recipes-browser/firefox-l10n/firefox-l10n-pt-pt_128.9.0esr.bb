# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "26dbd5c9dcde256164dbdd96455072ae"
SRC_URI[sha256sum] = "f62bce0f3692f9198030eb409c39ff4e005ae77ea1cab2d267f4efb46d7f4544"
