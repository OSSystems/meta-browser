# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "0e3dddf6d4568bd3e7cafabfc707e39fcf7d0b219de3852b24689bcffe387115"
