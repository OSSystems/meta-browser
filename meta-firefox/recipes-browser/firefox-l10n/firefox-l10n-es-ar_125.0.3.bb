# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a66b736edcea542f0c36b539c04667c5"
SRC_URI[sha256sum] = "ca224d604b015ad3a23f68dd8c6a3ad9d0314e8db519f6890dccba8514e75fea"
