# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f1a1b003c9f9964aa49bf9e08864030c"
SRC_URI[sha256sum] = "16256887c530701da17bc106a5abf80e245e3d92d8997f3b81f48fd6057b6aad"
