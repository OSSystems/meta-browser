# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f74324930fc766dcc3afb7beae06d25a"
SRC_URI[sha256sum] = "91782dcd2751e49776214209be8b6eaacf6fa485c5cef17cda7a19743fc698e2"
