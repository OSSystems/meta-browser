# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "880dc3d5c31d8cd1c0e7112e37d38c2d"
SRC_URI[sha256sum] = "e8d7e4514b585cbfecc3874b0e089d12302867e442a064f1868f93e9995ae80d"
