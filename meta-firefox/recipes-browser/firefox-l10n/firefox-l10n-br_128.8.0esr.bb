# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "41ad84bde5eea2b152329499446b8c9e"
SRC_URI[sha256sum] = "3e56142fdc0df3b4e851b17324821df5f09102030227fc5e8542e8ef45ada97c"
