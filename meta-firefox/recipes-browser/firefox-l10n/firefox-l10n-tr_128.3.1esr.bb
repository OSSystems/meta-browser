# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8ff34834ffab628db54c6ece33f15efb"
SRC_URI[sha256sum] = "4cf0c6b755c1b981a7dcfc7b0ac34e699b68de24d45ab2d0f2a53755dc091fc5"
