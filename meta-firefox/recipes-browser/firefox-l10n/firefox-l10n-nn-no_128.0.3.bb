# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0dce63eeb5c3b17d201f638de7e38302"
SRC_URI[sha256sum] = "5c5ad31224f002f86aa50f390da9f9e5cadb0d1d5fa953ab3836832cae6bc170"
