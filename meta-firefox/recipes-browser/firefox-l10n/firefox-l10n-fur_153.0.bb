# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7b72a03bcb7f8ba154a40620176908484fa526cafd612330e779e1ab0bcc237e"
