# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9c6d0ca9a9379d06820afa9ee7378d0b"
SRC_URI[sha256sum] = "862e267dabe53b93fdf6787e6f93b4c67dda84f58c2648476b9b059a93021520"
