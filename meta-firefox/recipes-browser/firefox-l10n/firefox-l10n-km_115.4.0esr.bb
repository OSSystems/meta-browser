# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "abeb1c3500221a99e3009ea14ec3013a"
SRC_URI[sha256sum] = "0564d1a60b8f01329b45cbd7e97bbed0581d37b7baa46b658f9caabd24fa0087"
