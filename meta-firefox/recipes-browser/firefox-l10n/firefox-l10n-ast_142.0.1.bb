# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "35ff0c7a8c1337a6fc2779a24258439a"
SRC_URI[sha256sum] = "eae41e564bb2275a9b1fead30c66bd50aa062d1b81603f998c564c8e94ac8d8f"
