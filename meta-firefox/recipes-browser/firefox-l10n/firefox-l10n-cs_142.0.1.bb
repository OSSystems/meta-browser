# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ebc2a144c6e0d6dadc49d492c0b8eb58"
SRC_URI[sha256sum] = "33088b02d68a01c1a69b731fa71398aae91b1a3c21ae71164498795f3ebfa401"
