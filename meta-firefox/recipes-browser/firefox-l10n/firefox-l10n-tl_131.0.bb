# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "524192ae1faf542577a96425cb44e8fd"
SRC_URI[sha256sum] = "4a241c68ba8e661a9c4c0ebdb5d17fb689b3cceac0ab8dd3a24679b9e2700672"
