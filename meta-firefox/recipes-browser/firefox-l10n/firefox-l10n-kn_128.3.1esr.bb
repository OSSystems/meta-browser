# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "71a3b6594554557d6399c65940bc598c"
SRC_URI[sha256sum] = "def1d54ad5360427dc59eed8fb37c8c6110d8babc8ffdfb3f7ae6fa3f70ad673"
