# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0ef4dd681d18ecdea2feec87826d8392"
SRC_URI[sha256sum] = "85af5d4b4845336913b13c875ada2f4047aea44ae9e1212e2b15c4ac6e6b9a12"
