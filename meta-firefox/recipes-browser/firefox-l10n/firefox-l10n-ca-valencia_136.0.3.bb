# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c868dbca6a1fd70d94070c189b9e48d2"
SRC_URI[sha256sum] = "fe15a04ec5b4b3b272f94e8e3605dbf7d61a22bdbab7e88cd00d95b8f27d3edd"
