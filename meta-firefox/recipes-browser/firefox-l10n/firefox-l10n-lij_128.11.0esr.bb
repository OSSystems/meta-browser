# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e28d7afba20ee9d47da32b7244903b0a"
SRC_URI[sha256sum] = "4698b481b3be0985672f01246ecfc6a31f5acbfefad2fc8c2c8afa0b2e0d58c0"
