# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a0a970ca09b9712c5edee884f504beda"
SRC_URI[sha256sum] = "d96bede7da9a5baae6139de1eabb1933b6a91f57b1bc11847d420f957147b523"
