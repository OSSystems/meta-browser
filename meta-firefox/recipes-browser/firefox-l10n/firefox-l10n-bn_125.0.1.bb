# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ba3f7f8bdc7f17fc6e7b847d60a3bfda"
SRC_URI[sha256sum] = "7b67b72e40f958115330d41d1f9c8ad9906afd910fa834a8b06ac870ca9fa1fa"
