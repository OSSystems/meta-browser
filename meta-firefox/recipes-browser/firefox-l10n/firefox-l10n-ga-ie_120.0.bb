# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8617f4166907d15154020b1e54aa28ee"
SRC_URI[sha256sum] = "8ee6758c4ce476f13a6320394e48f0fcd2802ae52f5f3380fa3424f1dbb04792"
