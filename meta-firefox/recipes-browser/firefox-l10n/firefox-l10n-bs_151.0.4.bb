# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c471fb367ff1809757384b0f6693e77cdfe37acf362ad095110725d06dea2de7"
