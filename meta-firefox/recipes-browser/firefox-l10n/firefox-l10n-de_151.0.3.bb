# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "714e063db6200b7a08e8b283fe0e4dd6644d691e3789f0ba18c89bc9bd52db0d"
