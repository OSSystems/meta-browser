# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b90fe9b3cab42898491457818c4329f0"
SRC_URI[sha256sum] = "960891e49f17b5a8425456182bdefdf746f1800dbd8851a4946943c922c06107"
