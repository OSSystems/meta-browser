# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "52f5b6ff945a3c1705905e4ac8c7ccef"
SRC_URI[sha256sum] = "f75d0e494f682c840d5ff4aaeba254dfaa8c74977d8f9743667c18e4fff42b93"
