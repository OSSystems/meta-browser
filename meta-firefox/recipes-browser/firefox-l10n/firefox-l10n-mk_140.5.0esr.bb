# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b0d5d8df1ab27aaced5085571454bff8"
SRC_URI[sha256sum] = "a4a30cd56c784f122e593c86d38f9f14b9270ee69cba3947ac2b1b2264530796"
