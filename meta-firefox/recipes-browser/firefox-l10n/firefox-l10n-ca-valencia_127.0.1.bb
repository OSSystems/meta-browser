# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "835ebbf6747947f2613ad67eac185ed0"
SRC_URI[sha256sum] = "c9d7c3352247fbe004d1f4c7d7b9fc9b2929aa619c58d239ce553cd869be81f1"
