# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "939ac5c9f2fec876e8a465b3df938b40"
SRC_URI[sha256sum] = "0019abc60823a8b9c89c8c1b8a13a89a4711b5783244bfad360d6979eef755c9"
