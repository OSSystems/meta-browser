# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "874cb29f005799ef8e0dfc5a3c8a35d8"
SRC_URI[sha256sum] = "668b669e9c5fbabc9c9d9d5511d4cde5e643cb457797e750c1fba28e4ce4c661"
