# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f9f053f412a9b68236224cd173f7c9a1"
SRC_URI[sha256sum] = "f63d2b16f66869ad703d7a4f6942d4ad39a677780bba2b9991a11ef9c5a6d3e0"
