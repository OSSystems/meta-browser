# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1f07ffad856480f25d6804a8ef4f3ee8"
SRC_URI[sha256sum] = "fec47471575d4ae1dadc491ef907a1dd5bd50b4a2998e81c5351d62adb1cda23"
