# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "666b00c5b6cadea27bf7d21ef50bb1c4"
SRC_URI[sha256sum] = "0a4b906bf77762e2e28b3ea9146f9767ee721e72bfcd5aeab844474c3987ee90"
