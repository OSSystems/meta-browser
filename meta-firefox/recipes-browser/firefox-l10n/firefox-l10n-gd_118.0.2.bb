# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e164075974e37e698fb2c106b68ec593"
SRC_URI[sha256sum] = "c1bc65c9a828a33713bf397f5173fc8cc88f0afeae5e6cfe3a7e5e13f81dc011"
