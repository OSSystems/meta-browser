# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4221a83a9e1f49931c07fa41bf07e933"
SRC_URI[sha256sum] = "a8d02b091a4f04491ac5ad48550e2ad3f923ce6fac2842eb652c6fd8002bdfc1"
