# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "035ddcb6dde37d22a28d861ae7db453f"
SRC_URI[sha256sum] = "7ee3de919c4c77b8e92bc20350f65dbd5bb0864d2b89b633eb4df5c5c972b2fd"
