# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "8acfed9f04b5117c10076849e00d2f8d37c03f609819de9aa1288dc8c714f81a"
