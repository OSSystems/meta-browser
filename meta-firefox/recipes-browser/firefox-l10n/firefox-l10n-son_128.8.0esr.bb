# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eeb857460a5ec81673be528fd0f26012"
SRC_URI[sha256sum] = "9a02e46720cb1e4d48e35227868d009d0d06cfd681da480bbad4317f5c1475a7"
