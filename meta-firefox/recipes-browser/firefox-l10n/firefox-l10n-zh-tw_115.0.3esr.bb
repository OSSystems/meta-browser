# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2c6b16003b0551cc3f338d9be6123803"
SRC_URI[sha256sum] = "ec4d63caf62ac68fe0c8658fc7ce7568b12f5ef2ea92e17d522a6363e579a337"
