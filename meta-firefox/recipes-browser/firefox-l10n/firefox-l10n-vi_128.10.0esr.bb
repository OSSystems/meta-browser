# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "53435f8504cdd267cc6d5de61e54ab31"
SRC_URI[sha256sum] = "fee2ca52ca6f143db79ec03dbc15b81a03e28b65e05230920cea30cd56f5d63b"
