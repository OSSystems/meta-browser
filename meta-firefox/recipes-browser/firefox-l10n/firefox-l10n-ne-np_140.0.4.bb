# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6a126362563078eaf37c3a487a605873"
SRC_URI[sha256sum] = "8d0c6a4e78fd0fc1bacfe546ae4371259999e9f18f4942fa1d096032dd0c1b9e"
