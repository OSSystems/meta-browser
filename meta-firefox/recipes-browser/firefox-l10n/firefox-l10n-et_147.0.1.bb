# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "75783e1a9f3dc262dd0358900273a6d5"
SRC_URI[sha256sum] = "b649b32c586db6cc43cb608837f02fce78e872425fc227df296a89b5cb4b8d58"
