# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "58f7ca679b97a4c3395af626c642a59a"
SRC_URI[sha256sum] = "8fad28515f72bcb268f14419e26cb6601968d8669815918cd01f665fc639bbef"
