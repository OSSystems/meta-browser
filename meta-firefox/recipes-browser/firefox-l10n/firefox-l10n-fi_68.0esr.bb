# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "148e77c77039e73d09a3f0dc70e620a2"
SRC_URI[sha256sum] = "a8ffd7096b6b50c28286efe4988b89fbb1136c4e3c0735d281ae45367143cf5f"
