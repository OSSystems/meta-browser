# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "61ade59365eaba7d9ac15da8296cd519"
SRC_URI[sha256sum] = "7784fafa1683da3dc403940b323fd228c22f22cd6ee42bbdbadb98a90998f1a8"
