# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "374ed2d444247523331fbc9b982701a7"
SRC_URI[sha256sum] = "fe3e3368f8dc11a206c9cae9aa4916101283e71965c3603a5fcf5bbe962c2616"
