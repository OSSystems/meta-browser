# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8856e3ac9c57c1b2bbc29cd3427efa56"
SRC_URI[sha256sum] = "75fbd0b89d57f59edd5187f8b95075766021bc7a6f993607f0bd764601ceac28"
