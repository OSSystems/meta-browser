# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f28eb2dd6f9d526bd636d3da3dd0856d"
SRC_URI[sha256sum] = "b2da552a1e68cb090b7bc427ee17f140f11bffc0c282c49f277acc0d892e95e6"
