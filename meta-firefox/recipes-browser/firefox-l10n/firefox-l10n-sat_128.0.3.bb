# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aef4f083468d0e8f2bbdbbc1b9cf0b2a"
SRC_URI[sha256sum] = "e0a3f5b2bfb7d27e6c16397b1ec3107208459603b5715aa0c77f441342be95c1"
