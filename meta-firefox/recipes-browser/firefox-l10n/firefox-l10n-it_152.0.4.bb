# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ac4ace6b1e4cc6f55caa6d38f35dff666dcec61c6e6e06fec54db02149170f9f"
