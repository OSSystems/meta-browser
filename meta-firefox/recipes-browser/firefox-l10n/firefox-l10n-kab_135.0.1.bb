# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dd243419283729069342bec99df17568"
SRC_URI[sha256sum] = "ed44a4893ef2902a1fa5e4b6f80f73f47d0a3f697ec86a8dc878acb9a510c00e"
