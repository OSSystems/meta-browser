# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "48cc3b62d6e100d056f5a203e5136713"
SRC_URI[sha256sum] = "40ffa43673661a22ce7fa50fdb5232391521023fbc92734530db0cc4c804a0b4"
