# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "034a82ff7b65d7ebb14fe8f76f33a7b6"
SRC_URI[sha256sum] = "3dc209e87fa6c034829753b526e3b19b7dcc61b280a4210d2ee1c5a2c5d65af1"
