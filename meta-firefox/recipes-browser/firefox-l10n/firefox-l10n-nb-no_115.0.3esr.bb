# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0d20bee8feb467af9c8d0e05d3cb2267"
SRC_URI[sha256sum] = "b3ba6d9d4ef8173ec152e22c96871fc6c36edd89ea22acacd13960383137ad78"
