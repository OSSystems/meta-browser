# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b92e297b5065aefcfc76088f628f8288"
SRC_URI[sha256sum] = "c79c4786990fc3d48f4d76d38b7b9dc07b1eee40858e11e414e37d848332a7f8"
