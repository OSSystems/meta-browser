# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0d9bedc36ab79b0a5a027f9acb1310b2"
SRC_URI[sha256sum] = "ba34e50b13196d580bb1f1fe7293b2300bd8b46e03bef0b5a26ca07b44805395"
