# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f4e3a8db67f804c1c9c245be001bbfff"
SRC_URI[sha256sum] = "779ed8e9ac3d77d6efe466e82fbb1370c7a078dda105fd31cec900eca53f92ec"
