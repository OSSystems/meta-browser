# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6e33fdb64c4341575a014739a99aa84d"
SRC_URI[sha256sum] = "2173b01ea8380dc5f25c981a986e867078138c957358da4dc55814485599c19e"
