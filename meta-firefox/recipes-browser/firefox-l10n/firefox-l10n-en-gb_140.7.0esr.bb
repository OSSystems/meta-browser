# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d84ab31c76d022adf01f53b8de6fe42a"
SRC_URI[sha256sum] = "8500146e61f31dfcac8d66f3d3a3095215d5f8a819d3a3cb43099d2dfb47dc7f"
