# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e5b0e305505ce5af0c3c2cc87319e827"
SRC_URI[sha256sum] = "796319b1a9a7a7fe7b60c859859249452a6cbcea147ab6bc42e2c62ea1ca492f"
