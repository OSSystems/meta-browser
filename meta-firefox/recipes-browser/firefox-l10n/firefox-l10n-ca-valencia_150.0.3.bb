# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "219bf9b76bd83751baf4adb47048cac51d059200b034e44c3fdd50569fca800d"
