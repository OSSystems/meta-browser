# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "94f6d0d781274118719437904d59e953"
SRC_URI[sha256sum] = "3b0546ecf7a885490b0448eda0c206a3775738038f097fc06c27306c59400728"
