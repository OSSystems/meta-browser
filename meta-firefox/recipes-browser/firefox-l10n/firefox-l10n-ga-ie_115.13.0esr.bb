# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5ac367cb2ae2f2d695a0104f846e1e91"
SRC_URI[sha256sum] = "d3d8ba1b472ddfb254bc198a5a5ff949c8c30b10e8f82d40abad76c48b78bdd0"
