# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aa6f119c9df50a75935b04e518527466"
SRC_URI[sha256sum] = "a1f8aac2e538f5bcf09ab4211354a0bb16427e91d09b74ad8c9590cde46b3759"
