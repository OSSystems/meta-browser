# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9653e06b9aac39f8cdd5c06d70442f11"
SRC_URI[sha256sum] = "88b0ea6bcc9eca46005c18259eb0b378d28e13c11848aff2d31b594bbe8a668d"
