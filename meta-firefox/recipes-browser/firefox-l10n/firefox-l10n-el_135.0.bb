# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3cd23bee99e95ec9c82fcecdff20bf89"
SRC_URI[sha256sum] = "6f9e5fb165416ab38fbc93571338c7b920c22c3171422410e94a46320f2f4dae"
