# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b0c150ab264f3bd805348cd1145d64eb"
SRC_URI[sha256sum] = "4b39ae7fd01445c1e4fb409dd23759c1f6df7486c6e7a47087e8779509ec1b14"
