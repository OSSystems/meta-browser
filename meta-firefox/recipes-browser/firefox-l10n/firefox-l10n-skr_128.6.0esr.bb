# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8e293831e97dec0685fb3a44044958a8"
SRC_URI[sha256sum] = "747e4103c385decd8a69cac4aa6f99612a6fa895d47658d23f981e52a3cf669b"
