# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "24abd10145ccc38bfed16baaad3d12c6"
SRC_URI[sha256sum] = "b27b5b5a0d4a20c1444211b130997c6a700e2be440ef57859ef9f588d121eb0e"
