# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "72df2be059ad8bd6492c1264dd745d6b"
SRC_URI[sha256sum] = "b041a28ebb4d38772f69c3124938ec1d9a3bd9ca4a4e803f0e358af88cb604b2"
