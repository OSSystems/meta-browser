# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2b2106a0bf2ae406bb022db3b971c23e39b7828df86ffd4d80855afa17741664"
