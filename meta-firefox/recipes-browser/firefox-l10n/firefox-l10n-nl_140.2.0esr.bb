# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3702668061d2e06f938c2be788ede661"
SRC_URI[sha256sum] = "66cc25792a1028a64cb56299d3bafd91784ec60638f2bd211e7060d101676a77"
