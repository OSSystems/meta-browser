# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "381e137f0111b4f5cf4ba42662d38f7128d7ceb5263039e6610ff6918f0a7834"
