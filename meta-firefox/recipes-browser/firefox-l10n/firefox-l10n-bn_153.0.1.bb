# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "a6ea3420229072cbde16aa3c12b1dae99be37d06e3a4640db58b065d40197bb8"
