# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3746f674b8bf92e765f087745b482714"
SRC_URI[sha256sum] = "e16d63af7dad5b5065c1c6e1bb0d0f1973e740e03d69f3a4e980ce40e8ee3db9"
