# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b37900e7b8e0c5738ebfb2a7743b686a"
SRC_URI[sha256sum] = "4155d982901d4f8513ffd2319c100b09e91e7fed651b0595e697b4d7d2c7f8f1"
