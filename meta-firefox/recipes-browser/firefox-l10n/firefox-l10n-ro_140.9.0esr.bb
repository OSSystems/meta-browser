# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ac53bb80a6afd2386354ebf53d42e1d6"
SRC_URI[sha256sum] = "0ad175432956f7f798aa8a057d2196d684ef5ed537592841f189e996b9c03854"
