# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "228f045ccc1f62fad968297ead0f40eb"
SRC_URI[sha256sum] = "29d2cd621a09505d9caa3190a018fd7ef46ee2d871b2bec310d6eb02fd4c281d"
