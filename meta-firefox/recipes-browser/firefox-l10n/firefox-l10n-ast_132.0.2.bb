# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a72dd127d99218debe8fe8e2ac56d09f"
SRC_URI[sha256sum] = "7d15f60a9374462ed276a26740e6836e6a6023753db38984c0fa06d422dbde2f"
