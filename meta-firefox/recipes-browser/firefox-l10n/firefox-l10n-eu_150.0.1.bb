# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e8f560116b232fc4e0671d04427114704bb341d94691dab19ce6ec045b93f484"
