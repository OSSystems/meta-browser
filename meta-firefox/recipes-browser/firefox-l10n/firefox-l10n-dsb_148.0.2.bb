# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8fbd88a7ccf22695d3df2ce42a2642eb"
SRC_URI[sha256sum] = "cceb575e68a13658560f8f96ee6aa7610295a76cf26d0da2bfa1505c1413d22e"
