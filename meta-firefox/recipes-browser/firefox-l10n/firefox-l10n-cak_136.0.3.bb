# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "27db726afd8fa1b2bba14b149ac1f8fd"
SRC_URI[sha256sum] = "457e2294cd1ebefd7ff011816052706a8e5370149a910ed6a14e6886b4c87e0e"
