# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8814209c8bb151373698ad630a81b6b4"
SRC_URI[sha256sum] = "c3d0a8588dc5ad23f0fa154ecd9fce2b257f56cc0977c0354edcafed2ab1bbfa"
