# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "69b551a95f0f581c95d2ff20b2bfde17"
SRC_URI[sha256sum] = "79239f83ec118ce8998971a6cbc1f24d7c799ff152d6e8a8dafb22af8b4b68b8"
