# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "185135bcfb78abae3e9fb8995cc94f8c"
SRC_URI[sha256sum] = "5633a99eff928b5f724860d84bf182e3b69b660a49abf617d4e25f3e8c5121a9"
