# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "651313239af2cde1a1f0cee2a5fd425e"
SRC_URI[sha256sum] = "7a597779142b55fe3d08035d66861f44dcd10bcaf428910f2c19b4ce0f68b7f5"
