# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "79241a24d80b9aca368f44d5e399b9cd"
SRC_URI[sha256sum] = "d82a5716486411d52d23a694135eee818a3e7da8f0c0dda08f8f0336f1ae0160"
