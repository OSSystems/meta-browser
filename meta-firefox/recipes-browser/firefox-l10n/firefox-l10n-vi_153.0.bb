# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "53ef5b5eaada2a679753c46198dcf2c412299fd806a1d62360c6446592ee3316"
