# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "05a062d317dbda29c5485bf9d707e36c"
SRC_URI[sha256sum] = "14ecc77a544170a1c477ca7c8aed6ce435f5ac3dd859ad138f2a3bca86875a9c"
