# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f4177936ec5889cd0eb1a56007f8d129"
SRC_URI[sha256sum] = "81f70f08cacb1c1f2677529dc493a732d8b9e0b77a6d824d6153720323f434d8"
