# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1be33457e9a21f123c36e5c5333e5480"
SRC_URI[sha256sum] = "44740d7702fbe80b1630db9b36c769971df4005482fd0e6eb444fa1d1067dc17"
