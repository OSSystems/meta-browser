# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "41a6c8cf64ce9d8b329c37f431cbb39a"
SRC_URI[sha256sum] = "8ae59c5207f0c2a5c3501b5a796dff93623b41d049b3004c26d41d549ca5f83d"
