# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "564ed3d9b3c14df7736ccb5f5cc8e0b2"
SRC_URI[sha256sum] = "e335bd9ce9da1b3c369265b03311a4941c517fe87dbcbc1d79d0c64aeb3c5426"
