# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d61716a8f390ba203b16437d8fb4893c"
SRC_URI[sha256sum] = "3685b3830a5cdff672cc0f2250c394a9f02cd319668f0fc0d2b30fc745c72015"
