# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "df9a7d70a1c0ed6299a7fc089eadcd39"
SRC_URI[sha256sum] = "85926a14d37676a90d25d5cf74ad21ec3090b741a442435bde161d4d49294614"
