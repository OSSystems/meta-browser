# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "574d4bd81bc34b2e9a8461003d31892e"
SRC_URI[sha256sum] = "aff57dc6db1d92b82d024647b6efb927b2344f20f12217fc55642fa839243350"
