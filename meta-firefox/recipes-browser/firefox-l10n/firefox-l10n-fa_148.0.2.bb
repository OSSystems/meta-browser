# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0838dd6bfa3173e99e6f2de752cda48d"
SRC_URI[sha256sum] = "fab1fe90eb4cae99623c64e804d8c7ed171fa6e0fecad2809d0d9574ac050bab"
