# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "16b5f5eef541106ed2cf9ce4f45af726"
SRC_URI[sha256sum] = "23981fede609fd91cd8a8ac92b85aaadd2b2e79a98542a0fe9dbb5fe85f01d2a"
