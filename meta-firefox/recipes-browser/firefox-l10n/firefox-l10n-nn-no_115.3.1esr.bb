# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e98392ef79cc434683dd0f2903602bbf"
SRC_URI[sha256sum] = "0e51f6049938c45887ef213b9165952af01dccde8148cdb177424a0f4fe8bf08"
