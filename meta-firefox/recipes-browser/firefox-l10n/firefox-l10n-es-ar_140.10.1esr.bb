# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "9de1d3076e51f001b17f12b5b7485f6c5de05afd287a1c5bcf3fd8d2ec27f774"
