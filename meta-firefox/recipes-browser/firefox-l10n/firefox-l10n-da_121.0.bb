# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fd0d47e45b562493ad40496b0ea2ea88"
SRC_URI[sha256sum] = "7a8ab5772ee26b84b2bf65728f66df5ab12f46813e9b1128c25ff95ceaafa43a"
