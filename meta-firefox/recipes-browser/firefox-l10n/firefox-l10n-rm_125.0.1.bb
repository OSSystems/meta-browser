# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "170f963b03c5e9bf3d095fbd2b60b0dd"
SRC_URI[sha256sum] = "8d3d811bda513da6685db57f9e3314afa669d8097d454fe7d430d2414186204f"
