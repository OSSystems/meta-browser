# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c1cbc3afad55cab79f3c322aad0d5bf8"
SRC_URI[sha256sum] = "ac800b4ae472db53f4ebd444e55af6cf768e98c8b165859bbae467d7dd9f8603"
