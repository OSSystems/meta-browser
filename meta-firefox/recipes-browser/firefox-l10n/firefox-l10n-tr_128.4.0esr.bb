# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0df682e58767acc529a726ca02a463ef"
SRC_URI[sha256sum] = "2c95f2540c03b4359321d288787bde911a33e5c437871bc3f36bddaf40ec4940"
