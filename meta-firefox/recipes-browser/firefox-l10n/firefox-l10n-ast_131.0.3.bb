# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "692d33a8d9fb8db8869b3dc0097c8fb9"
SRC_URI[sha256sum] = "44eb8bd15a9445e73bf7a7552fa51f80b0ee0160faf882854dd6c07277685234"
