# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "74ad6dcc5049a732641f6f9d04126879"
SRC_URI[sha256sum] = "2f27937fe613f8c05de5fec368f57bbb309fd64fa56d2723b42ca5e527ae3831"
