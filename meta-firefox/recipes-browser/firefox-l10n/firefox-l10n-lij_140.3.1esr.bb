# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "af4b895c5e04c604259eaaf52f73edd3"
SRC_URI[sha256sum] = "e6acdc1ee8ffe109929a969e64f3e322e9f658aa54208c1c2eebd2c170af670c"
