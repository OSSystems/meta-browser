# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "40ece413b12e5212bc6c0316b369239e"
SRC_URI[sha256sum] = "a569fc027c517a60b70826df4851346b5d595eecf65589ce24db4e903b13bbe0"
