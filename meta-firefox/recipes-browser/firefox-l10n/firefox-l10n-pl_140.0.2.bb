# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5e016b65dba830e86a51371f1818c320"
SRC_URI[sha256sum] = "0a842959f4dc0dc078dd4d3d8117e52379ffbcbc4632c3bd9a1e7f2a635908e7"
