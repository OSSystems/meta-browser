# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6166371d1c4e95ab73bf7fe2dd0b4f66"
SRC_URI[sha256sum] = "7d6e147914b73beabf86a516ee19409748c553a257951a821fbef7d3ec0a14a7"
