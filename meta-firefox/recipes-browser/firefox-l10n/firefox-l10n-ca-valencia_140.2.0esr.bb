# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "899ad621079b95092b8c11171cd41f18"
SRC_URI[sha256sum] = "5e98b05f3c0eedef90911c8db63a024c9369e653b838ec56fe11d58e39eae781"
