# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bc74d0ab2bef46a6ce76596c850d3b2e"
SRC_URI[sha256sum] = "4a7f7709189f47861b0a508046f89707157b98278a66abc2389afdfa7998d68b"
