# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "74c74afa2eca64a3b39e43f9e8eb5070"
SRC_URI[sha256sum] = "10aaf4db461e516f273fdc3b655156ba2ed0206d0a71d8c1cbbedaeeefc847d1"
