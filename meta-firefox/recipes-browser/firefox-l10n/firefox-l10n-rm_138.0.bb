# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e50b11d3db8c9812e115802bb7b4db75"
SRC_URI[sha256sum] = "e960ee3917154958975f7099b3efd875d61c98c3ff6a86af9f03a67232ce7894"
