# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3aecda3e31c090f211b74b066f5a6055015efc2012b246bc1724087c24787f75"
