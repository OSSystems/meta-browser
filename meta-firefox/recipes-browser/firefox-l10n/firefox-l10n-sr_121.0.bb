# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d9064ddaf735a7480e478d425480c3e6"
SRC_URI[sha256sum] = "743803e24f97e1d951745bc15653d6639eb5de5fc29f4c15f782c50e46de83c6"
