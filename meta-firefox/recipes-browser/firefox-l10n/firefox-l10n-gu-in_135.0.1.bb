# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6f1e8de0fe199be2742018be51c31cf0"
SRC_URI[sha256sum] = "375edf81e23e7edb11adfc985b01398d5eda84f12f714ebe6c7f1cf68fe456b8"
