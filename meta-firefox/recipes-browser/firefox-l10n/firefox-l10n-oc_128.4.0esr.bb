# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8647f0c6cd23e9ee99e134e722c6fab7"
SRC_URI[sha256sum] = "794fab21bcd1183a090858be5a8e5973ea2aba4a51c595b3335a233f1fd0b746"
