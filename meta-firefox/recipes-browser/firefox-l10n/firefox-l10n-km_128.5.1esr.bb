# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c8ae7ee031b34519fde56fbc93314f11"
SRC_URI[sha256sum] = "d579273f50b518b05c665e704e29b4b4b4f303aa8358057c3d5a383e9076fa49"
