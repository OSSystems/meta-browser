# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1e05f1b1e52e488375ebed19d22f8567"
SRC_URI[sha256sum] = "d660da9a0234cff2923c269ebf1404069a23e73b8658ff693b4e94c7e12fc67c"
