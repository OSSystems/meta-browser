# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "5b2d499de1f54bcf60bf56c9271059c0beab0d444397b48f6212301de4cd0447"
