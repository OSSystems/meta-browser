# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db2353a96fd08c3b67a604fe219f9248"
SRC_URI[sha256sum] = "f5f8d5eedacea135533326aa4cf2e578f0859603588bc3c341b6c045523bf07e"
