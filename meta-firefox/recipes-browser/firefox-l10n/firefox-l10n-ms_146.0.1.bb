# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b1ebaf6e6175b9cbb3707a6cfeef11df"
SRC_URI[sha256sum] = "27e722e4ac38e8560d9d46fdc7eeceac3b69fe5b7f4d2c32256ad651a2d9bf0c"
