# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "12c0a2eae4e3d73c072bb8a5859afacd"
SRC_URI[sha256sum] = "3eeeb09502563f8ebb014db9bf041c9ae9386e14561fecec980d0cc85d8e3206"
