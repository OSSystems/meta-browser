# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bc743b1c094a0f758213ba41f3f53d90"
SRC_URI[sha256sum] = "9c381f15dfdecee6dc0228efdb21083dfd5a62899af76b00bdb414ab0b05ba2d"
