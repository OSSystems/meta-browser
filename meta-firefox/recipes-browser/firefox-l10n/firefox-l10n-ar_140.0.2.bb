# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7c3f69f697db2c96275de060689bc688"
SRC_URI[sha256sum] = "88e649b062d35d2146fa65ca6c429157a8317cca458dd19e3e07fb08dc0bd871"
