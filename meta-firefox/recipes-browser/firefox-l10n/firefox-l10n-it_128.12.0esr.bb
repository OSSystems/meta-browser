# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "903fb8be3641c96d7dee0d367484f06f"
SRC_URI[sha256sum] = "3d1e115468f2bd5624927b943201108f7545a02363245ad148a709796920d5b6"
