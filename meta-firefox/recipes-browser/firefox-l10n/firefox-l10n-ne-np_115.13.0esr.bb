# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c6b49d40c7083800aa56ba4ea7b998c9"
SRC_URI[sha256sum] = "64866ac11ffed00b14a47e0e6ea495d5c82a536eb85f91a67469cf706e38529a"
