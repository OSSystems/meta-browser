# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "299627353a0b55c4d19c290b080ae573"
SRC_URI[sha256sum] = "2661a643732d2322a7537fa36da5e9bf73eea213be75e36c391d0a53611c9932"
