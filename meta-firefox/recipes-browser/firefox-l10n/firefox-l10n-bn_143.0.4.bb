# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a06d36fce31b77c622ececa3ab64b01a"
SRC_URI[sha256sum] = "a76baef39d465f7bf72c4f89d87fe8f1ba1dbf9b800728cc5c65ca604acd6df4"
