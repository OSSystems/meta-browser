# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "9b9126f8ef0642f394319002bba8ec559ca197ff1f9be7802328074fcc4204cc"
