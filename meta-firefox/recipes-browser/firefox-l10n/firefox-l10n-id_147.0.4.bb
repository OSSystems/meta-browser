# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "70c21cfb8b9cb6de2f12a99ae0312763"
SRC_URI[sha256sum] = "3c3eb8e88accf976ca9fb051917d00be68105ccf4725a19d21b988c48d2f3f36"
