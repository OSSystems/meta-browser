# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "13e06ffca976f9e2209f1af428054abc"
SRC_URI[sha256sum] = "eb1e411762fd1e69d3e3781c051f8d17d70a8fd8cad352ee6aec2daea5db5caf"
