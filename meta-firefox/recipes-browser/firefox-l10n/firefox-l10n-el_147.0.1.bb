# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6a850b60c25ad5351896852e7ed1cd28"
SRC_URI[sha256sum] = "0b095aacaf9750c0361d17d8c980f19a47f37117468a9de2c83139ea8d336c3e"
