# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "59108dbfdaa33d5e27277c01d0e47d5e"
SRC_URI[sha256sum] = "48f90842071a571e480e3da772b5b0ce5ec471583ce9e072ba1b1709845e7168"
