# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ff1570398d2618583fb55da40d13491d"
SRC_URI[sha256sum] = "1aa51a67664eeae76ac9ae2177bd959473e46a821c9896e9b290e05d29550370"
