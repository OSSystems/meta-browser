# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8c176a3f3c3793dacdb3984aca788347"
SRC_URI[sha256sum] = "5d4a84599d64e47ab4bbb0a71a5d5db8d7303ee1e29e38ecc4c56f54e40a0238"
