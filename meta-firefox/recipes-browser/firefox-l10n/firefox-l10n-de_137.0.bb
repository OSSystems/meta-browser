# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cb6b9504dd0ef43ae9db7fcfdcbf0a8a"
SRC_URI[sha256sum] = "a71391e5d2f9b176926c1bd7cec2e9ed6ef6fba34f1b326067fc133e47439174"
