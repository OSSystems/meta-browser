# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "267e23a561316d8fd81ab0ab1dff6337"
SRC_URI[sha256sum] = "0f1106e351eacf89426813587d43cfa1ba9c609c5d844fe784660ac69c2d01be"
