# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cbea8e76216dd1baed78013c3f10a398"
SRC_URI[sha256sum] = "6db28544d280a4e1d341e6d3cdaf8999d2b91c220b31c9301ea44e42a864de6b"
