# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bb604ea466d6fb7235ab960f3a2da68b"
SRC_URI[sha256sum] = "7524117f0cc824715ee3cf9ce17ce93d075792f8fd12bbd61e42fe9f35015a0d"
