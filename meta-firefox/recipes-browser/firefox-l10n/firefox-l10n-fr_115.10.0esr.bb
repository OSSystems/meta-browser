# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d59be48d0a0f6534dc8b605873028b1b"
SRC_URI[sha256sum] = "c7efd4bc66e4e7cfce3dec8acd898e248a1e44365d0aca45f88affb174ab9b1b"
