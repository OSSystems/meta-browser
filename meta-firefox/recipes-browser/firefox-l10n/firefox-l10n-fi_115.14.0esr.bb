# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "909f835728fa60ced804a66393a1673f"
SRC_URI[sha256sum] = "82912e7bcced55b0f21ef4309b946ef47b452188830a45c93fce22231bb675f1"
