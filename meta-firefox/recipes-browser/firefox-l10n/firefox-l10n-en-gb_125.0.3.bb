# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2d4c33d89c57c018e375e3d879de9aa3"
SRC_URI[sha256sum] = "b99ea721f3a6a6207564f5a7b01f401f10ea63925d67ce68d6fbdf4306441569"
