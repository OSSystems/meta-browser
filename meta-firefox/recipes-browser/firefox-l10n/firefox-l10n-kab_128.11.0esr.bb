# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c9d10d38ab46d7942b1a4055d55d018"
SRC_URI[sha256sum] = "cb00ca7270f56c3c4f22679ca829b90fcea68892c42c0c8c8af06378c1ae7948"
