# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "31780f78fbd1c66f806dd1af621401ac"
SRC_URI[sha256sum] = "4b99a0f5d7879dceeccee7e33b036102d8be4c5c0c686d9c91a9b2e486a82ecb"
