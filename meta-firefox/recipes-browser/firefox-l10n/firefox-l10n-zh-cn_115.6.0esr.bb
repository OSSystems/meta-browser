# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "751eddd88bea1d07c0f90be4eb9b4d32"
SRC_URI[sha256sum] = "d9603a57b4e0cdef5d212b4782664a4cf628ebf9922e6fcf74cf87b150d02962"
