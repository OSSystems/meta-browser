# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "86dbbf1bc0563c616f3cdd84fc503f33"
SRC_URI[sha256sum] = "c726f47b4242f2258f61d47d9889a7b8a33312b322d9a330af01eda1be1fdf5d"
