# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f0cca825fdfbf101c0c6476b1861f4fb"
SRC_URI[sha256sum] = "75d5a4e179f5434b6457c6e48dc6c026c3e8d9d148022e74b17eeb529cda3090"
