# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1999d74cd970bb0110a89bdf62f966f5"
SRC_URI[sha256sum] = "bf8f811a719fb32d3b28d7fc75d61cc2d1e10fbc0e05f2793a7ab977cb649efa"
