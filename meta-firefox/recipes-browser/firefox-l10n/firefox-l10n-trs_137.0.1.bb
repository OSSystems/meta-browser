# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3bb929558e6a599093596615ea4329b5"
SRC_URI[sha256sum] = "ec5d18ae46cc731ab11ca2b9a0356212db72ca042095db4a44b42a5e6a6d1c30"
