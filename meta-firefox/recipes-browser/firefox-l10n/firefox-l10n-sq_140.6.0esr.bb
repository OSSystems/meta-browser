# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "27b99ae978c6958d6ec378773ab641ac"
SRC_URI[sha256sum] = "2e90572075b17d574db0112ce3861eae2bf148700fd79400a918bbfdfc053849"
