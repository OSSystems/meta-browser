# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "66685d691d854e2f774700c286ce161f"
SRC_URI[sha256sum] = "9ae0e678a6d05f2b20c9ef0c558b77cc6da51f66f734306a2c9d3d7ed7b7bb2f"
