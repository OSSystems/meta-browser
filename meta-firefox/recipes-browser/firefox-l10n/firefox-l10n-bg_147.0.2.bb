# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dc0fb6afe7cf7c794a0d4f9dfce3f646"
SRC_URI[sha256sum] = "3d30bbc915dc1cfdc2a4632cb424f356bad417bcd31457c1a6382a46d38162eb"
