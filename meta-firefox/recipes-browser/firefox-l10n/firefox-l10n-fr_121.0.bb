# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "16b42e17a600b65c02b373280d419390"
SRC_URI[sha256sum] = "2f7f189c5fb8f0b81a890bdff1e702b1966b6d83a0207f0b509ae4d788b2878b"
