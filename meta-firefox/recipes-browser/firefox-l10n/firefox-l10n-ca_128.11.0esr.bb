# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3c09dff26ceb0e16f0322e951b6b0fbf"
SRC_URI[sha256sum] = "2d94fa11b228309aa0ded46bc3279ddfadc8457419b0405a75a490b38c19e47c"
