# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "0d82a8a77ddbc00ae0296936e636fd86205a8e45bcd2275e733ec919fb486ce9"
