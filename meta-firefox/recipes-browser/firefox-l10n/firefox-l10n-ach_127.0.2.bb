# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4acb826ae8aa9b0e3030be8896372473"
SRC_URI[sha256sum] = "d8a2b1b906a6dccf4fbbaa542db6d75594eb708515b1d0fd4b4580cacc01dbf1"
