# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "feb866f9cc871c6c1680b32ea654745d"
SRC_URI[sha256sum] = "6aa6c78c592544be8ea74d6ac1215fd333c21af3ec5dd6592a28eddc098096db"
