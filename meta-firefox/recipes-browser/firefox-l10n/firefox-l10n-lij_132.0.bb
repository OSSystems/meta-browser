# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f105cdf6ee50112a8c5c8aa9346eb10d"
SRC_URI[sha256sum] = "d6eb3834afdd27d790c6ab741200495e7aa325cf8d77d291c513981fa423c828"
