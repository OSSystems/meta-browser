# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a8e8d23c83183bfb2e78b4e9a62e83fb"
SRC_URI[sha256sum] = "9a3ecf68670e52b0c8fe5b311df2209a815cf08625841cad8201c67ba7d1fa3f"
