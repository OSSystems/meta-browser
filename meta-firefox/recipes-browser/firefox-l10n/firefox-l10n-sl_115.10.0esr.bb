# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "48954f38ab3602e2ae592e1c7fb40c17"
SRC_URI[sha256sum] = "66355e623a24c0abd94888e0c670b29aa426d4b1f39f3dd35b3b81265a7aa4a0"
