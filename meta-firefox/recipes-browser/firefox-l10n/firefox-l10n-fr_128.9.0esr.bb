# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "39d89c6ad6278ca13869f0db738cf0ac"
SRC_URI[sha256sum] = "64a8cb85c021a6ad030f42597a53671464b0fac292406b0c92c7708cd6cb58c6"
