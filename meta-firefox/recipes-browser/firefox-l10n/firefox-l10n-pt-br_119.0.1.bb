# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2a32c24e9c136d1f4b340b1b4c41e758"
SRC_URI[sha256sum] = "cef7d6343a79bc6e5cc419bfeab052b23500f920809374a2e196104f8b5532d6"
