# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1b0e0ca371f7aa1093d89e9961d5ec88"
SRC_URI[sha256sum] = "2d7a905023fad40e99c2a355727e6e7e05cac8f56b6f2c725904214b8f50cb35"
