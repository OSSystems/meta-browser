# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b8fb534638e4442227e81f191e1821fd"
SRC_URI[sha256sum] = "64208c436ce8bf5d9eb8ca81c8338b0183333f055a5ff6ef6e4f574a9d8dcead"
