# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1e89fc64f03890de7bb978b219b7d0ba"
SRC_URI[sha256sum] = "cb3ee1f9db495edb8649ad7574bef2c22f31fcae41e05b3fdda05deddee059b6"
