# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0520fa38ded5680717043c6b6ebd4b38"
SRC_URI[sha256sum] = "1db7ff32f10fde2d6735f26f3e47f3ff1dcdcca5c584068092be12be3579e9f1"
