# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f088086d8bcb71a0212b4cacaa5e1ca1"
SRC_URI[sha256sum] = "5efe378488dc1268ff155ed2004e0d385ba50aa1979d7dda5bd56f35cfd5702c"
