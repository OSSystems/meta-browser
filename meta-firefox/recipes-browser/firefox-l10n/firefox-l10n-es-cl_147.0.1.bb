# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fbb66353d40baedc2f8fc479628366b0"
SRC_URI[sha256sum] = "3e11201bc684f3fb6a46a876d7bfc2235fa2aaec3dabfd84b379f7dce02da55b"
