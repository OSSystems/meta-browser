# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5b86f4f3725024c937236db5be240575"
SRC_URI[sha256sum] = "842154d5fcb84bda2b0f6964f8cb2a70577c808bd46a3bb018c454cb47122a30"
