# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ea5a6f0099ff0b0beed278efc069c9a2a064d56529470f83ab25d773e73647c0"
