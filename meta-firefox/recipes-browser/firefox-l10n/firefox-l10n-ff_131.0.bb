# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1c194d608e9660315a9dcd444d5f9f11"
SRC_URI[sha256sum] = "8f61e61d0c45d38cd50e2382a87e6596597f17e387b4c7aefbd0e6a292897db0"
