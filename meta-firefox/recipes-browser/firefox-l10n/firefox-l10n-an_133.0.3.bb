# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bb8a01cd8044d588de2a7c8fd2d16060"
SRC_URI[sha256sum] = "b4f4b07dc6ed380e95c91a1035af8b3ad956124ea555a518b5dea353303fa0ce"
