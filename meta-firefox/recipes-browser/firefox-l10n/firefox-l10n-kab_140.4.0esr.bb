# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "20aae482b81f80236a48f1b2daeaefee"
SRC_URI[sha256sum] = "d860785e96b652419dc71c02b6d86d05b5dfff4fc9fe353806fc896298e87062"
