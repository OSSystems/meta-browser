# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dc680dd46b60107ef02fdfd2265711d9"
SRC_URI[sha256sum] = "4a090fe897730cf3e767a8fd02a602220341a7c244dc01b74266dc1ea71d857e"
