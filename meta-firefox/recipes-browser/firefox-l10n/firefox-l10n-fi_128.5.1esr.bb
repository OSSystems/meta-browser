# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6f4ed32f0308821aededf05f3759a3c7"
SRC_URI[sha256sum] = "2b4f9f58f43ce9305ece87df6870dae6fed496150be1a465dc4e416f38a503b3"
