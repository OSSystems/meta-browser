# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cee38de6828f72cddf739ba08db4f5fd"
SRC_URI[sha256sum] = "73cedc57cb000baff9fcd7dff078008b6e660d1525d73b6782b674777d90a6b9"
