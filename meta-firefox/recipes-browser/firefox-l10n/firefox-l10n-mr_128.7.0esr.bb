# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "700bac7e5d585ce1978ada9f37571081"
SRC_URI[sha256sum] = "ceacdef4d96b3ef10aeefce24d56002361559bbb026563f958f0efdc8d528f1e"
