# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "972fa51aacef42a66ac3ddf1db3f256d"
SRC_URI[sha256sum] = "700219b596e513e332fd1e149280cac92482c7daa429509d9ef10252d8bf5583"
