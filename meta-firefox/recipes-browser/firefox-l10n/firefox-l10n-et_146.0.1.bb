# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "25b8308d828280f9cab6ca2746e49129"
SRC_URI[sha256sum] = "df408c77c124593dc8e4cba632cc3bef49e2ba8e5530b13ace969048605b1493"
