# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ea01534c776213d7cedb7421464e9799"
SRC_URI[sha256sum] = "34194eaa6714834fa12b2b293e97bb2a9e152b6bb98c6a75ca88a24fcd0642f2"
