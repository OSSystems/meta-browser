# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d384dacf1a688899e07206661e910092"
SRC_URI[sha256sum] = "d82a84af6cba88e547747928f6f04489e1cb9af4eb317c77f9931810c0533020"
