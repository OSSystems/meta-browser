# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "f7295a96d1fd089986777da20de814bd6c4fa9480030cdb29ab6c92ae2bc49d6"
