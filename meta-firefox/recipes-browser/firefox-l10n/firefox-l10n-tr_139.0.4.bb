# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f869281e1de2a136257b5df222710d10"
SRC_URI[sha256sum] = "9601ad93c299aa2ba64c7ab4bcd00cfddb796c4a83a4164009fc1ff5e03692f9"
