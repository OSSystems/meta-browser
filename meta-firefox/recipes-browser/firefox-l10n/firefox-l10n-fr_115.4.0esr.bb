# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5d644ed2cd8a1a45a93426cdacc55920"
SRC_URI[sha256sum] = "89c18f20ceb67d6b3fcb995775668d94a92a0deb7557e06778e7945fa44c1f58"
