# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3a58f4579a0f971425dde970290dc009"
SRC_URI[sha256sum] = "6da68d1c1fef6ba6fbca86d1f69b81dc870bb44eba7e17dc95f38b5c905bf450"
