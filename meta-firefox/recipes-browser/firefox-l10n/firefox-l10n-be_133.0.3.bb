# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7a3028e00e677c30142e32139ae27fb3"
SRC_URI[sha256sum] = "c2b9305e909d4aff9f708915e2b6bca38fcc1cbd2d8670039750b86becca039a"
