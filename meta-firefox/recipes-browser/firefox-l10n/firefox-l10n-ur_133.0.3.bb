# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "34fb3642ec5d07d6225ed668e3f909f8"
SRC_URI[sha256sum] = "0e7cb08591ba64b2f8506ea84100106cdcdf628f251ade5e29cba22a07aba797"
