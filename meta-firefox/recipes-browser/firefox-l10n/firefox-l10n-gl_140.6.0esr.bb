# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "646f7691b25ed5234d3c891ea491279a"
SRC_URI[sha256sum] = "d3f1f6d59ac7384f254f14007f2a060f8e103ac8fbe5cdc0cf559883f2ec4339"
