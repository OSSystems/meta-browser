# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1bf684bb57a21e1c2019636a0fcdee2b"
SRC_URI[sha256sum] = "38718e8dbc2d7b966deca7a07f6143f3f4def396c2372ed8278a0fc63cced70b"
