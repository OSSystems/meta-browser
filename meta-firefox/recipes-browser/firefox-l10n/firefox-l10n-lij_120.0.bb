# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "95098ed3063aa580dfbb461fd34672d7"
SRC_URI[sha256sum] = "0b01358e5d15f5b9f7b3661afc695749e84261b2fe178d02fe0190222e15f638"
