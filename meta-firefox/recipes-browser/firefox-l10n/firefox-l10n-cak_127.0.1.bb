# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ec2f50f8faea0e6ae9ae48f9f12d65f"
SRC_URI[sha256sum] = "45eb80c6d3aeb59e78de3a64f49dae24fb3f6a8dc051f5eac072d9e528911aad"
