# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "359793da2608621ba0f41b82a223dd5a"
SRC_URI[sha256sum] = "1b4914c3bcff6475481225078c2913ed62ba9b206a9a5ab0862ff022e86b06b1"
