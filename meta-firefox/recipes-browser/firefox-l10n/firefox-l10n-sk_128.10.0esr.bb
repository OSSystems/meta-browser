# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "063e458ff73054236f3d53b572e1ae8d"
SRC_URI[sha256sum] = "8b423baac2975c1daacaaf46873a02d01b6e3697b0b8631e3ce392b01a870f11"
