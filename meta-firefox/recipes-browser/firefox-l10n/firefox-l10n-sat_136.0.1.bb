# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "412bf32e3df3266806fcc687ade17d4b"
SRC_URI[sha256sum] = "7857c4ae9f3e811459970d464f6678ffc0091d208e20e6a81c50b75d20ea6a5e"
