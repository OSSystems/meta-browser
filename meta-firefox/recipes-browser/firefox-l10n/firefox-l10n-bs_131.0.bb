# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6e2dc2d6caad0149f18e747f13ea8dc6"
SRC_URI[sha256sum] = "7cb03e14b27216071b06dc6ff19b96f67b0084d2b3abc6932ccc004d1f91c72f"
