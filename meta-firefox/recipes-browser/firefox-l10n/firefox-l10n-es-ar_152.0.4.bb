# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "aadc1481ef8f6569bc2f491f30ee10ad3c72a7aae7770d84d6e77f7da8cdc0e9"
