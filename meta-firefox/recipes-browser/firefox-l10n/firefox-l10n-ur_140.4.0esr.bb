# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1fc54795f591019f5a02f3e2334a61b3"
SRC_URI[sha256sum] = "209c7fae3cbe90fcfa860f7aff53cacb655075716842d1e984823afe312eb31a"
