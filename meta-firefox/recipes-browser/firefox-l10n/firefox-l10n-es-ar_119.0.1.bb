# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "349767889805420a85a500ee7d157940"
SRC_URI[sha256sum] = "bdd544d6da4ce90fac8c209dc587b278c79cd1b991522feb9b8e6a516d8a7263"
