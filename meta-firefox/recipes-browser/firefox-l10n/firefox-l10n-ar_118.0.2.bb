# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bfe1465c049e01f5daf66af2d45890cc"
SRC_URI[sha256sum] = "c2d618cfff1fda3f3dea6240cf23da43772d43e8c426aeae70407dbf057c14b2"
