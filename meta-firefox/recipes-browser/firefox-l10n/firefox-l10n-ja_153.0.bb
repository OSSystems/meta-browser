# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "229be9fcad335fe6db255f3166f5a86b26408f24475b0a77c8bc5176d881c88d"
