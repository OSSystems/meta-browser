# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d8ebafc31f0967dfd7a08c9b1a1789c0"
SRC_URI[sha256sum] = "1d81d89ac3b9922fa6f734462acb7c7aed0096db13c7bed07eabbff4014c9b57"
