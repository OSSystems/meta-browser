# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "543ef88a1f0341a8f39fc0f1afc987c4"
SRC_URI[sha256sum] = "a77ae4578d8c79debf28715507fa62aa9d13867012d7f3637746ee86fd91d2b2"
