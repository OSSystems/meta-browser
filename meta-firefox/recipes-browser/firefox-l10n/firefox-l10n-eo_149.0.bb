# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c76d9a3c6504b0ec45e3781835beb71d"
SRC_URI[sha256sum] = "cd917776568db8b197df169932b1ccd705cf822bc0f36ed3b38d5b02085e2c3b"
