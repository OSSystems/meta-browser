# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f6536785e83feb975207fc9801ad1284"
SRC_URI[sha256sum] = "a40a04003d54a5a329428ce34c999be838db164ca8906ebdcda52bc42e8edba8"
