# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "eaec21db4fb4aada6a7260fc84f31bcaf283313910595f3d0a8732e14a3c53cf"
