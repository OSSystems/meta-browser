# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6d018ee3b8c93b11c8584fe911d52a16"
SRC_URI[sha256sum] = "3519be02a73faa2e57d26d4f66b15531b33700329fc4d3eb8e817719f89accfe"
