# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eed559fe0c1190e92df98fdfc9621891"
SRC_URI[sha256sum] = "4313f83352e7516b507270a724b3a0849c7a26cb408c446ac25077a2c89ecafc"
