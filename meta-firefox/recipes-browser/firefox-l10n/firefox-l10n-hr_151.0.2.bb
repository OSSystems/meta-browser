# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "1635383255b10d46646e3e028664b3a973e05a5205462d3f68fa35e35605f623"
