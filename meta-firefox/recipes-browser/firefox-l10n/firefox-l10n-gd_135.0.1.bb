# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dcf4e144fb5fdbdd91b129bd3c6ce5be"
SRC_URI[sha256sum] = "1ba1cde1a23991a95f1c56c4558b847bf578c24ca468118eff7ea3ed1c7379bb"
