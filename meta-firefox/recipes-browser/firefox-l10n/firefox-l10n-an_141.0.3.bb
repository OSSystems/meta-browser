# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1caed37560d89799ff0b499540806292"
SRC_URI[sha256sum] = "8ec64af5901ef990fee7119341e01fb794f10864a700a68334ae7d4aefe91ad6"
