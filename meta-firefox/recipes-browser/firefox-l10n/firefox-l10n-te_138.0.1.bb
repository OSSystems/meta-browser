# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "71eecf8057458281f0d97378330ae57c"
SRC_URI[sha256sum] = "7231b95ec722f49ad06ba3db843e77bfbe83e793c526fed1c23a0fd2433c9307"
