# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "51cb140c7b2c6bdb0bf71ab2d9408bb7"
SRC_URI[sha256sum] = "9cd68db0ae8ebd50da14786f8af7c10c430f50cdf347172b4900eede54921c21"
