# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cf137f4c5f7b043b3331b01efad36a68"
SRC_URI[sha256sum] = "a9030839c0ad745d99410c99c89030db55a2255e092538c02fe330a0057e3853"
