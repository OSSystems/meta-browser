# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "622ad04a1493ef8b298067db7d6e52eb"
SRC_URI[sha256sum] = "d2b2e1d9698488fab6f587eee19a02c3ce26a0abca01c9f855ac886e012cba94"
