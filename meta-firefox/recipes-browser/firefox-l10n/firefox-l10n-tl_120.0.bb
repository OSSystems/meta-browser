# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4bcaacce074ffe5eb0284c0064e85df9"
SRC_URI[sha256sum] = "95e8b6c1f6c08f73d982548e2e993a81a5d87d1203d9aa50a6c27b5585d669f9"
