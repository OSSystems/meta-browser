# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a5cf4c7ca815525f19e06e83596667ff"
SRC_URI[sha256sum] = "ae134bd452e8aac075125d28b0eb882bacb0d53b4553bcdd655c5986c98bd921"
