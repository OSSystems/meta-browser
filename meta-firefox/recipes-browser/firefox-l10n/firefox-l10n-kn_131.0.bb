# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7d3bd84061a6306d0c6d7285f5aff458"
SRC_URI[sha256sum] = "796960f28c89d6c4fe7aff58b8d05bdc778e7452938ed70348a3e441f5c14247"
