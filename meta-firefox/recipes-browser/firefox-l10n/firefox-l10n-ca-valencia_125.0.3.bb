# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3c132854252790b19a009d3fd8913907"
SRC_URI[sha256sum] = "e345fcfc0ce4459ea19c52d0ada1c83763350a85280ad2e590e8fd077c22ebb0"
