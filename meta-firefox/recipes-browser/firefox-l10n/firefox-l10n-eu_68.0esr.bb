# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c147fc403d0ecb5c9508fa85d2d1cb27"
SRC_URI[sha256sum] = "417e7225d83dd0251eeb850f0bc21728ad97cc8e81a6614c8fb75eb198891f51"
