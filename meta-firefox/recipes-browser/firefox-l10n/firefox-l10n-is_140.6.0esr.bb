# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c7293d20e49dcecfcc9acb95f3312cb7"
SRC_URI[sha256sum] = "266429719ac0d0d598b4e7479828e5f736bcb8f8dd35cc75f8f06843962a3e7c"
