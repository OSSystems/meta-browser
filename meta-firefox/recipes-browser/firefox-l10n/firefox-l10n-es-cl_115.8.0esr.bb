# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "27d15fb7cf66e87a7f3c3bf2ab4246ca"
SRC_URI[sha256sum] = "296ce4fb319a216469f723487e34228608818c6c252f9ff7dac506352f099bfd"
