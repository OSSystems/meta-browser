# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b999023b577506f343d92e2f3e3d8e66"
SRC_URI[sha256sum] = "0f467cec82681fe5309dd24a111c866a37854db1cb4021ac920c40d2fd0eeda3"
