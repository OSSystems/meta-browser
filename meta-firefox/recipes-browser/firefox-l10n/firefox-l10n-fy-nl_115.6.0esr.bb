# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1ed69a25a0c7a83330ec98f37a460c96"
SRC_URI[sha256sum] = "d7b2d22d79d9e08f143c5b34df2c9d4bd02d4d229fdc95d091503392cb52d9d7"
