# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "50159eaeb323fde92855c10df6c2cffec4ad12d9b8fde4f275172fea19175783"
