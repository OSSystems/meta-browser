# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ab420e01c2c7a7f7f1e0e7fca70e6eccf7162860e478fb7131e8a94e2a45f788"
