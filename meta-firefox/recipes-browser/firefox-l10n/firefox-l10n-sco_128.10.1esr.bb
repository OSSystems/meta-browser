# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1a882203170cc64f36225fe9a43fc54b"
SRC_URI[sha256sum] = "efde95469078ad5ce03075e92912e565df30a7d897cc2e329e7b814b68ceea94"
