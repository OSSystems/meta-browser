# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "560d013c5f02c26e40aff02c3ad6bd0d"
SRC_URI[sha256sum] = "4ede164cdbcda452c4431278e5ea2e1c08bd86e283f0e964ff9ef4c59d500c5d"
