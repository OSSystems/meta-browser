# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b93f43f05ee642e1d7e938ff25e569db"
SRC_URI[sha256sum] = "7070b2f9b88be85542d74c73364b3a3d4808d030a0cba763f6c2fbe2f3a53dc5"
