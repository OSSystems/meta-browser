# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4ed265c4b30929b45cafd28eb53720a7"
SRC_URI[sha256sum] = "68ece46a02bc5e996106d54767ffff5d84598b72a7ff07726beb749acdf65134"
