# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2594b4fdddb335c6fd1454b9694af3dc"
SRC_URI[sha256sum] = "4396982b1c4dffd98835f365daf4dec933986f56c802c875bfcb50b6ae542a46"
