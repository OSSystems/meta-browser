# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7b4967199c69cb3398b5e0af340ceaf4"
SRC_URI[sha256sum] = "aa3c7acb077ba079c47042af17f7d060009fdbd038983c3141aee574c329057c"
