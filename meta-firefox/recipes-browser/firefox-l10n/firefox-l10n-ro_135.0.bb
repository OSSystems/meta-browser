# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "81dd72c00e75451a8aa573499784755d"
SRC_URI[sha256sum] = "1fd05a3f42006131f95d711ed042f423362cc75ea9eb524a84a0d9a746dac69e"
