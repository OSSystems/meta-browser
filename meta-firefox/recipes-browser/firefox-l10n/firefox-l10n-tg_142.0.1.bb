# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "41475b462471ba2b76e4fdee802c5df5"
SRC_URI[sha256sum] = "1cf42b2e2e5cd9de9faf7fb88337f7743f9228fa5518535ecfe609b89c3484ca"
