# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bc402c564de9e082484a81b875889f4a"
SRC_URI[sha256sum] = "ddb76dcd16e512845ba8e052afa41d50db5fc56fb67c2ec548ebbf0b42d2904d"
