# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9176fb0a58d6e589ee92afb3a5c9d068"
SRC_URI[sha256sum] = "a7b7d7038030f38b2c899822ea7d3696f68a477ba9ec706565980b0ddc60dbfa"
