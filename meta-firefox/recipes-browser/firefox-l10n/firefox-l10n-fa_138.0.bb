# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "19e115ca66b0a9f63fc3f0f032839f7b"
SRC_URI[sha256sum] = "bf60ab05e7aa68a1087a3f3a20d9ff948888e478ccd8354163d01b91485502cb"
