# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5316e2e5d732c0a3da688d39963eb190"
SRC_URI[sha256sum] = "b40c53b0b55b6ff53292a75d9a4f5fb5f1d2dd17e60c6c7db930bfc9a0cc5152"
