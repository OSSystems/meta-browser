# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b0e2f6e1761488143f2f2e998b1cec6b"
SRC_URI[sha256sum] = "192360942135e7058022b4d8861ac2eecce2fcefd19541829d226f6000b74bb0"
