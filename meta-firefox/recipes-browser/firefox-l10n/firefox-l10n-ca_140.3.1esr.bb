# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f503c2000ae7aee89a0faa82f0d79224"
SRC_URI[sha256sum] = "25c990f35d1c4963435f51c00026dd3cb9d190928a0cb180df11506a85fa25fc"
