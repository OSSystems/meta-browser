# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c9a7301e274dea1729a1ebc482ee5e51"
SRC_URI[sha256sum] = "955cc4a4a719256997135e6e9cd9d9643461da15e8a9315bdeec86d294ca3562"
