# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5752643444a403a5e12fb58bfd51b7ff"
SRC_URI[sha256sum] = "94d2801f015a75ece4358a7ab9b9f34979c262b9f93b6d27f1bcac81b72074fd"
