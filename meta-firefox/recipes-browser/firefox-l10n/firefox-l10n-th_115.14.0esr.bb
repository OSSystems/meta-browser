# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "55a8ced5a14efd35ac82e98b87ee24df"
SRC_URI[sha256sum] = "6e0e049954a2a454a658863725ea3fcde11a8238af6a56e44b30c9b3ed7b9726"
