# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a181566ecee11feb4c7448444ed567cf"
SRC_URI[sha256sum] = "cbd0fabe4d973cc17c9d4d6081f90b633ad657933683722ed7b48fab38293136"
