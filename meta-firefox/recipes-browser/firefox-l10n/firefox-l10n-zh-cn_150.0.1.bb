# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "64b6c7480c1517fc4c55651bdb75686219259aa14278efedd83605286afbbfaa"
