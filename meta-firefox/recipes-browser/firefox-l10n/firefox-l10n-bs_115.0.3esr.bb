# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6f658bc8ab11f1a002585919be35cebc"
SRC_URI[sha256sum] = "6351197dc147c09f8308f5272f5b80d5993e55bd04ab4f51ace480b345979639"
