# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8f9a8a6b11cb756f7d17df3102e74bed"
SRC_URI[sha256sum] = "86bcafd00c0d053d30c0fbd10c0202fa1003deb8d77c107f803720e6e6afcca9"
