# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e184be130abfab265b170b8bed7382cf"
SRC_URI[sha256sum] = "f63d7b9a80554d830bedf0da6a53fa81711c841955c124082886fea72a56447f"
