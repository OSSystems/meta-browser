# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aa15ecfcce8f18e2ae1c8b0a3c925fad"
SRC_URI[sha256sum] = "d0f4f9a0a401b2f06d22132f76ce0e76deea43ef5b8e27183f3714099a496632"
