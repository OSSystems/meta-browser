# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b58fdd952e50b563245d13ea006c0e7e"
SRC_URI[sha256sum] = "ce96b07b7a00097f62c94e2646a84686802eed1165e7c5fe69ea61ae97e1add6"
