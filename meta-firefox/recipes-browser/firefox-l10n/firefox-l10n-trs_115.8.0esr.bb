# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8a70ced2a645356768f194bad8edef22"
SRC_URI[sha256sum] = "395cc4fa7aadfac811e78b753cb43acd85df9e0ebaee10929d6d968e5c7d8286"
