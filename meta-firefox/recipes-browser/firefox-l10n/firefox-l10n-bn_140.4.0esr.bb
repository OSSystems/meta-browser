# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ffaccbcca11a774d6d3894fe8ab575e"
SRC_URI[sha256sum] = "4a82eb6b6090e6117d77d18ac393a50221e87df1532a9276242d95c3d22fc96b"
