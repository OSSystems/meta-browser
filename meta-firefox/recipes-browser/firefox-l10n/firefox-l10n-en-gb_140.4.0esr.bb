# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b87ea090fcff6e261f7f5fbf1d17043e"
SRC_URI[sha256sum] = "d46f31cd5f2c2fca2bdd03cc4222b33655c63bd703875fea5c3e2bff64acde94"
