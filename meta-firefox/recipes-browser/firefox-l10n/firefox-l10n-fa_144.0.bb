# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8df53f88832c6273105b16cca2d38dc9"
SRC_URI[sha256sum] = "14bfe00be4f11c2f9c3ba43e1bcea87e7ae017ceaeffddfde6cf661e33582f37"
