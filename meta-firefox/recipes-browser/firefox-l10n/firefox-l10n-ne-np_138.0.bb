# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b0ffd7b7738d3b1c89969c00da3b26e3"
SRC_URI[sha256sum] = "4f74efbce2c8ffc18f06b7ddcf2a3657f7c177749b69bdf69a743a11617e9d77"
