# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f3990c72afceff2b08cee6255e391472"
SRC_URI[sha256sum] = "b6dac6c05a7c5953e5333571299307264374719f078b7530f335589c2677ab81"
