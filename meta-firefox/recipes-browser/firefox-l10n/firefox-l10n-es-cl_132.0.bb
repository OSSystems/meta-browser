# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ba5b41e81e48d5c47d620fc506922993"
SRC_URI[sha256sum] = "c57155d11574d941e4d919155d632898095641df853beb0337760b056fd7b852"
