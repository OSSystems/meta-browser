# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0ec2e3de810a54bff96981d8af80b2e1"
SRC_URI[sha256sum] = "e675257314f34f9d7b1f98a108c270bdaa3a20850d1a571c970a9a599b8ccf4c"
