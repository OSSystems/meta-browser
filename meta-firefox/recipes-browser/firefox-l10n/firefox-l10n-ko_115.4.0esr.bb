# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e2256a0656f2de0a8241bd2c0ca90bf8"
SRC_URI[sha256sum] = "a92597f65d5adb2b709e7ef4de4e94e9b1c287b8e9523d093b4f7ea4a82f0d81"
