# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "381ef9a4947dbeaa6429d0449bf763e3"
SRC_URI[sha256sum] = "27ad99442673e1a416f970d45a3d074f755dcbe66e79245afb99c23328b7b69d"
