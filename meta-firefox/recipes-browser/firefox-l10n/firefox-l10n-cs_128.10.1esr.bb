# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5b2b72dd00341b32f93748fcbf400ec3"
SRC_URI[sha256sum] = "3bbb52271933cc310e4a9313635e574bb914f977a8d3b1b4af7a81623ef6c850"
