# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e08a6f352ab9d5f505cca57ed7fe95e6"
SRC_URI[sha256sum] = "c447b5d2b1f23625382f089ee55d7cd805eacc5efc592c49c0b675b318d2ddfc"
