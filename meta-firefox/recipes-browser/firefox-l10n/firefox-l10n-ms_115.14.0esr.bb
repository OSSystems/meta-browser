# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7c5ded679cc5a6bc04639d1c92190ba8"
SRC_URI[sha256sum] = "48230ca53ffbd14cf5636a3fb236f22f6b8953937067fc16e3f55a36c143f626"
