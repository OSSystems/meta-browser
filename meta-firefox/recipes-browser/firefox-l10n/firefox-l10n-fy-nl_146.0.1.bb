# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b8a4e164680589e4fc1258a455ed89ac"
SRC_URI[sha256sum] = "bdeb21d39222b2db3810af07623584d8448a4d032717cc15e1ffe5a98f79f2de"
