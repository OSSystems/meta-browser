# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "63da3e33e092135b6f60386e49a6322d"
SRC_URI[sha256sum] = "38cefe4e97a3aefcb7dd67e759e44e0ed1486c98aec5d3209397927f0253ec06"
