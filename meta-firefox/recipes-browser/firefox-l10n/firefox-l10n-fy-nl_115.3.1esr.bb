# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4c6aa2ed096d456f50670f626a66772a"
SRC_URI[sha256sum] = "5a5f1a97110cdf01d44eecc78dd2c7b9d91c62902a742ae64abd1b44a03c5625"
