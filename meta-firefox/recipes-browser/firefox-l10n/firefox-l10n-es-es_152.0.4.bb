# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "62a9d88e2d62c88cf9af885ea24cb68fb3842f8009ae604ab752e2abc68e8628"
