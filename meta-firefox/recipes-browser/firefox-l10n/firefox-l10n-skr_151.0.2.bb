# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "cdb9cf3a03e021f7fcada9aa44aa691b9fdca6c437185337fea192ff7df7829a"
