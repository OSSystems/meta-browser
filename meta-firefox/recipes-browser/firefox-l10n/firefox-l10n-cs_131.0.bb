# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "296d161a6766a3308a67fa3257bbef1d"
SRC_URI[sha256sum] = "e34c72a0b25296f5f6ea83d382fd7a305c17bcfdb0e66592fc156fbe67177aa7"
