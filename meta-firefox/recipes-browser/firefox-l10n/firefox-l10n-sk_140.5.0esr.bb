# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "29ad925783538dffd355d5f0a8ab9713"
SRC_URI[sha256sum] = "9d6c523546cc3c8d4e1f94b051b9c7b409a98c65737c6744b86ffa64911f235b"
