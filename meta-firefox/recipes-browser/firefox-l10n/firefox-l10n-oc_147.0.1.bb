# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e15cea9a9466693de5e4cf2717a0c194"
SRC_URI[sha256sum] = "4ceed92ea52fc8807de7035d9e3a7804ba6e6ae9c1fb14cf8007ba397088781f"
