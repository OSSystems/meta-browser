# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9abf4f3e0d7db1ef1a1ac891dbcd27ed"
SRC_URI[sha256sum] = "f1abfcf595334cfaa0638478d3d714ce1037d4068c1e67dec9786d7eca6bec6e"
