# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9c23ba4d94d58cea85f3e8a7ec3436cd"
SRC_URI[sha256sum] = "39c9320c4d9a967510406bbf8c1bee17896a6b8530a8c0d54ea0e484e247c462"
