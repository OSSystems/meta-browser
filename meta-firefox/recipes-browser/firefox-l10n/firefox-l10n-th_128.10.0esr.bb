# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f32a6d473ad67f0b55c9fc600dde9ace"
SRC_URI[sha256sum] = "23545527e7a776be579b7f01b66d350f495860e60d4bb3123472c163f882acae"
