# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b8eced6393f3bf6099c627afb7b262f1"
SRC_URI[sha256sum] = "f900a27c1209fb13695fb1b5de9ba05ae2fa62de773d819d45130b65ca17b07c"
