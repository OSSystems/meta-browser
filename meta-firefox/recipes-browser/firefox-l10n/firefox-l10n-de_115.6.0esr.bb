# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "68c359f7c8b346bfbbac1d758aaf1677"
SRC_URI[sha256sum] = "6bef743ececf2ee31533fb9012bab7d4332dd214a71e70eb9b22d3cae5ed491f"
