# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d18d529af8baadc3fb47558657d44096"
SRC_URI[sha256sum] = "6f62423968b04dce4c27247d747e37bf9b88e689976ce8b6704116c21a55f875"
