# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "71ded3ba51dd7926e467d314f324597b5f9fa136d481ad6fdc7b23f9f5b83600"
