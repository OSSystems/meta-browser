# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "22919ff475d2c2ee359a854dc7e593cc"
SRC_URI[sha256sum] = "4912b05b0f0c454ac1f8bb50a326cb67f1d7f2bc0eb6a5998c5d9fecf8a43750"
