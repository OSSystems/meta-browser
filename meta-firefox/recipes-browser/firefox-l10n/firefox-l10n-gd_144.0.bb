# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "abc20940b7bfc12b16a42ac33aaee698"
SRC_URI[sha256sum] = "dc55ecfb0c1e40304c2e40462246b00944a9465e18ac90c7d597eddf66382d4d"
