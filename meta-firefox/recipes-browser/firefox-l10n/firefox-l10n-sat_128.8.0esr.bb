# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "47838270e674c1e812fb89ac2e06d2de"
SRC_URI[sha256sum] = "4f8e2763aac90295209415c08bd57f9c9f9a110e6e3310682db49ce0eb0d97e3"
