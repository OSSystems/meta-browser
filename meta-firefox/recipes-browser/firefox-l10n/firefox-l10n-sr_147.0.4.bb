# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "111194dd4e041afc660ddbb6f23345ac"
SRC_URI[sha256sum] = "fdcfb13287d0a0257a8fbe8ea0a1af93ff3ef29a1cce7a021e8e3cf4a7293a3f"
