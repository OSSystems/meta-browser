# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "20a974b76925b45c1e9806b23ef93d90"
SRC_URI[sha256sum] = "9bfc96c608cd24bf92c3f9e2e2e3513afd28a1c77144445e6228d93981c8ccf2"
