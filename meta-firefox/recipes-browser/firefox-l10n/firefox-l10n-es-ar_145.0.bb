# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "793c8ba5eb0995f9dc11b40fef4cf91d"
SRC_URI[sha256sum] = "df2521cab7cd6b1e5e4e4bc0731afaeb16d508d6b72458427a7d3072d4c74f76"
