# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "469304cb4ee983c7c8ad3b33c29fb8b8"
SRC_URI[sha256sum] = "a152a877a44f74ee638b5a02082ca4b1be85371a0d8830a182a63fcbdc90d9aa"
