# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b93c54ad33ccd3a809ed6758d3c8ac18"
SRC_URI[sha256sum] = "0ae751473ca8d4dc62e16decc635314128a51bb469a2e8b76d0562d39cc7972d"
