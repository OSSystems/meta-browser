# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bd50042901a42b7935faa97694a506a1"
SRC_URI[sha256sum] = "146244b2c41b3b2cfe4c1315033ee6c225433827f493ca708160e14b04837c26"
