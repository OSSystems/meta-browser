# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f8c1ede95acb87e0158a4e55a98c12f8"
SRC_URI[sha256sum] = "9d6d0b17ca70c239f5cccea7f4883331b5602458c27736fc7885a409d3cd404c"
