# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "02d5f4a14809ae0385fefff1dff690d13869b6df1a3160a65a8c9f95a483b260"
