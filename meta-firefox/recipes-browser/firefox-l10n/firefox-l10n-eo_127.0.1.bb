# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e7cc7a705f6a7f49fff49b1e12487887"
SRC_URI[sha256sum] = "2470aa0940b6d368b4f86b03afca4fcab1872f25bdcbd50a295f144fce89c07d"
