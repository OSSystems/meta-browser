# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c67e9f41773d6a3ac13376fffee8a5a3"
SRC_URI[sha256sum] = "ff4ed592b4160bb65b1bef6a9ed6f22baa766cfe54df5c4527c494a8a4250188"
