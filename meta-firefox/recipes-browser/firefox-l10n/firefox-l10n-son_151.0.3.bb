# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "8bef022dabca882cc111e4ad8d6e5b61af776958b33bc682f31602ee10831470"
