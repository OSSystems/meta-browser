# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f1edf7d95988037d913be7a0a98c21e3"
SRC_URI[sha256sum] = "00a999df93fcb7b41758e72b937d84606682bb6e18b2022b769acb9f54fcc59f"
