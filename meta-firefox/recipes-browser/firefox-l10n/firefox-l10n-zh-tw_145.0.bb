# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a7ed9378f645b063fb210d38669d9bf5"
SRC_URI[sha256sum] = "c38101cf3386f6d50aa5c0449d4e4914108a6340aa6491e58d4c4cb6d81433da"
