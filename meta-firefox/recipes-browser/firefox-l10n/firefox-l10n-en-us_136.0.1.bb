# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c7aea8cf179228ef157b08909e85d959"
SRC_URI[sha256sum] = "baa8f7402549f6b6c727c854788435f8c2644a0a5e8022eefd5e707e9369537f"
