# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d2a609da951c01109f44da3385f8f94d"
SRC_URI[sha256sum] = "dec0732f647307dd4d09268a56ffeeeb6904c12230a7d4d98345f32f49f7d2ad"
