# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7c28010ade25916d5910d0899855bf99"
SRC_URI[sha256sum] = "6c1c47d69ed995ed1020021256d7fced2f704809958529a9ead37ad7c915c0b3"
