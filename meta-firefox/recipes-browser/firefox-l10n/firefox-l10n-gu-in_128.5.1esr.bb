# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "04e07d140820f0e374522292bd728988"
SRC_URI[sha256sum] = "45a12974f109680f5424eb0f4a76ff570404d8160617ada79967dba0c812ec1d"
