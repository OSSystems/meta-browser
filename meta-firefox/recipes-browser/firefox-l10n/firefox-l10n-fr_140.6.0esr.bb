# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5117a711eb4807a752f6a45c328a6034"
SRC_URI[sha256sum] = "8a54164177ecc1907b533514f60294c3db046ddfd22095f19982cc847e9f7d1b"
