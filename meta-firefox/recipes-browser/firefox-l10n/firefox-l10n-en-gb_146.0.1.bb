# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5e81dc8d725ef126efd7177e2bb4c070"
SRC_URI[sha256sum] = "70ad0966e3be8efbbe63fe8a18aa200152c356660f01b19462c27651a92e4bce"
