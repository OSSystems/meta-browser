# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c9e9e7530b64e86747cc67f5d5e71b85"
SRC_URI[sha256sum] = "88006d10ecbaaa047bb4de58a92fa2c3b416a39baf7e8547dbece4788d7fa04d"
