# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "482a39b5a2d4de6e3ce2b4d3452f7242"
SRC_URI[sha256sum] = "51528a988eb69ebf8e5fd24b01735db0cdae4ba62ccfeea4b6bae3de5c1329e3"
