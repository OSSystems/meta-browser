# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "49b999a66629080e2f35d735dd2d3d519b597e7ec9d4226371cfef5c4cfc6230"
