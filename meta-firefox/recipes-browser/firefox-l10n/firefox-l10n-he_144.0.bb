# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8bac401bef8de1e673eb23096c5afd91"
SRC_URI[sha256sum] = "d001249e7264c37fae6d7667363692a0a6e6b5146f4fac2dcb9d8eee14c1f035"
