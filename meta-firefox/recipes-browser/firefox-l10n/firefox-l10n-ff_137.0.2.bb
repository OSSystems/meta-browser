# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dc1cc6da32eb8a51c1a7b0030ebfc65b"
SRC_URI[sha256sum] = "9ee0ddd5fa3254563fc91c7b2182bb84dbe49869d0f942aec0154d5afb14a4b3"
