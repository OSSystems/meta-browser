# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "82b761b6a6a5d55a47a86bae832b63be"
SRC_URI[sha256sum] = "a0cf83251f7a26a02cff062a2f1c3f983d4f36ec71014d88093b0a748f246588"
