# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a3909ed4f633859c9813c8502ee39833"
SRC_URI[sha256sum] = "0f906364184f71f7d4cbcae67f56ae932b5dde1a7e5b88b79bae4a1f4da0315a"
