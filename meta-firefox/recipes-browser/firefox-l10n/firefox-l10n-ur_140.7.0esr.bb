# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b2182dfb39b6b316fe82d9c25e41cc99"
SRC_URI[sha256sum] = "311dbff6c85fc4589b5ccbe0bfe4fdb10439153618dedf5b0b37f2716230b7c0"
