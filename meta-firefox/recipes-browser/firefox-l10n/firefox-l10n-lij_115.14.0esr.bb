# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6dc963dd99b2e0865cab5790d2baa99e"
SRC_URI[sha256sum] = "071ac590347f0b3f987cf43f67760f83bfd1e7c26cc59abaa6847945c553f1bf"
