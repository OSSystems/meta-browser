# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "534ee155864cca32e3f9fb0ad40582d4"
SRC_URI[sha256sum] = "2ec5d85bc4d822c6f405ab6710f2c797e51a80d73c61cd5f9ea05c9286cfd8e3"
