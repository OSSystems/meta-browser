# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b57893ef4db0e6f827c5812481a97395"
SRC_URI[sha256sum] = "03dc2d1b85434242c261566ef64c71e9cf5223a49e0b1faaec15271971533a06"
