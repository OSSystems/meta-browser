# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c58454c16d083d4cb145df197fb19039"
SRC_URI[sha256sum] = "7a52ddcf9f7844901ce5d7e37b39b88bf0b9c34a634b3a9178050e9223106d7d"
