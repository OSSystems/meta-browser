# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e63c2820793b9d663f0c619ea175cba5"
SRC_URI[sha256sum] = "063558c09168cd183fe3454f2c59949ac9f77e3d6f390ba3b480b8f2b25a88a1"
