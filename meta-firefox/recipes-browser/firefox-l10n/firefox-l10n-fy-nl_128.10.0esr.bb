# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "080294a0af268b642f601d21fb8c45f6"
SRC_URI[sha256sum] = "a46556209f465e510a5c9d83c4925b9d4be9c0c7d2284575761a6f538b027690"
