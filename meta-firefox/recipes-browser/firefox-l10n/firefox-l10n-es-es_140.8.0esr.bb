# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b9c50b781fef7ea2f6443d30960276a6"
SRC_URI[sha256sum] = "d35d71505158bf50425495301b558325fc69665fa99d1387bf03cfed5d3e35a6"
