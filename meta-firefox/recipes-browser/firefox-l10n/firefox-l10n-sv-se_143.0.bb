# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "46ab8f818acfc8b0b5a3652409c05e1d"
SRC_URI[sha256sum] = "f2e4d9dad6a49fa2b257962d175920127ffe046df6432fb807ccb4b244e6dc02"
