# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "81e27522f6d18efbcf87c728472b3e1178c804452eb62d5caf366dbe2a7763bc"
