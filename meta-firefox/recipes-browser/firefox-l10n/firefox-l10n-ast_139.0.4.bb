# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d36c64fe08e2207bdb16ce368301b8bd"
SRC_URI[sha256sum] = "ad2a91543d253050ad888deaefb862ff201f6c27c1ed6c5bfc1b80ac2f5e73c5"
