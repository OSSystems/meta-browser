# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b9dd5e2a61a2815d4070a3874d51474c"
SRC_URI[sha256sum] = "5b7067375db250a4a607121842456ff45746da2ae2136f89e4ba1752a356fb86"
