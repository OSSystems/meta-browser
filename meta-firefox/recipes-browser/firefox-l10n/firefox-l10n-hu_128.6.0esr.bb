# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b77abfe420dd985b682b0940f218f848"
SRC_URI[sha256sum] = "eeac47db206af35aae4ee864912e910c974792299fa9f48c606260895dd5de84"
