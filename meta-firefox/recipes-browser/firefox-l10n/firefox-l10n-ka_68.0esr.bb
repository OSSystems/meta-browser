# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "475afe37b13692556d94774f02adfabb"
SRC_URI[sha256sum] = "6cc5cf73e774a9487a4e05fbc4ffeedaa2b9135266b09b181b11777bd46b93f1"
