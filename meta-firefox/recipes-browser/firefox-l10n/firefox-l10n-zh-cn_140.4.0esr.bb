# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bbfcbd6d0fada7068f231399db73aedb"
SRC_URI[sha256sum] = "e57d3d4c7083886d2d8008adf7ec21d04a2e453c82edbb91d367f6122dbceb76"
