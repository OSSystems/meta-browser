# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "9b0baba8b8b1ab35c3dd6e93e75a7f3c93f7562190745526b221ac3314f4c326"
