# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "733e24ed33c4a1bc9a2ca3226958eb52047148644f64d50f297a0e4ee18d1734"
