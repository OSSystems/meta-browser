# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "95cf09b0c63e6d2c30dbc8b39782e7bf"
SRC_URI[sha256sum] = "4491532ccdee14793dbb567db28d957877f210995cd569f70a252fdd25b5a4ec"
