# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6fefa42f2b1d0c3dd6241920ffc4a795"
SRC_URI[sha256sum] = "56d67b41de956062d20ad246a13edb7bfc94f66187beed95dbcad08d59bfda46"
