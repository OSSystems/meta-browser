# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "be0f458f596289bb853e0bff31131d3c"
SRC_URI[sha256sum] = "4bfabb06a7fa4a335f073ef19bfff788fb8d386f4a2415664c4a052960831027"
