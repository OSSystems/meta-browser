# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ea3c91c0ae5a358ae4d076dc32a9f73"
SRC_URI[sha256sum] = "0a8a03ad6f86f1db6699bce343a06f02f2540490143b0413c0d2297106106a1a"
