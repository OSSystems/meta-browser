# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9874b50523467161074c6388954a3bb2"
SRC_URI[sha256sum] = "1e0e32f1ae771847942769023d53287c4d4b2a2a5552484890235de6fd29c72b"
