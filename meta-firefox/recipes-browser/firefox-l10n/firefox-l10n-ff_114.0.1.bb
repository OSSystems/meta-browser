# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "81ff5b5613fa817d1088769d983d4c8e"
SRC_URI[sha256sum] = "4d8cf2311092e7919b07fb3638b180a3466f04719d13ec77fd27eba42618da81"
