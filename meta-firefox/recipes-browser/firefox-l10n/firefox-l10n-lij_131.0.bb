# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "978f30b3e5af050f585760e7d3a5ddeb"
SRC_URI[sha256sum] = "a4506ebd7cc78f2f46b2da636fe5c08f2528234ca2c235197bc5f325d86c704c"
