# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cc79c0aa9e044b3be8e3d944d74547a6"
SRC_URI[sha256sum] = "7e3d9db35e7ab3b8bddd9a6ffb947057de9f9528774c1628ce8dfd1e27ccc423"
