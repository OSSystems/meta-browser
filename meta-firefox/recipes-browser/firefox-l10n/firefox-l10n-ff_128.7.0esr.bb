# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e7033d63edabcec94858af9a5cb7d8b3"
SRC_URI[sha256sum] = "17ceec214cdf0346eb62f3e11f2b36202033279b813f3282ce39fccb97dc9798"
