# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cf3da64e9671f97c0ccf4211806371c5"
SRC_URI[sha256sum] = "d143b693ab4e226e45f78efeca16ed4c330eff1769143ea12c49478126b11302"
