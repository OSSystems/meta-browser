# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "76df1f7e380c25ff86a2156790427fd8"
SRC_URI[sha256sum] = "9314d4abdf5b6672ea7307e3faf5919a2cfb340c6c1d15b2686178c5a97a92c2"
