# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "88c0f27cd3e926618251baf75e256041"
SRC_URI[sha256sum] = "75797a495a40a307d6c5d1aa4ef196875a0aa8d1c42422e9808847892a641059"
