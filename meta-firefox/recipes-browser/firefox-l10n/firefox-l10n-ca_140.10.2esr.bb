# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "f683c6fd2bed7e2928bdd3f47fd87ab88a03ca65a2d7666687ea34903e944111"
