# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d6014d77c3986fa81e317dd1cfe5637d"
SRC_URI[sha256sum] = "2a7e6ddcb2ab8db7172e35f0b06951abfea8cd5f415a2d2a85cc9f51cd0cfabc"
