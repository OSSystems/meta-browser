# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9f602df02ea1bdb3f9fedd0bee582de6"
SRC_URI[sha256sum] = "42409e63fefc7515d02e4a8fb9b7b1683a616e05a7a29cf362bf04ef41829b02"
