# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5c4f0eba939854e963803671c36420f5"
SRC_URI[sha256sum] = "0505ef584c69386a1aa59fe57cb4970c483fec3339d87b4a755c19171eef1dc3"
