# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8e8f0ebe9f567922977805b8598c8f3a"
SRC_URI[sha256sum] = "4d70d3a48293c185763880f544dee866472dbaa10e6266cb736666be5d7558e0"
