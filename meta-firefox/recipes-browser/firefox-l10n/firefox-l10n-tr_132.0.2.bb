# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e7817fc024068d34e2f92fd5344dbd9e"
SRC_URI[sha256sum] = "a3e64f8271afd3ee7906f0aa76d8310a2fd0bee4a608c54b3d22cde35b10ba26"
