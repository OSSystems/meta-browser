# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "49e8dcb72dbbff4a6cd35915d6b6c774"
SRC_URI[sha256sum] = "791a38412a82395834aae4a4bbbf82650fb794578ed861165c4d350a9171e703"
