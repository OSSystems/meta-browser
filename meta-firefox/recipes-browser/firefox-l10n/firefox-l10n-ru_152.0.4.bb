# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "91a800387f4ec20de2f8e1d8ba1df045af306e6594a83e3b94682a1de90c7980"
