# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2ae027e1e3e4c63706cdfdd273ec9585"
SRC_URI[sha256sum] = "7aa25322f5674cb81e0f554f108888b750e42781cade7caccad651ead8b8e02e"
