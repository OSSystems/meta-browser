# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ec835b3a8264edc24ba5c37333bbcedd"
SRC_URI[sha256sum] = "9cb2d2d524372e97ec619c5ff5861cff360725a393cc9a3776c20434b5879b41"
