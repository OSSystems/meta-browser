# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c6a0b05dbd0dcd5cede4ad77582b7bab"
SRC_URI[sha256sum] = "951f0648d6a0f62ea042972c124234afec6eb2158bbb65b1e5805c5f1dec267c"
