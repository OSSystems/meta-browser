# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "8b1e1ab1eb8b4d7f789fc543d269c0f0b3cac9e4e84103ba2c15f48d9b321be6"
