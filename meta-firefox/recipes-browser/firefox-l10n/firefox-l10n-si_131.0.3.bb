# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f7756b62e8e9466409a3b365946ad3cc"
SRC_URI[sha256sum] = "5a984c3bf64802829436647054fea67086fa62fe3637d5490fc5357f365c3de1"
