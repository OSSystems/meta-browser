# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9264deca6a622f9ddbc791c2def46f65"
SRC_URI[sha256sum] = "af5ebce0f54db926d6df408f09de71e9fb187476cb33ed11ec6b041f0236015f"
