# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "01d11fb4dc3c61b18bd253e95369fb9b"
SRC_URI[sha256sum] = "a735f12b3d3a922bc95710ee2f87d87b6475123cc9ff871243f943fd7e2e1da8"
