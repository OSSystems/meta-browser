# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "95ac660f735b64336a3d52ab4be479eb"
SRC_URI[sha256sum] = "fd2433b3718358c08c831fd97de7017c28b6b92535662f5acf1bb4ba3a4b50b5"
