# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "00b3afa436bebe82329b629fbe4ef529"
SRC_URI[sha256sum] = "e577668cb8a339b674884dd472453017f24ad94417fd5ffbeb5db4dc599d9d31"
