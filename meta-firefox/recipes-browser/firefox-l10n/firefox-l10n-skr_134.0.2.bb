# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0556f6a7480abeb9085c1e23e4317015"
SRC_URI[sha256sum] = "daa6a8638b5ac023c0754478333c376fbd4aa682401ba3491f53cd20259a1b16"
