# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0fdd18a45b9cb88c4067e19359f1ee86"
SRC_URI[sha256sum] = "8c8ef98a009e448b22b52ddef29e864aad9a82d69a664a48419a43f04fc94363"
