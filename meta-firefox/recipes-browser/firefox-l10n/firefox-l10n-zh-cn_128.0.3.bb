# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "88e1c4e14b8a8b00a135b796ca6ba1ec"
SRC_URI[sha256sum] = "df93e68d2a6aebc5592fd6436a17b716bba58581e262befaca37285bb0aaa079"
