# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "10268c1a1f9870d278470ce9d7d416e3"
SRC_URI[sha256sum] = "b343f0ffaf082fc9dc5e263be5d8eeb64949157ed0ffb01c44ed3ba56d4d00b3"
