# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b7ad70f47d6a0e1eeaf05d4eb1bf5031"
SRC_URI[sha256sum] = "e5caffc8de7441baf3aeb3062debd363b4942e441cd2327f9a4403d1d27ff8a8"
