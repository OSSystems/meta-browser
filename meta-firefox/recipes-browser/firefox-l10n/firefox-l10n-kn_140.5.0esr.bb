# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ee688b8ad941b44b9fbb384836cf1c4d"
SRC_URI[sha256sum] = "d7d51505020e7c8d06b937f33a5c7410972737790d91c3dbc4eeeb227b85a5b1"
