# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "98cbc754f86e896b59f15405d16c9acf"
SRC_URI[sha256sum] = "59de7d24e0e3bcc1fde13b1543c3097c0dc710c4b60664cd4dc56bf794ddc709"
