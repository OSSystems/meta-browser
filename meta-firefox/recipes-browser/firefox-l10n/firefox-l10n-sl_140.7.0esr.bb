# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "90d5a5fab9d297b0136baea0732eb872"
SRC_URI[sha256sum] = "055274094f3d6c8e20a981711cc2079606d211a4bc939b5f2399a4d4f01e4b9a"
