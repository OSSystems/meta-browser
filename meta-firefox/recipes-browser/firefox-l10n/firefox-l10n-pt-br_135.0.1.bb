# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e02c64a89554568aedac047b66b0f63a"
SRC_URI[sha256sum] = "a483ee8592c24a685e80ff0de877ffbb09a03d440fe56cc170bf0cbd0af605ac"
