# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0b6676188b46285a0297be35ac700834"
SRC_URI[sha256sum] = "f5877b10b2d8f31c81718874b5c05fff74a6cc54162d5a6671c331ec6d27b763"
