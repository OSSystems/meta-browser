# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2cbdb82e9dd030c298f9c9d2b9c4bb14"
SRC_URI[sha256sum] = "0e31fae9949be9c56176e67bcbd0e3e62c36c88536a0cb611a67bb7f4708f0ec"
