# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "dda3922bdbbff9e2df606bfdec852e80b5079eb483163fe4c90e9ecff92bc634"
