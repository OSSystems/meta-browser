# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2133bc24e0dfddb917fe577bc2092483"
SRC_URI[sha256sum] = "c9a0361e3223c2126cc6501fd5d3351b974eca88d640a191cb6a0cc6550dae22"
