# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "136666356502049b9285e4b1bc972d11d609322bf92ff6a9dc6d4668c9d6685a"
