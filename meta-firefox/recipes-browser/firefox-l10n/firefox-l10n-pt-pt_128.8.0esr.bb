# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5b5985c25eec43f7be5c8c24c551f3cb"
SRC_URI[sha256sum] = "01ab76b5c0a757dff046704457cc4bbb5f2655d4de58bbed9adea5789ac9f514"
