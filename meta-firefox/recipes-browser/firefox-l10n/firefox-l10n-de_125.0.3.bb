# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9c8a764a6b51378cefaada86b3aec99a"
SRC_URI[sha256sum] = "bab9ea1e9ce041d5d3f5c083c6d138cbab352f1e9446c29643f3fea81d717a98"
