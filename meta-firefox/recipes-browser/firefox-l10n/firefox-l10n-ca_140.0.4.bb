# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "04a5c70a2e55a0f5813874b9165f6e8b"
SRC_URI[sha256sum] = "13c513c1e3e737a17541efbac7cf9bef69fa717742ea449c2470302e43646dfe"
