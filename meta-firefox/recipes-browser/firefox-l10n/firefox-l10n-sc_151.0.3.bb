# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "25c9036448aaf99bdd6499e76daeee12841a31093c65e2ea5d90393d6d72e227"
