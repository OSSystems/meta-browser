# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4758be4ed25aa45be42db9da498ca328"
SRC_URI[sha256sum] = "fdb66db1024bca36f55ec8633d3369cc650380b5b2b98fefe3c349bebe3b2532"
