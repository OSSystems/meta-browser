# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d5067ee6d61193d4bb5dccdb63725ee7"
SRC_URI[sha256sum] = "5d082673e72536c4154c38682316b6608bbe28265fa061c80485d250da3877b0"
