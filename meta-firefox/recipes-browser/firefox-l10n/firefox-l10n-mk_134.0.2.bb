# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "70555b0f426790e9ac84a09fb7a227a0"
SRC_URI[sha256sum] = "35213bf422afaecf161ad9390ac11ff8d4f8ffe8652945d9f08b342d15634b7b"
