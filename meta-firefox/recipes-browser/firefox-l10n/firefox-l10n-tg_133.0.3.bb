# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d7ef69c97394d018f5e1746138673e64"
SRC_URI[sha256sum] = "cbbde1c5987e21313a58db87d6e1d9c82bb7467d2f15eb00e33fb4aeca9a263f"
