# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b9659d04add14de810e553ad34f6c9f4"
SRC_URI[sha256sum] = "b059ec2a54f77efde395e34d572617d9e3645092c0c30699c37d460be2da9d42"
