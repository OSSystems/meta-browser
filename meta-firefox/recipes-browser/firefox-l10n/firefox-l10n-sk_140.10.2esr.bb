# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "30293ff6fd27721d167ad5d1cb176c503a74b7c2b6f8c82b403704a3605aa40b"
