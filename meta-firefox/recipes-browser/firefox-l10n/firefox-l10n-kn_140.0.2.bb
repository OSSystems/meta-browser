# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ae3708bc50953d89af109be9a2f6a52f"
SRC_URI[sha256sum] = "2a8c1960af009cdedd9d2c417de71a037f5398c1744924b3740c49ccb865a356"
