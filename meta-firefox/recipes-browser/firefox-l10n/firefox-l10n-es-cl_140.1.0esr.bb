# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bcaf5cf7f8d8375a6643654e3ad52814"
SRC_URI[sha256sum] = "95ad13cf5d6eb345e0ae40d566a61637a542ae8e045f2b0cc6e2cf754fa34ddb"
