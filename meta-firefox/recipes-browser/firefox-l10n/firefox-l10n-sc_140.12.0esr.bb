# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "39b592c75e62c57b733035757f4dffff198f02dd9a9af8623c443c9da48d922a"
