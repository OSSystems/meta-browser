# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "65ac620cb2ffbb701194f2bcb58b9424"
SRC_URI[sha256sum] = "08892f371502b093704bf12d93b98bcb16b1a29e5510622bd47983bda0a19e63"
