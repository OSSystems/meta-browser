# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "add60e44e1cb323ce7d8d671d145ea2b"
SRC_URI[sha256sum] = "45ed921806141b18c77544cc2b966d4c613b66f31a888b9a5c0a8d08afcf56f6"
