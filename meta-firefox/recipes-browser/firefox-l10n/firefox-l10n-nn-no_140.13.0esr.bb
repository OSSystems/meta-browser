# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "1c9353f40217b5a1d0bcd5365d1a159ff8458d0472613bb92f96f24272b5634a"
