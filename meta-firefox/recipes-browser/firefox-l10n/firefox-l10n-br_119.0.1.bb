# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "385c177f85a0566379ead7b7463aab74"
SRC_URI[sha256sum] = "f24d379208207efca9adae5f60a43a34334214220570c53411d6345a67a758cb"
