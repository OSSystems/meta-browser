# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bce6ac2d8675e57ebac0f13a4954328e"
SRC_URI[sha256sum] = "1b6aa4cb6377e267e37ea09a46c8220f49869bdcd97cecb6b424e9bf5d9d8c32"
