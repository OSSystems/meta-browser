# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "09f7dec8582c6b3902ccb0bc4a29e326"
SRC_URI[sha256sum] = "47e3194532a631acb5ac192d5810aa4c0aae2593fff9c374129509448b28db40"
