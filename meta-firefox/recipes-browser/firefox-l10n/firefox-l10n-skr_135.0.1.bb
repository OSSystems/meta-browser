# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f11f124c43feddfd6e3750996fdbe184"
SRC_URI[sha256sum] = "ef709891a937f2fc00c7fa508c6042f1f04ca9da1afb568b2e323beed5787bab"
