# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b7aa7e45d52dc3c08c24252541a7cbde"
SRC_URI[sha256sum] = "559f9f6b081313dcb70ac035d368196bfbde65dddbf80672376ff9cf854349b1"
