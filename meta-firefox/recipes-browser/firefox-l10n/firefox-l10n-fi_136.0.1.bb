# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8387a6f3572f993636b1c3ac79cb4717"
SRC_URI[sha256sum] = "ce2cd9bd736c6f332b9044df893f31b6134c355acbde0780224a2a4b0e5192e2"
