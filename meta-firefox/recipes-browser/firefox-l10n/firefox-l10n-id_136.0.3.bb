# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8bcbc41b9a1e0f412393fde9066d50ab"
SRC_URI[sha256sum] = "b2834201819f71d3858e34627efc205969285c77104074168dbd3ac04eb88e44"
