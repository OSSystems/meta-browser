# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6657c903a980424f8d736040556e0d8f"
SRC_URI[sha256sum] = "65bf84e6a4ec8f409972ddb7f10e0ebd99c8e1ef8092c4dd98dd93c221252946"
