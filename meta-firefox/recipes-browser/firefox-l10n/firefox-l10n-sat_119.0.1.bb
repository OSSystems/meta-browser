# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "55b18ea2acf6afa4e9ecde69b4885ec4"
SRC_URI[sha256sum] = "362218afaca6465c9a52108e6dcde56333fb1f2b9a67053342931360f26106b4"
