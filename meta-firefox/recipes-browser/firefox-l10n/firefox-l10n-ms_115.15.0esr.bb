# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c5e5de0731afdb1c95d05c269f29e8bf"
SRC_URI[sha256sum] = "d193705ff48756e4ecd37661065bc051ec9853a489f0e7cd64f790d073424cc5"
