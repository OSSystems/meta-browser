# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "839334717ffe8524ab034c832bab18c1"
SRC_URI[sha256sum] = "da394fb008b1e4b82368965ef153fe4285c587bc05d1508abf9538735b2c2268"
