# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "320ac9688b8dd6b97461a153eb68dcee"
SRC_URI[sha256sum] = "3496856ed0144815df8b5e2d0a718355ac675cdd3328f20aeda74832289d7936"
