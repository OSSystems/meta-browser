# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b5a61e420b6e0b5adf44de1b3a0ba88c"
SRC_URI[sha256sum] = "726e758bb667c29d70015c22d90207012ab8327c0657fe32af0bac4a602c2cb3"
