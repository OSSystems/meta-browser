# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4c6b0bf8052d470ec7d53c8fd0b0fc90"
SRC_URI[sha256sum] = "360528981d8dcbc595da900419fd572473fdcbe5805ac9f079c303c277a2de88"
