# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8ab68df5c4559b9137add8330da496ae"
SRC_URI[sha256sum] = "e5709d6eaf1ca2c0804eac5852fae9885d7190b2a6c23f95015df19a84062b2a"
