# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "083ce1b8208413c17fc3bc3da068f8252ee9b10476f43be39966c23089f380ef"
