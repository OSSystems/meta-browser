# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a897bab367fced0e84f3b135f5579bff"
SRC_URI[sha256sum] = "67a0d0ac97dfcbd4863955f9cd871dfc8c7f4944937ce04b9eec60835e22d44e"
