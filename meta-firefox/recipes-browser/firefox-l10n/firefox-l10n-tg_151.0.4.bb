# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ce11039829e11bd67a5b6a015a7d0e1d455f34524af082ec9f7ac757d46cdecc"
