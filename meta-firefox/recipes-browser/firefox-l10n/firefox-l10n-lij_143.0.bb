# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "abd8cf357b620e12f21d85a542b30aff"
SRC_URI[sha256sum] = "2176c2ee2d3e1db6c1945b47ed906bff4415ce92b87048d470cbd63afc73d893"
