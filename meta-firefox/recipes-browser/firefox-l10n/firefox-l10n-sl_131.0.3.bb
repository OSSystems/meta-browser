# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b8c2833b1f32af85756f165965691364"
SRC_URI[sha256sum] = "b560945f4850fa93c4c75f8e24bcced5fed5f7f08fad29d831751e9495673b1e"
