# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "685004b0540b4f8957246417cd53e55d"
SRC_URI[sha256sum] = "12f9b9cfb949de43fde4d43e4b5c61b7d4acecca248bf5f8aed81e4034fc2e31"
