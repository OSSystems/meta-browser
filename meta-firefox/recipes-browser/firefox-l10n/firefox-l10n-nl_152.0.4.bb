# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c14649bd519e166ad362d6c36f12536e5a20f7fec66a0fb9371b30948b04a8b4"
