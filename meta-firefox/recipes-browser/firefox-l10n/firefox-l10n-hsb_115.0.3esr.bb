# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7a3c47aa3f1e87a0ed9788288d869710"
SRC_URI[sha256sum] = "0ac704cdfa58d2ab0047a519e012ea12d747b914a9d436bb948642018b29a764"
