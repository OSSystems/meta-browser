# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3c7c2d98154a6a1087d4e1343df5f493"
SRC_URI[sha256sum] = "349f1cea22fbb3887048b2191e466d119cd2e5012e093628ec28e94baad1ced9"
