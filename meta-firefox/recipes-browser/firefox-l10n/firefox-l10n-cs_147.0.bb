# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d261d2ddb424368295d2e574bf5145d4"
SRC_URI[sha256sum] = "056e9a9704f87ddb506815b9892d2018bf396049c43bc8c9aa3210a6a7fe8b45"
