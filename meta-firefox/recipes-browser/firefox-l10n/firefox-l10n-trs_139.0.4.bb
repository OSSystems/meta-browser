# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f3ac74bef9b29012088ecd84ecf6fd3d"
SRC_URI[sha256sum] = "1448c2363aa44c02c49725b69e072dc3105704cad99ac88e898ffe339eb48477"
