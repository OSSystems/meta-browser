# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f0b0e4dd97c98cd932caf7f266d1db13"
SRC_URI[sha256sum] = "a635b6d325803153f8498718d696c5f9e88a7a452618432a1a5ac1af8cd58e6e"
