# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6ac8cad2b8ffd5dfcc5d4bf6d0c21bbc"
SRC_URI[sha256sum] = "41d3a5b36829217265b4aedee260ae14350c09ded74ab237169db1a67dabe49b"
