# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "01bc92a8047a58066aa19c5e712b7a0e"
SRC_URI[sha256sum] = "bb19eb1fef82623770c68f417073633798f1ecd8a419c40c869a060ea3a81244"
