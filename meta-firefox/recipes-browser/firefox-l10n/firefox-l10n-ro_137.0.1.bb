# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3c7d1e9f4779c09e26c4f1f941c0ac39"
SRC_URI[sha256sum] = "1349df72aea048b0050a427b1583cabf8374ad056c2cb8fdf740606f6caf333a"
