# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bc160a05b598a00f2dbde87a882806ff"
SRC_URI[sha256sum] = "7b1aa35c9325f868c329f5246121c3f5707ab16aa934e69d1e24fa7f765f949f"
