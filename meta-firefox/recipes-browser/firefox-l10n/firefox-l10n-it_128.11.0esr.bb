# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "606ea55628fa7a6562c06ff99ebbfcb3"
SRC_URI[sha256sum] = "7b3d0d1f1f2a51da6317f1ed67c3577522c0c324309e838fe9c7c31dd7db183c"
