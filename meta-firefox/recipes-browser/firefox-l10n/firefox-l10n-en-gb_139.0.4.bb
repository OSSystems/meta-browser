# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "01e74aab5aa7f561a3f6d7c315d984f4"
SRC_URI[sha256sum] = "b81b0f93038fecebf98618d33bc6ee5d9caae2eecdb3578103d98caf689881bc"
