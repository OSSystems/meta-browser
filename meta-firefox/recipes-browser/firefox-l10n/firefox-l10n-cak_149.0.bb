# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d7de1f790d09f4ddc49676fc25a25f63"
SRC_URI[sha256sum] = "87cf23e942d86ac3f1589bff9c89738e975a59865c617589ba60977603c5e14a"
