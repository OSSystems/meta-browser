# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "23723610723cdb169f3abdd44b8e13ed"
SRC_URI[sha256sum] = "e00e8fcfb781d6b9477f1348746f674b38b91e430f184873fd99b86c5cba911f"
