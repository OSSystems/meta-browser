# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7c2732928657332865430630416350a5"
SRC_URI[sha256sum] = "c80c6674ad96da1160dc1d2c7ac9319ac53443a5b9117165abf74793cd63c9a6"
