# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "afc1613a2437fc923c06cead90920b73"
SRC_URI[sha256sum] = "46c2607570d8ad5572a08c8f2de2b7694466a986cb5690604cbed01faa615af0"
