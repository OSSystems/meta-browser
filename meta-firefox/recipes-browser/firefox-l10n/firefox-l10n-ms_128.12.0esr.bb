# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9c9f9107957426d32d275ce301f6d942"
SRC_URI[sha256sum] = "987049b587a25618c84423a6dd868c06c35cb455e0974bee74db77ed8761509f"
