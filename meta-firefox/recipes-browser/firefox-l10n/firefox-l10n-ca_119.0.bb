# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "138956d920546f7fd425265a31db525a"
SRC_URI[sha256sum] = "183b8ba96e4550daf76d00338eb5e0d3fcf5d5069fb3b65ebb7c9241aafe80e9"
