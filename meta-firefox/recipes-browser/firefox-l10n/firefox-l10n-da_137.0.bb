# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "109354e1c8d12a2ae85131358e19452d"
SRC_URI[sha256sum] = "3b8b0a699259535697c7e372e2e915374bfe92dd46d3261afc1857453972ecf1"
