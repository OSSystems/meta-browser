# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e7517a0f453df244a8ef0fbeddc4c5c3"
SRC_URI[sha256sum] = "dd3d1940f84f9ed49e0158c7b08af3abf46858c4e78d8719517dcb2c7fc34712"
