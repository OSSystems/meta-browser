# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c26a9ad309040638ae5be33383cd73615d3bf9f2626692e054e4b069a9f3e493"
