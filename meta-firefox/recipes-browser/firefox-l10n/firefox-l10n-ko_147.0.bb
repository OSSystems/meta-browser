# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2a125bbd9e92f49b3d2ef39f1c152ee8"
SRC_URI[sha256sum] = "2b6a2f68d34f7948ad74b8ecd0e01d67eefc26d7410d881fd44a11d6de03a14d"
