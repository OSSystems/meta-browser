# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9f1ce4d60aa202cd89be26457d665dfe"
SRC_URI[sha256sum] = "7ffaba37f94babdeea4a550f1920bc78a756872f699837d1f9718cbe9fa3622e"
