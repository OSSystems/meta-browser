# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "73116df2fbf59206612ac8fb533cbb5d3bee7d333f37a492cc3138c55b993f7d"
