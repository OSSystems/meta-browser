# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e9d81c9ea1e5e443d66e41d073db747e"
SRC_URI[sha256sum] = "2d037f1e3d7c2d31514d35f45f337f286f32c47b21e1241ba757004d1b98c365"
