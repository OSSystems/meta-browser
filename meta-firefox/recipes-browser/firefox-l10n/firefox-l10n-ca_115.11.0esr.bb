# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9744cad0a71ad5d7dd0a82374207ee39"
SRC_URI[sha256sum] = "8c954f2b1cd225821ae4674d12f3a55be79212b90c5916c0eeab3aa5af52c74f"
