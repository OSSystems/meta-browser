# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cb4a156c9ff055d5496511beed63b8c3"
SRC_URI[sha256sum] = "ac13a1e319f41dc4644d8838507e86a5a0268b13c5a6816cf8adee7d46adf1fc"
