# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c9e64a93b9291378e61fdca4157c3f3f"
SRC_URI[sha256sum] = "326158660133a7ab64f43a9e20418a9ace5e463d72caa37a55a5cc75eaa5b656"
