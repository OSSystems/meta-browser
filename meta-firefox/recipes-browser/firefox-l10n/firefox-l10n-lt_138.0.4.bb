# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dc61f04473bd3e6cf700222fa22a9bc9"
SRC_URI[sha256sum] = "3990ccd734c10a913aa49007222057939565596417e125de06e080861c305a6b"
