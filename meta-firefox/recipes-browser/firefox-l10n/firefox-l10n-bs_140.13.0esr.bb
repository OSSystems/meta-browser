# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "673d9f16bad315cca7d18f5f1ac81601aacc93acb8c7abd59da793f23f3e245d"
