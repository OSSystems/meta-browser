# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "481efd122bb785308e5b39c9a0c79e25"
SRC_URI[sha256sum] = "cc468c49bfd8f38b0f47adfc914b62a0bd791326a893f4593a05af9dbcd093ce"
