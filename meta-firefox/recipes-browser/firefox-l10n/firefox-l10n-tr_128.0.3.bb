# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3e973679a3413c6190f9477debb7499d"
SRC_URI[sha256sum] = "467117b596a98b69ccd3fc98220808c14b787159c63761529a0c5d88b6b8aaf0"
