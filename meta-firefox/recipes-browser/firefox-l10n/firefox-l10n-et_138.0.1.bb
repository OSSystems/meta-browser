# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "73b76378c96802e8743f216a6c431057"
SRC_URI[sha256sum] = "c03b4fbb5ba0bcc9181c611ea38b58ed8efdecdc5d0c850be886058d82838e2b"
