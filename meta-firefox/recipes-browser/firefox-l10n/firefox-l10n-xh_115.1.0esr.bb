# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cbead2415f3308592fd33a191741ffcb"
SRC_URI[sha256sum] = "38565074c6f53096ef87e4c957b202e6aa580d2bdbb8fbbe898b56f22a3123a9"
