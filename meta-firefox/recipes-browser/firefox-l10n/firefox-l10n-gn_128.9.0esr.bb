# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a9037fa98ec9e058db400a5f20a06be2"
SRC_URI[sha256sum] = "9651367fc7267d353e23582814a07cdb9e20565df03cc0f7ae3dc10d23b05cf6"
