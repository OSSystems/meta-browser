# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "35401ab1466cd4231e9e4195e5971352"
SRC_URI[sha256sum] = "72674ed2b21d0556f4ff337fcab39791d680eb58a68128ada9a7c4eb9fc043ec"
