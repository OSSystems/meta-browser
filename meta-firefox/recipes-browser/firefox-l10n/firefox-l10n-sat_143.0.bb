# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f246f41f616eb74aeb76e25b1241b513"
SRC_URI[sha256sum] = "894c33b74dc76aa459791ed5a974f16111b80510bfcf952f8c62b5829886d2c1"
