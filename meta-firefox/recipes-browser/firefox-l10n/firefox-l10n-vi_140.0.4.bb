# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "687949ba5966d622f5b079760b4c9a74"
SRC_URI[sha256sum] = "91694067a9061bf8e2d090d7bc7cce56036503dd0f859ae3293dc028d2df29af"
