# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "84f0d78a24aa68bac39989335e8f4708"
SRC_URI[sha256sum] = "9afd23034d7c50f84a6bcf27a36226e2bf0bbbdb847919ad17a8e5ede8e3c448"
