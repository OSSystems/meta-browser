# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "64eab3919c2bae093daa519e2f927414"
SRC_URI[sha256sum] = "c472aeb8bcfa6602bd8563fcd1b128254e5a37912362840671b3ed1d004a2dba"
