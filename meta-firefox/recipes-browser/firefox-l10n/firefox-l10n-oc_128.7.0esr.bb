# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "93325e41ae518b494af6fecb38aca489"
SRC_URI[sha256sum] = "4e1d13fc5ed5f28db805ed07ac09d712c36a06ea1d6866e92159d87f0ef4a923"
