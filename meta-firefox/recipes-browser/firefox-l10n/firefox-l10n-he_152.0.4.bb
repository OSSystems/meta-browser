# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7318597dcfe4bec84cf6920e22b3f8712d6914816317030873a41308d1e4a43d"
