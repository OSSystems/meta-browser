# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "97e98b9d18c7011c49804015ac807708"
SRC_URI[sha256sum] = "e99cb961b1855a74e02868dd047ca578491373836255c5c924356d9c92827c93"
