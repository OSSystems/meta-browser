# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7246bb23cf49084896bb19b2b0d0f18e"
SRC_URI[sha256sum] = "c15abc95a7a1435357b304c85a35e41eac2f8b50619d870d7220c69495e03673"
