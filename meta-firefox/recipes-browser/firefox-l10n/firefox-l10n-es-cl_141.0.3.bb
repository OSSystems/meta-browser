# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bbad90455b8b64e1b369cd8997c0e3d2"
SRC_URI[sha256sum] = "32a729227707b233ce4b02cf257c1c3e73d3dd8ab56f369529540b3c6997a64b"
