# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "41a5da8dd32419dfa9c5d4076659d56c"
SRC_URI[sha256sum] = "2052018e5f3f181e444cd9825a6fbe7d9ecb9d18d5041a44e7c7310d13bb655e"
