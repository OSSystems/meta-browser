# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a3b3606dc927a873d929efc20393ba71"
SRC_URI[sha256sum] = "7c14015b9ed00262fbd0bc8d8d77df773cca6cbc834450b98609202715feb036"
