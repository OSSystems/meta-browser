# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "fb381227aa73c79209191791bfde64fb2194fa4d75c6c06a2341bf22e3543142"
