# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "190f0d66458b7a6bee59cb9ded8a4101"
SRC_URI[sha256sum] = "0b2f9ff4e917c87badb936f6f6b5b4137ce19f624c1256ded968e05d46e98240"
