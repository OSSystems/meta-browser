# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "27672b4b9b4404caa2c90cad98df709e"
SRC_URI[sha256sum] = "daf2983afd73cadec95ffecb38004761b3a2935604546de7b5cfcf5be34175da"
