# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c96b431ac30d5392110fd367ec7aa5df"
SRC_URI[sha256sum] = "b9aa36fff6ffc56afd51ca91632c9972ee69a2c1824d7b7a1bee722d16b83895"
