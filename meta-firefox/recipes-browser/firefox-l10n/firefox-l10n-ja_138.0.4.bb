# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "485bc35499c62a317bf09f4f5d23240b"
SRC_URI[sha256sum] = "cb303ba922decff5a0cd79b672ffba52a0450fbfa62b9e9c6b285227dbc4a1aa"
