# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "27cb333679a890add00841f8e6f55cf2"
SRC_URI[sha256sum] = "17ffce79cf693e33fccfe3f0502af4f92c0144367c72621f48d599db3249b805"
