# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a2ab1cbede71fd39d33b12af17f11a65"
SRC_URI[sha256sum] = "3f09dd8ab913878ce047a22037da5906ada46b582f21c235b5b603a213879f99"
