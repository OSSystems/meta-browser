# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "431dd44e778755f25c9098e08a47b64b"
SRC_URI[sha256sum] = "70c96240c5531b36a95b4f97429374b4d31bae42866fb7566ef229e6d0263ffb"
