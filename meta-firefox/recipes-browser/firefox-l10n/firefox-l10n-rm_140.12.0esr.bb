# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "b8d47d0bfa6b3e7090883f154ffa36c0619cf25e323c5330c38d9ca62f204ab4"
