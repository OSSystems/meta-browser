# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5e934ccff5832b455305601dfc0e1cf4"
SRC_URI[sha256sum] = "466e06b2bfd919fda544535596abc8212e1af448bc67a03dfc289c9c1e673cd0"
