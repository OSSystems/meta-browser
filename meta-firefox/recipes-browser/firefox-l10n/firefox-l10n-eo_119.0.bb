# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c9573eaf9e4c9dad2f4ab4bae2840c6e"
SRC_URI[sha256sum] = "6540f846360d1b5e897d06b9aa34b47b21411ed8254c6e01d6724c31cddde9c2"
