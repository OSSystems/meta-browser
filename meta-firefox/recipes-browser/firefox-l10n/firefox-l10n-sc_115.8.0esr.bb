# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6940a53721d2074483d06711fc73f052"
SRC_URI[sha256sum] = "3d60b6fb10ca0bfb0c6eb127995bb4781ed6d91a02f6e3d30a40930089864f88"
