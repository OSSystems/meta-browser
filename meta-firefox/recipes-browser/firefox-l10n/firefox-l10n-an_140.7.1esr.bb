# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3dd829df53aea5c15851fa2e47873b6c"
SRC_URI[sha256sum] = "b3dc5d0c63bff3c1aa5d079d1f74d3d36027c8d06384be82aaa1109d9fedd9e0"
