# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d64c3ae5347ab4d8c4b039715ee8a171"
SRC_URI[sha256sum] = "09c406a0365c2b9a29ee1f6f8ac3edc08cc66c8c0ad62b160d1b452f5a9b92cd"
