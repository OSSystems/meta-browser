# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c2240e56ad1ac73c87a903aba107b313"
SRC_URI[sha256sum] = "9ca1b23b03d3fe2e1c6d3f4c0626aae2dc5c69d320d55ec8824fbead29eab65a"
