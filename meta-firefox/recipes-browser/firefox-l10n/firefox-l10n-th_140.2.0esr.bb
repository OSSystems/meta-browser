# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0a98c76541bb95cee4f470d5726d6730"
SRC_URI[sha256sum] = "d2b82112dcf06d10e2c2c8ac45165109c10d1b8009b8e6e9777502c308bdc6c1"
