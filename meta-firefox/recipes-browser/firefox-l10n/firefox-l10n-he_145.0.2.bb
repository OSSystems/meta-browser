# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e9e1391a28219744773e6f530ae880d0"
SRC_URI[sha256sum] = "d2b43f165de24bee49241e8a80f704694fcec0916140d90132f588defbb849e8"
