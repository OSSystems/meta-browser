# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "36e98334efb12ee92f69e9d97253de18"
SRC_URI[sha256sum] = "64ead6f631f44aa653aff3ceb2a5d5000485243c92b13e294809a4582d8c2fa7"
