# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8093a48fb957813ca7ecdcdb2f4e5b0a"
SRC_URI[sha256sum] = "0c92e0b7bdf2a14cad909dd09708e5d222ade40f7ed627d8b7cc3d6f17c5b453"
