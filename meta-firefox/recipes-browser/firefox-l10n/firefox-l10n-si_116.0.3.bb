# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "713a2174c4822e10afdb1a60d629d985"
SRC_URI[sha256sum] = "72034e380c0ca2ae13f0174b4b906c43e5dfd302ecf4105f9d0082dc62ee9a28"
