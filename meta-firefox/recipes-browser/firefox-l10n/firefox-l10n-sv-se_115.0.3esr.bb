# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7276a0437614c57c10aa117d8c346309"
SRC_URI[sha256sum] = "82caf8bc25716aafb5d9a66f5c9a8bd9ba071496af56be8c4ea48ed18f2b1512"
