# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f23dd8d1962159a00182f0d612a67530"
SRC_URI[sha256sum] = "999ff36c98cab585a20b4368e5c21b023f004898918322e536744f6b237cf7bf"
