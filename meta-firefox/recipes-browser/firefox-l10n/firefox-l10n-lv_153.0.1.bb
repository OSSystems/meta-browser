# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "bf2c3a553350a8816e0da4e3bbcf19d44c30a655d33dfd4ae85558fdeab1bf62"
