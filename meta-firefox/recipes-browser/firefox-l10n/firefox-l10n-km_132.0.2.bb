# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7f93f3474d11b482a88d8f03bf956252"
SRC_URI[sha256sum] = "eb0acbbd873af47711ccb50c8d019a6ed5f1e10d10433c35a39afa1fe0014f7b"
