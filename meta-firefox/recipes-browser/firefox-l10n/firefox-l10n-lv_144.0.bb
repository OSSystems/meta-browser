# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9d3db3702f1c643138bc0a76e363281d"
SRC_URI[sha256sum] = "7c444e300893dac7125981e391cba75c68f279f2eaf329e5dfbd1f042eb3e9fb"
