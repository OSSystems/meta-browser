# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5e7e68c052d6fd1d9cdf88b69f3eca2b"
SRC_URI[sha256sum] = "1f2fdf412ff7b7f18f01aa26ce8a5dff7d352183dc183686a4b8e2148f34de58"
