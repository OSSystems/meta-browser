# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1073e51d6600e68a350eee2ecc709b58"
SRC_URI[sha256sum] = "bdb3bfaa587ff1112c3569d109296f8c85f986adffbc1a845e8f560ea5a65215"
