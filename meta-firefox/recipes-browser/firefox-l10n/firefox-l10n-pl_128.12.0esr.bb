# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "755cbe4fb80a5530de1ce5ae76bc185c"
SRC_URI[sha256sum] = "7e5b9d77a3181e2ef5873a75aeee3af690b6d0b6655916f0744231e693ac2210"
