# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4e189395d199f392e9629e465821cb5c"
SRC_URI[sha256sum] = "002dd8bbc20a03f5df3221409da8d0551c273a9b7a93a9c4bfff0fa201fbe632"
