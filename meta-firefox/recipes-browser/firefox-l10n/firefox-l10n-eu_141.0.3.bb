# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7b32ee0c761336237296968705b7834a"
SRC_URI[sha256sum] = "685f5c1f0d60a99ea707df726a91b502c5d223b8bc8521e44c0ca5b229941e1e"
