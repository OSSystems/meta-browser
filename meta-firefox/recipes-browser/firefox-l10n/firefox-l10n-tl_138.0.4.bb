# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4d661746facb9a3ce46231d1c7d01630"
SRC_URI[sha256sum] = "b89f3611d54086ff499fdce4648c0887917bce6f6d84e64031038ea8acef4bd5"
