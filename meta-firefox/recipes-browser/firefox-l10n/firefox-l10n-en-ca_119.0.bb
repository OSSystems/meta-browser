# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "64db03255d023770a2597a2180642f61"
SRC_URI[sha256sum] = "3011de26b6014ad359d071ff486756e703f883a81c1e5a741cd63dd61fa435db"
