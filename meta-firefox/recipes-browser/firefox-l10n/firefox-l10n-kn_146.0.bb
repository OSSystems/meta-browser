# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "320441bc3fd24565a3cab183cc4a2442"
SRC_URI[sha256sum] = "f1a86b99408b633a150091d6e195ce13d3ad7fc92e8f65e1f0a9cae459ca0c6d"
