# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "750f98850594bc3bcfe4a29652efc79a"
SRC_URI[sha256sum] = "3e733ad0c13afe105c77ead34b89c3f21ee284d4a0b0bdfff64942f49d212b2e"
