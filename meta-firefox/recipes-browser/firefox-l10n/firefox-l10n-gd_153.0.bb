# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "635deecfa144418f94a236a16f0d84ecaafdc5703e631e6e30f43070f9ee5910"
