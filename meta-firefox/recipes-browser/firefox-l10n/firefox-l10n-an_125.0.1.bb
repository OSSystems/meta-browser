# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2b84d46d209b4ba541f21597a2c47d6d"
SRC_URI[sha256sum] = "38551e5c5e3508f2ccd09ed89378b5dc2a133e4af3cd4ebe18dfe3acd71aec10"
