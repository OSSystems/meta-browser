# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8b0ec7cb24786a0fc76a2d742851a100"
SRC_URI[sha256sum] = "641bf282474129c7b5da75e6d18a95109ecf9c04fa40ca7bfd499c72b7ebde87"
