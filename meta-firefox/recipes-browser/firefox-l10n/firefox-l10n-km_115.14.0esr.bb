# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a5f5b759b66ad1d571a96fc49e633fd7"
SRC_URI[sha256sum] = "bafc7066fcae8008ce572e03c2cd7077de2c1d0a061970c5c6fbdaf334798918"
