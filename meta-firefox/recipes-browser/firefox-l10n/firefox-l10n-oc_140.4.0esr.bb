# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3689823eca4c60c666f3d4f2283d4cd8"
SRC_URI[sha256sum] = "ee462c32e36dd3af8887a7d47ed192ce9d4a7013f9d0715e6924fd936a272d5d"
