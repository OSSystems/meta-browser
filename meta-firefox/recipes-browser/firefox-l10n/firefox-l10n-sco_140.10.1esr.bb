# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "91d252c3e1acab90d945dce51bc566d7163603a9d0445dfe5315e477c60a858b"
