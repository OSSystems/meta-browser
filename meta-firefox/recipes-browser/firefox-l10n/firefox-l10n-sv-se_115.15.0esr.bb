# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e0a981541a56ef1c203e65e71a05e19f"
SRC_URI[sha256sum] = "fe95cfcc389cb9616aa193e58780c739d7529e886ece44f9d910fe0fed10f111"
