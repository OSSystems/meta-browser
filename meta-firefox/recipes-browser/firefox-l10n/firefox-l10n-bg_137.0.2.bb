# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "04b39a772a637472bb4e860a5ff49a0b"
SRC_URI[sha256sum] = "4143a19ba26e4bf11083d07db31914d09c2e2e985b19ad66bd34cde989b438e8"
