# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2eb2e84c9d45fabd23623cb7cc045c94"
SRC_URI[sha256sum] = "a5ad58b74a6ba0867a3e533b049cdaf790b117f9848a2730435c771a6d8c7ed9"
