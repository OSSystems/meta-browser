# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f478962f866ed1078b6e53c401c845b3"
SRC_URI[sha256sum] = "a9ca9642bb4eaaa4c170e38ffbf6a3fff1f6662cbc62792e593f855931766aeb"
