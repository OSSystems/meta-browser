# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1ddef9bcd6ca16cafbe2d9fdad520999"
SRC_URI[sha256sum] = "2ab2a0f0c7b48fdda94acbe198676a7634e9c5a9dfc6c0bfdfea065432a1925f"
