# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "be498d3cbf186e273d431422b71c947f"
SRC_URI[sha256sum] = "0dfc571ef0ec7b3aa12b9150e17f6f16e6f0affcf5b08b265786ede7f0f4d842"
