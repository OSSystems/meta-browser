# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "779ed9449da8bd22d895bee6ad24be0d"
SRC_URI[sha256sum] = "c51d748cf08f4ff9169b02e248e0868e3186d9bde73306d19aa9b140d4530620"
