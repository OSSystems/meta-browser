# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d1fdeae89f95eaea43a808547401d22b"
SRC_URI[sha256sum] = "9fa6fb5d767f22257ea1384821196bb2b4005e2b31240789857058010a2baaf7"
