# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "78300c6a8491945736f9b4c10f6534a2"
SRC_URI[sha256sum] = "76f6bee044e7e625fda1fb62acef8fc9d34b9e1db453c934d13f4198ea2ec7ce"
