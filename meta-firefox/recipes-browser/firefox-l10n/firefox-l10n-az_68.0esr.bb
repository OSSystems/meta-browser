# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a6805fea639ff9be0fe27ab6b12813e0"
SRC_URI[sha256sum] = "32caf16c1ae5c191618a6488ccd9cdeca6b5328a72a3d056972e15def439f102"
