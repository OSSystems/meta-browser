# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "81ad27eaf583d2484f983a9df2644808"
SRC_URI[sha256sum] = "414b62e72d443cc0a0905a938fefd7fdcdf7967253240fc80a5b3d8f247b65cb"
