# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "73bf8a1019ad5997a73ad25148961527"
SRC_URI[sha256sum] = "9d111898179a20bd397b876fd1cd07773c6f09aa91a7f9fd512077f9539b049a"
