# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a40facc38764b2636637818b40a451d2"
SRC_URI[sha256sum] = "90b8e8bb00cd7010c9c639c2313922a2f1021e3d8b0bc11835200f426fd24cfe"
