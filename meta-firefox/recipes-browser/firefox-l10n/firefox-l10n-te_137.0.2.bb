# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a5de8b9f9c7c26e72d4f15061e28a143"
SRC_URI[sha256sum] = "1af57c6b5329cbffea740d5c7c99515251d9f964687683de2af49d77fb5349b5"
