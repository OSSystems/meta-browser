# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "84016f05a54a2c19525bfb7fa7d7c07c"
SRC_URI[sha256sum] = "c63b042645329eca6388c35de671e777a898e71b07df3e5233c21283d8d02a64"
