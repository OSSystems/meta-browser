# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2bbb3061353c20621eb959388fca844c"
SRC_URI[sha256sum] = "e20beca837a86a4107fad025a5ff960326608523bd092d51f54c981ac5f201c6"
