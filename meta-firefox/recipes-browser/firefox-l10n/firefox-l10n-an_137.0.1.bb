# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "091583b2a905098db3600fb0f3c9027d"
SRC_URI[sha256sum] = "795ead8edf6ecfaf7ba94450b960ad4df17e1b771067f87de2033a0b58f2122b"
