# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0eaf9a7e2b736265621eb7fe5268da5a"
SRC_URI[sha256sum] = "5d5460219b3d410fc3dbfe5b30bf363eaf3f0427f8389a51dad1d5fd36231370"
