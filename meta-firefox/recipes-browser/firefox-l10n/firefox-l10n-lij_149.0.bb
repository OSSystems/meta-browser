# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7b264f9f66ef9c1de33dd23183f5a7b0"
SRC_URI[sha256sum] = "b226abf44ef08ac34581f7bec72f060ec9e6e69ba114b2650788dadb19581708"
