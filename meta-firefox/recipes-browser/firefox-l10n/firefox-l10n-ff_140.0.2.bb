# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dc9ffa09afe85980cab6fab93f7cfea0"
SRC_URI[sha256sum] = "23d9c4023789c45e6cb9ff87a76a5f699a9f6e0c09d1a4249f723177f9e401a1"
