# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f595abfffe6ca9ea574d6900f73c6cbf"
SRC_URI[sha256sum] = "57b0413b805b76ce763529d3d9882bbaccccebc1c711a6c32348b9435c6fb1db"
