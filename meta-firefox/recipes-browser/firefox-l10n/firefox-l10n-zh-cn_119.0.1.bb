# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "810b8f5a8c384a0dc44579443caaafe9"
SRC_URI[sha256sum] = "958cf13e22f27b95333a9e316875c2df1aebf52f12909588d1fa27a32c17af64"
