# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d83e3c838ec8e80de85aaa62355c5ae46a3774f22faba3cf893feba61229f01c"
