# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fe67ef585622854cc50922bc59e67021"
SRC_URI[sha256sum] = "6946d2d2bfb5fbd49f58f805d2e26119ede5684db9697e60a34b701c20bca435"
