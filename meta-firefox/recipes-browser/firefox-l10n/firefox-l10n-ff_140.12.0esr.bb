# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e80be9dba334b3ecb15e09424ad47da7d95a63dd44a23471779478b37a3cadb7"
