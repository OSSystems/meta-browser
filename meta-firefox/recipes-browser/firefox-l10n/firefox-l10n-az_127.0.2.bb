# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f5b34fddfdd94d24e5855fa73e24c474"
SRC_URI[sha256sum] = "32c67b5b369f45e1cfdfd7e4d743a346ebb590b6438f5277ad89a6f77b7d947d"
