# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "48a66be1d8623cdf32aafa5941a19dec"
SRC_URI[sha256sum] = "875c60c35a5d49c55e10d4ad794ef1bbd7e43d936df1a8f4013a6e4a4adba000"
