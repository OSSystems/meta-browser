# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c60e765e4a950eb96c928960a3f43205"
SRC_URI[sha256sum] = "10bbbbc39bebaf53ed987ce10380764f93a76820a5f1dc71fff28802a0522711"
