# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "a2ce9c832ec58438c1c2526c7c31a0b8c6359cc58a3f89e1ca08bdc03e077162"
