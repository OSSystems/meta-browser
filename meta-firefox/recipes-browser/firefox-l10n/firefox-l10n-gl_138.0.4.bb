# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "670d789233ddf6252e16c47e9d19a297"
SRC_URI[sha256sum] = "cff1166f5988b0b52964cb9023733f33d4bac2b48fac1b62fc05aa378b5e6eca"
