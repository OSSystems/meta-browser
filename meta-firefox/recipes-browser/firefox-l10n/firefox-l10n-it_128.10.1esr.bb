# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d584e91f3d3ef334cb5f46cd38ee4d93"
SRC_URI[sha256sum] = "831fc3d578e0d016e37ae9323ca58c9ff132d356fa7e777420cbf9c43a13c8ae"
