# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "928d7ff7d59f9745281380420350a62d"
SRC_URI[sha256sum] = "bcc6ca195133ba9652a9c0299715b3dbad89369d95d031272c5fb48e016e3c9f"
