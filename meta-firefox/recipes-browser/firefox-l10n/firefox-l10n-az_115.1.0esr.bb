# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b0679eec1ca025c05cfd9b03f9a505df"
SRC_URI[sha256sum] = "c30c1e916b2961cf2d02bea368ea32510268dfeebc3d95dba6a526bbde53ac25"
