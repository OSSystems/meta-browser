# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8715d235770f4e6675ff9337c61036f7"
SRC_URI[sha256sum] = "27ebd4c6d16d38fca5ff0429625a19ac1955452d559f471ffe8dda70a31bbf61"
