# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f5c32be2db872dda6b7784d5f45e86aa"
SRC_URI[sha256sum] = "8252a23e06c950104fe8ccfef0a3bb3c4064e24152355275bb8ea083c12bc134"
