# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c76eb29dfdc5b7289a34f988bbe00381"
SRC_URI[sha256sum] = "acef56364e8bb61525b61da459974ed15d4c6f6a73e6df6c1e26d7397c7c676f"
