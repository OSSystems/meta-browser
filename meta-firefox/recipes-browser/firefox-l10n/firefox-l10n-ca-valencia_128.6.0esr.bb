# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "172c9df90a4cb3ab8f2d85bb2c7e0671"
SRC_URI[sha256sum] = "d0f390ad290c2c5e967d2ee189c31e0c8b6fe21b35bf29b657d8491cd207f1ff"
