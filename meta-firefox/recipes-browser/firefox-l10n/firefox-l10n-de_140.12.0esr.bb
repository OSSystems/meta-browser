# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "583d6939fd28f6f21d25d2ca8904c4a5d540b4fd434a6e7ed555a13c81b8e131"
