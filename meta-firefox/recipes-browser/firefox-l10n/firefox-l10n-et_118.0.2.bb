# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2fe2ed17629f042fb05b8f06d0e5a182"
SRC_URI[sha256sum] = "f0308b28aa793a6dca8dce48ea787b3d85030daedc7215ba2ae04ce2bcc02335"
