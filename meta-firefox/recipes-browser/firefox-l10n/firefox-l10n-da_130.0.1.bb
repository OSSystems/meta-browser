# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1737ecc10ff00e96ee45b24b701de27b"
SRC_URI[sha256sum] = "34a33f24b29a488602279c687cfd31f5c12ac3eee44a4b1546b12bba6681c679"
