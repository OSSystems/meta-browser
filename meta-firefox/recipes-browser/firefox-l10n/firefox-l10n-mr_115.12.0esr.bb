# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4909882b99391d0f1c5019dc6584f225"
SRC_URI[sha256sum] = "5b2ed9d2f9aec1121203988e098ca5dfa2ddf1476df64a654392fd23e422ac51"
