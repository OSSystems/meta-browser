# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7664f771a3b436edb9b64059a9de0a96"
SRC_URI[sha256sum] = "98ad10c35505d8a2b00a9a7cc04c37120f60953a1927e05b391e99713d50cf16"
