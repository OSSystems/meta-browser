# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4ed47fd61178532db298342421ade5c7"
SRC_URI[sha256sum] = "00101a10daf15fb072cd4f5daaa198940eb87b2421ec7bd7f7f323ab898fd5a5"
