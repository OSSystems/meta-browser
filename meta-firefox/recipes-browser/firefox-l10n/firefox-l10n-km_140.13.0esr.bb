# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "572d06b7b36b32149e155a2a6158e2218523880eac55dc4e20337d5e0706dec4"
