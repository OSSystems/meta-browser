# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8a13e119ddbdd0c833624754331702ab"
SRC_URI[sha256sum] = "4828c7bf325286809ad3fdde28767c78d88ded0bb597fe757fa8fc9dbed7f7ce"
