# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0bfe7bc3ccb9f7b12079d9f64687c113"
SRC_URI[sha256sum] = "9a1b926844dcd68815ec9502406b1dcec5eaf13ad1708835ce9b7739a90d1b4e"
