# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f1219a2afccbc4e182c6fb2f4cdc535d"
SRC_URI[sha256sum] = "d78469cb961b3fe805e528dc4bfa3f37d942f41fbc1c8920b51ea9f343394981"
