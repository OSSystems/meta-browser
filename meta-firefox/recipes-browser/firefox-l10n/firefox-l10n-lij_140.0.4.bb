# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3abef817b3bcdc6000b23f22a75cd244"
SRC_URI[sha256sum] = "6c44456e40f6ee27faf3af93089c4252778f45f999d087062e8fd792e2efa5e7"
