# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e543dcfb7778a73579416e40dff56e5c5773ac48f5403126d5e7f3761ffe74fa"
