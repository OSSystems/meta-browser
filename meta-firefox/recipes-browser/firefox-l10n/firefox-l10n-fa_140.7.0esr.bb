# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0ff7e587dd881cb753ae22d86c9d5854"
SRC_URI[sha256sum] = "791cf84290825f902469b32df8f3b7f3fcb478897c0333ba9c38bce8c8b12679"
