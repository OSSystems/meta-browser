# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "631d13bb48d1e896d4e7c0a886ff8d42"
SRC_URI[sha256sum] = "9dd3fc75184b5297be56a716bab98cc907b5a5657e27053381f198cbe7859123"
