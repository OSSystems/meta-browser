# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "824f5274d9c02bd823c34ffa7c4cbebd"
SRC_URI[sha256sum] = "5bcad823acd9ba11049d8e31f120340054a92d71bcaae50fe0991f78e3d704af"
