# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a131251494319dfb3e861d40261f619c"
SRC_URI[sha256sum] = "b6c0350515018e4c4f28195ca34642bb98c6d2287c4283f02d325e8541a304bc"
