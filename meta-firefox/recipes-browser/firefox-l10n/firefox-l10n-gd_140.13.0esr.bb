# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d29cbff40c6537fb5c961d20a9d8abf92cdb89497591c7cdf2f6e293996ce01c"
