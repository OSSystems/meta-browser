# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "13edc429e21bba617b7f205f4db13d43"
SRC_URI[sha256sum] = "82cd9cb8087e2bc3d56c39395513424fed6e45fc09d8ed6ba42abcd3498bc0b0"
