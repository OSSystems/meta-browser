# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bf540a00aa2f642ac63e7fbf34b1ad3e"
SRC_URI[sha256sum] = "77e9cf03343eac111b06a5b9797a48152f3f78229b77cbdebc239bb747b34d65"
