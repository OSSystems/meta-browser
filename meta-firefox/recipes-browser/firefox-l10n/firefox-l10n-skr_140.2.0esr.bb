# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "071d6cbbc1ffa78d603f07c5883162fc"
SRC_URI[sha256sum] = "62d83a3725670789e9f6a585bfc24adf5c47e20bed7458edfbeafc15f05cb080"
