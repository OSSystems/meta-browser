# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "283f92227ec6ac416b6bf87439392ec8"
SRC_URI[sha256sum] = "602ddf39c568b56de5e493d547e53e1a81ea5b64b9ef0b1ea9f42d6ea1542c9a"
