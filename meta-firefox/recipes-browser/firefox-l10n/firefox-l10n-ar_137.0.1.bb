# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8dea4fd2b85cee7e786a9dff48f4d159"
SRC_URI[sha256sum] = "41d81ab377bab7b3119d26029030883fa00f69d3813c9f6e1523436bc2bac50f"
