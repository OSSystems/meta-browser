# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dd5a0aeb91ed0dc6b65cdd53d069f27a"
SRC_URI[sha256sum] = "3e17743efe806abdb24ac9674ab082d5777772c4a0267960f19fb62ea3d6de88"
