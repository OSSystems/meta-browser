# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eaf843b55e2991f98ee7b09cbfe78c9c"
SRC_URI[sha256sum] = "71ef67c381d8698dcb635fe8e6e8ff07939f3d5350cd47766c5f62781492c1c5"
