# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "97fe205f03eb641dfa9e41fd7043579176142bc8ff3435bc8b0a0ad722d22cdb"
