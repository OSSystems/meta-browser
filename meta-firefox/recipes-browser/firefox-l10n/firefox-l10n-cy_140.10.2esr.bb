# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "f021d2aec00572f32cd83566f0287487996fb9042fbfce20b23e4cedf0471c77"
