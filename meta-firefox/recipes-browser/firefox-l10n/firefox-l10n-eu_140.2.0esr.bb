# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f58207749dba43bdaa96b3c1df101a91"
SRC_URI[sha256sum] = "3cf42d556eb3d4483e19420e99417154a07707b7ef4e41a3f22f01c3a0b3a487"
