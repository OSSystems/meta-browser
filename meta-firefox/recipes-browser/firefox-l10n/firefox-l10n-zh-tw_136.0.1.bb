# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "da8bb2c646d146d706e1c9e526943e8b"
SRC_URI[sha256sum] = "9140ac44836f3270379e987b604214ceb400a46de0f149af02f00e65b432fe4e"
