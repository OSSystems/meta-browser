# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4d63234af8d04e5c9d768ca75e87f262"
SRC_URI[sha256sum] = "ce75149c67cd4d00b0869d81f3995e62cf6698918d92a3c38fed75cc7122f046"
