# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "95d6577643b73c2cdc4c2063140a5b3c"
SRC_URI[sha256sum] = "719d38b0c05a11911c07ce02b4adb808576b4e45d384244c54f8842329c46553"
