# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "5de8e8779eece019368cb5790023f4278b81d9138e387e9e9177c803439f5ad2"
