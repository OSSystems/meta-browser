# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "af7567f96d4eba0e1315f4ae7a9e13c1"
SRC_URI[sha256sum] = "d221605f16f07ce399d2f9dd10edb6ea6c3e13884e8703af69e21a0060d784e4"
