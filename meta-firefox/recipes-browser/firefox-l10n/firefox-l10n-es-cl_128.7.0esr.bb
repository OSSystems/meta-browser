# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f3758622588bebbb096e952064490c18"
SRC_URI[sha256sum] = "9a981b9437fb4a38c953aa35808984a5cc1f14d9200b6d8deb67416b3fab2ea5"
