# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d005b08ee4c000ef050b13b591f60549972a8c9203f0a038f6fb70548c794026"
