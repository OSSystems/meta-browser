# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1589c29aca24ae6b277252983a2e07ec"
SRC_URI[sha256sum] = "798b4334ed372ea5723c50bdc2dacb8940db98589071e4bf05dc9b2605572103"
