# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f9442dbf2c3ca5f46d34e6156abd4ef6"
SRC_URI[sha256sum] = "2188b945117553f1860c7c8fb41e000c5ec40e29705adb466af80363ce4a0bcd"
