# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "793085524690708cf8c14fdae53ba311f0f28ce73045e0dbd1740c165c762680"
