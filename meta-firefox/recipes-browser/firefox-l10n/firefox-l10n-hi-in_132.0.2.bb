# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "152bdaae9dbebf10ba51e0de69e3a447"
SRC_URI[sha256sum] = "083470189cc1818ba029c585ed831e34f7a761bb072e48d6ac3c2e06109243ff"
