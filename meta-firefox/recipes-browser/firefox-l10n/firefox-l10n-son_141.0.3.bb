# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a7b5bd10ab6e369e6dc3a7aba16ab235"
SRC_URI[sha256sum] = "a4a174c21993a00f99c41738a15ab16e59e9cfea926e68ff6002c519fa5689f4"
