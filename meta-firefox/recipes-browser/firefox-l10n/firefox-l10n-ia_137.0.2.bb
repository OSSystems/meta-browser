# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f6f5cc7b27207353d8aea2d3ed1810f1"
SRC_URI[sha256sum] = "5accff53b77ebc603649285b5068e2ea6af7c8bf405a0b6395c06ba64f2ff7ef"
