# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c080ae93245010f027d061370b6c1ef7"
SRC_URI[sha256sum] = "c26a82c2c1e2a603461a5bca703fb71832b8861a5f69a909c5bd584b6af8f480"
