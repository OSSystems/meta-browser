# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2d1e3af405abbf15d0691f8145b734c9"
SRC_URI[sha256sum] = "6d8dae091a1cf15ffaf7067b08c74b9e962ad7dca6981449ed74270782f0bd0b"
