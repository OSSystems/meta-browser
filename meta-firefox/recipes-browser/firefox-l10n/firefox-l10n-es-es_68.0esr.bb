# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "89913ab4bf0e02a6044e432cb53dfd30"
SRC_URI[sha256sum] = "df818676999fdf9c447ce660e94b01d9fa1981e3d9cc13484ec2c0a8b53f9924"
