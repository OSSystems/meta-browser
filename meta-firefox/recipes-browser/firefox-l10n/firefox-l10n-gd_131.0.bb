# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ce45eb96e389d8acc0f2dbb19fa834cb"
SRC_URI[sha256sum] = "741387917ccb0d3601e5ad5055b1452e900ffdf5453b85c4ed56d40dc21e8904"
