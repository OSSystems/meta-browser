# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cdf062949d36cffc5bc7176cee7e4108"
SRC_URI[sha256sum] = "7c34c6dfce8e45841c5927c6f87ca2849583251c0fa265f4815fd7a53bfd19d6"
