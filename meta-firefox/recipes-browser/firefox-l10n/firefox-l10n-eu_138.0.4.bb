# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cecb6055cafb76168077dadf1807fd9a"
SRC_URI[sha256sum] = "b42358376e72fbc006fc52ccbd8d41b7e4e62acd18d64d4caf0902c0687704f0"
