# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4d5471009fb2974f3a36d35c5cdabcca"
SRC_URI[sha256sum] = "fc28c3ba632c3634a6e0eccbe7bf3076550b765555f10b9a7a4b2501b15e31aa"
