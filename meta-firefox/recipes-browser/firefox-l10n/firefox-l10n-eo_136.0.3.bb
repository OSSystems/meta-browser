# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8033b0cb0145eda29cc5947771f5b6d4"
SRC_URI[sha256sum] = "1f56071b5f86d9f77e0e5ae5be9987f29f73a154934643c06ca651748533033b"
