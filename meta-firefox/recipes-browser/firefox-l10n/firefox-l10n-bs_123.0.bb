# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a40be8be994c5167230466ca354bff4d"
SRC_URI[sha256sum] = "d40497e45e1638681b2969b786378bb09a901407298b0c505cb30db586a164ff"
