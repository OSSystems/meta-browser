# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5d08ddeb07f45f554329a54bbc1cdb27"
SRC_URI[sha256sum] = "ebc90e068d5b119cb09a808e71d77238b709dabd57e7982ab4b491378024ccd6"
