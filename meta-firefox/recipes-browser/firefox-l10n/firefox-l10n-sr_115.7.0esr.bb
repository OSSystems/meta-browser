# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "930a2329331fe752ddcb3a105454ab4d"
SRC_URI[sha256sum] = "57e1f19ded3f10a7e24959eb533f15286f711eedf8ff4ff761f3ed0344966076"
