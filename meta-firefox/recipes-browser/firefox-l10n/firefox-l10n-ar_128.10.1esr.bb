# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c6182d8b6a60f4e2765c5138161b494f"
SRC_URI[sha256sum] = "ad4d0d2f0defd145a17726c76cb165a3641f447d0e9f8e955d07f59cf35db3c0"
