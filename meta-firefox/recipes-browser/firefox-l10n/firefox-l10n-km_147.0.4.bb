# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dadeae38f01bbdc379cd201c7119e014"
SRC_URI[sha256sum] = "e5389e5115411513d1b6a742ab008d7a231dd079c5fed7c8845fafe476876390"
