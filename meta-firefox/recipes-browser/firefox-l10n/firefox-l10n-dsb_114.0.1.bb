# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3af22a43ab946a1495e895353d14bcc6"
SRC_URI[sha256sum] = "70559fa56bfe4028c8dadd11bcf759d49ebef574299cc52a32858583a656bac7"
