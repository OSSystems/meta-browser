# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7ddb805bae90675d645c9f34f0f271e2"
SRC_URI[sha256sum] = "72b43929da71d3d8028c4721e61bc19006caa4ae287dfc02f7959ab948f7e767"
