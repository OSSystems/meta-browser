# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e47cef026f8e16a44645d84f537b0e3c"
SRC_URI[sha256sum] = "a2c422aec5d6b1f66461d53a7b2942275c08bd51d3d8c5dd2eee5821acc514e7"
