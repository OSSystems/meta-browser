# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "03e2791ad9175ea3a4ae426cbbb39071"
SRC_URI[sha256sum] = "4d321488bfbbb275ddc3ccdeb7fb7c6eac9584b00d4831a9da59e3fb6316e3ac"
