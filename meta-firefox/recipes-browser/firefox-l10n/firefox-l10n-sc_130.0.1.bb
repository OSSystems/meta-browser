# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d3c4e9abbec76627c0dc13c53557f78d"
SRC_URI[sha256sum] = "6652d4a106fed3052dc2cd9b586282cdee259becb620c26ff2ca7af073cce813"
