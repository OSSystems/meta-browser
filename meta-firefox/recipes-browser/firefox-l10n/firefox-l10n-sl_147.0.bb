# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ae79421fb5b6bd47486c07a9fe079ecb"
SRC_URI[sha256sum] = "6533ce9d7c66e1fb221f32b431614015fc33728047c49388b46915c13eba7881"
