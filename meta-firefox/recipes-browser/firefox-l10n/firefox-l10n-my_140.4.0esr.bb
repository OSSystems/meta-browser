# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eab7266368bb0b274484feb52f8fca6f"
SRC_URI[sha256sum] = "b1793f5c851e7a9eba66c4ab569a98625da5469de9ced4e3e33fa8ec173b1bb6"
