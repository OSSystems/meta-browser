# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "64b7ffa5cfc30d888ea5dc60ff8d5f02"
SRC_URI[sha256sum] = "e339ebf8c49b8655c421dfaa8340fa2a7f71888500e1be0ed3a7a546b267bfe4"
