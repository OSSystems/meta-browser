# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f73a535b0fa9a050ca35806b32c0d7c2"
SRC_URI[sha256sum] = "ccdaf46bb06060fbaf8462f597cfa76321190ffdd6b38c49ab66d3b6b85f459b"
