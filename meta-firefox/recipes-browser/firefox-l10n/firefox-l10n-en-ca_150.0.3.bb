# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c99add9518f628969e36c8c4c56618a01c2e6e0a5fb6b65ff57c185526e7571e"
