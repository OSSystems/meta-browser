# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1ed56967511b5500b8d419f3ded9bc36"
SRC_URI[sha256sum] = "79a80bd54aee9024a78be45cb3644d33cf9eadffe0fb56a9f85e402b001d040c"
