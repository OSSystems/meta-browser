# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3e65eeb81e8f377ecf85be4cf4e4e6ea"
SRC_URI[sha256sum] = "9863f2ccc7b917d4967e8473ecf05d68bbd9fb2712b598cc632e65092ae72496"
