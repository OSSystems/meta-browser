# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ec53bbc23188977b4844fb8bdeb2ed81"
SRC_URI[sha256sum] = "4eaa1a097d2cecfe8c0e9b37e97214eaada8fa9b648036efab073d09555b1796"
