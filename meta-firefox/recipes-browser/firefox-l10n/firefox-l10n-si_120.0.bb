# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9026275f9eef870cf376ef52225ff0eb"
SRC_URI[sha256sum] = "91ee57d09e9189f3ba042ef0190eeb827b75ff0968e190687c6a4c139bbe3908"
