# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f493509cb2fb92e496fa37f3ed91ca87"
SRC_URI[sha256sum] = "dd295c50062fcda33dd9a3b1d1721c05a9c03c79d46f87dc3818a1dd4ee86e62"
