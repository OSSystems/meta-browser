# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a8b0846224191b2335e86cc3f79ce00a"
SRC_URI[sha256sum] = "1ac9ceee4167d46f2357e22dc2c3272f4cf3a754fa55a2a7453282a8bb3d2cd8"
