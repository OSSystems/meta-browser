# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "431d9fbb311a15bf9cf1eafad56dfeb4"
SRC_URI[sha256sum] = "fbd21f45b9d59f2f046327ac1aed1e03602d22681003f8a0e8955e91b4d2c8dd"
