# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1b15a582416e6b4a74cc037117b8b344"
SRC_URI[sha256sum] = "bc57fa268719c408e56551492021a587619130a062152ee645c68580d55e6fc0"
