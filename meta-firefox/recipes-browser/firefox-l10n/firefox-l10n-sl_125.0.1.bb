# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "682101ca74d2d192ed9758d892eb8c7a"
SRC_URI[sha256sum] = "1cd94d405a7c3ee5f7258afc967f6f44c32032b538e9e457a106f4f65aa0567b"
