# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a59058ab60cf412d893480878d8f479c"
SRC_URI[sha256sum] = "2c3ccc7e006f7b08f50ed417d97077b09d996b9c240a4d0ee8ac7d7294df58bf"
