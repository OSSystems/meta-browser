# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "49bd1e558cea8728399b0643fe6002dd"
SRC_URI[sha256sum] = "004ed24ac5ef010a5901e6fd909c52a6695b7ca18f148d9acb6748dcfd88764e"
