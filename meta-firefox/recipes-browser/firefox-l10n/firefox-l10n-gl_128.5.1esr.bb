# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b34f0cf4deed3a6138a4e3838f8dd03f"
SRC_URI[sha256sum] = "8f668f562bc15c3b04f962a783ccea92fd90603f4ff3069bd695ec57a0088336"
