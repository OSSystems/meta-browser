# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "19ff3a58538528f67a529944bb5fd1c0"
SRC_URI[sha256sum] = "28bf341878d738ec5ea2484ee5794cc87703f8b278db6e6ecdf9ed6e2c07ca27"
