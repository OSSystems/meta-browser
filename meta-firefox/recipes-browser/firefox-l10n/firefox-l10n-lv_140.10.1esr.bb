# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7541fc45c058b1d4ea722f591cdffee3dd8ead39b918fc7545bfaf3f6ee840e9"
