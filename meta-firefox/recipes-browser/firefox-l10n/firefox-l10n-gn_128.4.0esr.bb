# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a354b08ec4e6d4fb7e37017b1e1b16bd"
SRC_URI[sha256sum] = "c83b492eaeefd8799f8d937273161e970f6a5943cbe25263d6f5001780eb48b9"
