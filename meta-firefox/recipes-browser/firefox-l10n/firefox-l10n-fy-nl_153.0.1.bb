# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "f35891afd103102ad0afc8645a0ab0c6b9bd25b0e30dec0c018b0d66628acda3"
