# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2a6d1efcfff0301ed876dba792535a00"
SRC_URI[sha256sum] = "1e23cb4cf00249edd26c428212f56a22dcb0b6c364a60979dfb1aca251d33b24"
