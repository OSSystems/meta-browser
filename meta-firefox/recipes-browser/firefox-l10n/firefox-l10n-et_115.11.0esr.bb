# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "552e179fdcf73214e2c564e3a361e1bb"
SRC_URI[sha256sum] = "7c56cb1d196b3fecbf5b197e266f6729c17df0fb642f8e5bbd1fcb7449d16f96"
