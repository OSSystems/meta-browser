# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6bda9c7589eee6d530eb9e8ebf91c8a3"
SRC_URI[sha256sum] = "5f040fae72bc68c83a4a589dadc65af02e8c8c4cc028c2e2b34d5dedb031dde2"
