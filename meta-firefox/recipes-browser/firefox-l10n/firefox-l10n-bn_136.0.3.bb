# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "06d61d307c794a22a21bc9b3bec3bf17"
SRC_URI[sha256sum] = "716b56cbba4631e6fdb847b8198ecb3e41b615b33b356a85462dd9cd47b86ba0"
