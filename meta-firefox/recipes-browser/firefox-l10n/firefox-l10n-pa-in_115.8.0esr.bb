# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8b9083a224f34df48072a5827e134b3a"
SRC_URI[sha256sum] = "53f06159df471ac6fcefdbb3905b3d9746378d881712a5fcdb2dbbdefcc6a5be"
