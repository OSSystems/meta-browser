# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3cb245dc2b3c3542dc7b9a6ea80e8e8d"
SRC_URI[sha256sum] = "2be9b28c401c0a1454c6f7afb3c12d23a149ad3441acfd5468b5e30666d24cc2"
