# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5f2cd1ecf456a196afe50adb3f69fdae"
SRC_URI[sha256sum] = "a3d0c82deca15f2120dd138d7b6d39b3ab17f49970b6f75a9204b6853879e29c"
