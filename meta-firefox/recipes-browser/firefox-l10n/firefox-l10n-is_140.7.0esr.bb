# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e64c094ceb33f1ab57246b46cfd202b4"
SRC_URI[sha256sum] = "e9b93f7eada2cd4506dee00cd45c29aa5e7b7d5e7cdec5b7b0717ef49198487a"
