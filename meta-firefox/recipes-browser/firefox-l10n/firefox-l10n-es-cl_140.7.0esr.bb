# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7a46e22e4b55ce2797f7f03227702c72"
SRC_URI[sha256sum] = "0f29b846ef78d0c1c8df40c7d9574455f553816d9e38bb65949c63f865da8b27"
