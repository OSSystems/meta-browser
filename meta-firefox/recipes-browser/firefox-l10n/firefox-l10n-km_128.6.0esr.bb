# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "018632fc9681832e4ef0247af42db488"
SRC_URI[sha256sum] = "40555a19c1c5a8a23954a079a2b0d85486ed3bd64b5809cd8b81351c51931271"
