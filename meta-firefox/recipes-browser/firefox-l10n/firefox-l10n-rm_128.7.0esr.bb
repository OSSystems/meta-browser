# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0fd325e4d99bf3c6c59677ea1969a93c"
SRC_URI[sha256sum] = "aa10cd588323ae943b9c5d77c409e3e4f409a8ebf48f86cb4e760d78d325dc13"
