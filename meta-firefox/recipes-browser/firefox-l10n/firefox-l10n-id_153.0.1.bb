# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2fe001111f4576d716c4504048b109aab780eb1e6c64426b5bad2dba56635989"
