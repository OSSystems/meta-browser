# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "83926338af466883917e8687050fcefa"
SRC_URI[sha256sum] = "27fd0ed49f0ef773c306c9ca9311b62db8d2099f88549669ba6be22c255e6cfc"
