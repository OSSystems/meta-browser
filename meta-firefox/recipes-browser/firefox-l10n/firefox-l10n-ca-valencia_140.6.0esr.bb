# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3230fa06b0cf7410f8d59aafd4216a23"
SRC_URI[sha256sum] = "e71fa954dcf042fe78c3702392ed840aca9474552b7a809f3047430d33a2b83b"
