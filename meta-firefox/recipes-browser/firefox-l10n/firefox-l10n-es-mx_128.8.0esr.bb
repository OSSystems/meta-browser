# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fb3bd17bd6e688dd161b9a0a0a341ccb"
SRC_URI[sha256sum] = "caa9167cd2db9f27fa5e8b91319ce1304f1cfa834ae2f8b324c31b2e949ef111"
