# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3400fb146478023081ab32fa195a2ab7"
SRC_URI[sha256sum] = "af6ba32c8911016bb79e5a3d3aea3fbc0353dd78a4178e0e19c6ad15f77f0871"
