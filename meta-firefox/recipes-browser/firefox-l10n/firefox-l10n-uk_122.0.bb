# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f2d5119578edea53394e42e037cce9d9"
SRC_URI[sha256sum] = "494615dabdcb60aca1617f743b1641a9744afb706e99e36ab2f54278a8d559ba"
