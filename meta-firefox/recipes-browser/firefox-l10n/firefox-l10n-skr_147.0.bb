# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dc1309c2d844547bf23ff4484b739714"
SRC_URI[sha256sum] = "7e8c17faf67ebf57af305052546875a34a9c33bbc3e99cf8e3141df223297bdf"
