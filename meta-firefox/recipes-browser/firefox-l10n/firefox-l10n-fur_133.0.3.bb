# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4d5677cf82dd3796c485c4d09ce83a7f"
SRC_URI[sha256sum] = "c78cf106875d325012d5b4e42cc4d69a6a5528343dd24213f159ca003ee5df89"
