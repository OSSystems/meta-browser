# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b30758f09ce0f8bb187dfd9bc7830a66"
SRC_URI[sha256sum] = "03363c2eb95aa9960c51ba6023ced0e74b72e0ac83ac846e66955f461c964460"
