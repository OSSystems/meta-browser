# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ab5cad738a8ce0b7b79079d371b8d678"
SRC_URI[sha256sum] = "0e13b754810a999f6856254f686078db4a2927a6401f67b6f843abe9d44bbf05"
