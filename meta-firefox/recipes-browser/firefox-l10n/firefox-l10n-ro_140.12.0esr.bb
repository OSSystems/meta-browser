# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "bbf2dfd742191c2fd333cf292468aed7017ef251a8a7d9a0f2a01c1037368d79"
