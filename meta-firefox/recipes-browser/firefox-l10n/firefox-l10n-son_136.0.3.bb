# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "133423648a82dc167fca0c66b2e47de4"
SRC_URI[sha256sum] = "4e10248cae74ecd27f30c1f719a358fbefe63ce06f7ffe22f5210995d2d40800"
