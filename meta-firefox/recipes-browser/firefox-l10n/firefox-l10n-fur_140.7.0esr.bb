# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "505bd4635d651327cfa88929647c1ad3"
SRC_URI[sha256sum] = "5fcae3b8fd3a176d833bffec836a69d9f6ed426774e3153a27c6634122b8fc40"
