# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "69a4855fca28fcd6bd503899ecd7a5a1"
SRC_URI[sha256sum] = "d374b69e0fedd1dcbf3e055a16763125e3406438298cc0e2734a9a55e93fdff7"
