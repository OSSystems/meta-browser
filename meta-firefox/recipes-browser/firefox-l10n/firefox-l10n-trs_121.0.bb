# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2e2b3fb801ba2683b1a9826ca349ee76"
SRC_URI[sha256sum] = "d01e1b1a4e4a8a89441c317b87236aa7b15c266497c6a860a20462ebf8d0e855"
