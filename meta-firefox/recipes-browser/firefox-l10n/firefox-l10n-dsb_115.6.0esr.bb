# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "64c5fb3b46686e02de921b25eccf6c51"
SRC_URI[sha256sum] = "d939ed47b2191ae2c02f014c841504892d1c4073d8e6261a6ac997bff056c995"
