# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ffa7106805265e15a55b0710c47ca1f8"
SRC_URI[sha256sum] = "a4e4251eb8538319b1317bde2164c65fa9c8d1a0a31c99df67cc037b045f8c3b"
