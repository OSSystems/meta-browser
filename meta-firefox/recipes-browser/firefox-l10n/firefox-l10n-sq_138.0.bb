# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d57595b8c7c4195b2291ec9342af94d5"
SRC_URI[sha256sum] = "cf7cf15b3fe8204ce63c068f4fef0112a507d01e09c518b06e2e4b0750c76436"
