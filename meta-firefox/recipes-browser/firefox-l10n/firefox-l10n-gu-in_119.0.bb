# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b8b2ed94577c2073f37c19c4907cb2c1"
SRC_URI[sha256sum] = "35ca7baf4299dbb24aa2943770adf3841a84fcdad5477eb16f2fea0fb98ded38"
