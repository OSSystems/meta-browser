# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "06949a04e980d86d090b0f668499e649"
SRC_URI[sha256sum] = "13a96ca35b2f2ea42741a7f753418cc9af8984a1074c0a0fa5c4c7c906fc3a56"
