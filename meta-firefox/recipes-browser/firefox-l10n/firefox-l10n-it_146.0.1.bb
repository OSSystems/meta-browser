# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9bbd995ed65d0a8775edb40a66ba29c4"
SRC_URI[sha256sum] = "84bb87b87d15f4a9dec8daf2efa41d684540d93e7b7c3e1fe6075ad141fda799"
