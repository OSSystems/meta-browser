# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c7ac3626c0c15353dec8ff5fe7ccb2fa"
SRC_URI[sha256sum] = "d2647718c06dd097dca68c3e7f7866b37ddbf3ae9ac20ba2985bb89b3065235b"
