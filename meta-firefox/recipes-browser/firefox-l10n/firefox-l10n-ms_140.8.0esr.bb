# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d9295416aac6081905027b7269b054ed"
SRC_URI[sha256sum] = "4013a30d35796ea21ca2527d7fbddccd9b93387c5ddce10b5bd5b86e8140a585"
