# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "547793a0db6a1f79b5a45d289d7eb83a"
SRC_URI[sha256sum] = "c031f7e473a5797df2899db0b8bba6fba65a1767fba3aedc496dbfa5ecc10d84"
