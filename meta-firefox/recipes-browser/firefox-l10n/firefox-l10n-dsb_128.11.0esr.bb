# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9a335576987adddb3a2560344c6f798d"
SRC_URI[sha256sum] = "a7308a87df373f15a1418323bc3a8899d172ba5bd326b7cdc3fbe6c1b8c08396"
