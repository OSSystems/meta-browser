# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f6380e4f98940e3da025afd2c8c690b9"
SRC_URI[sha256sum] = "33f4d7824309163bbf5845e337af7832f2a1a84162c2661d0d2873bdfa11c355"
