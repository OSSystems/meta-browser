# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1d48aecc2be8bea50a334a37781cd02a"
SRC_URI[sha256sum] = "33191d615f271836a31167dd3fd537630c4e088b0593c9adc0756326a335f43c"
