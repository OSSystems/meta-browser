# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "32105b2acd16bb704cff31871983186b"
SRC_URI[sha256sum] = "bb81dc382539d5bd835629f750f4833cfd6b9597be351bf8df83ff0bf75dc785"
