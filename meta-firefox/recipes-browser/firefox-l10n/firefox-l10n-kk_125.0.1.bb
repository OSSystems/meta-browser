# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0cc9e13a062fbe36e532e66c533b1167"
SRC_URI[sha256sum] = "5d59417baa5787dfe68309b78fe7e30fbdd012be2fc1567c928eba6a1bf6986d"
