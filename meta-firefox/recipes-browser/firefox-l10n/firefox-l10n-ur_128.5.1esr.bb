# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "54608166c23bb93dd705b47461212041"
SRC_URI[sha256sum] = "9d2fb596c854c42f1771faa4c32941880d0959a51951f402807d41cabece456c"
