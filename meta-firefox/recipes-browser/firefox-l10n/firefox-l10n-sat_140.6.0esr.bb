# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9df0745af0c08cdb799d9095875d61f1"
SRC_URI[sha256sum] = "f5d3f0aa963151f03905a795ee63ee6ebb3f68d0e863beb6dbb7261e1614098b"
