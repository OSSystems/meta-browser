# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "745d8c88d381e60c0e5173c1ccac1127"
SRC_URI[sha256sum] = "b1374c070e1623eb855fc0dd13ff401605d83b86c6e01f82350f24d7bcfdfd27"
