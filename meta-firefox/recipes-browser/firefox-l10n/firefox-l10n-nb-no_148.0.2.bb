# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6060d91f901926e229744136d717c781"
SRC_URI[sha256sum] = "2459dfc242033020b1c7ceffa1e0f6c3841bd4bd137467c0b2ad263d35073fd8"
