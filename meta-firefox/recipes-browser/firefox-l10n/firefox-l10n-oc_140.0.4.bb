# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b0e4dc2c5a95390eafd1162071b86de9"
SRC_URI[sha256sum] = "de4e1a03cc6204d0859cb329a6edb5ee034359e4bcd5049f51a1c2a6446cd768"
