# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "595b6e5f0841f8efb4b5e8e2ff6ad6ff"
SRC_URI[sha256sum] = "a7ce5009a7904a05a4fcf11fafb5998fccb393682315dad5fc991a031a0319df"
