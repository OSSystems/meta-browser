# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8d149ddc7ee10151a9870698a08c11a5"
SRC_URI[sha256sum] = "1141d87e7fa024e93f24d612136f1eb7c263ff94f74c560a3474f279c4f5181e"
