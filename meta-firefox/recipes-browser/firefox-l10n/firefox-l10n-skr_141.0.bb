# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "63b62f6d13f4b625dbe6a850f1a69afc"
SRC_URI[sha256sum] = "257560383ee59832110a4b350ca894d4701522ae9bc231c7018460fc68f9e767"
