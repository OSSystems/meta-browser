# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8ab0084d3233851299af6da639b1ca9d"
SRC_URI[sha256sum] = "871d83bde802247015f5d93861fe7e8e4a9cfca3d0f44037c945cde607fae5b1"
