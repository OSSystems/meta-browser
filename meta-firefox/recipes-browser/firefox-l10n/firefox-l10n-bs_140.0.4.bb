# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bab3329b2fde454523b6838c3c88efb3"
SRC_URI[sha256sum] = "fac051722cafc85a7d9918b5cb892e92357ace3bfb5bfe681290379c29cc84a9"
