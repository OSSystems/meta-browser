# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "a39bb339b0abeac2355a66c27df23cf53b3303c599ed665119129e17812f80dd"
