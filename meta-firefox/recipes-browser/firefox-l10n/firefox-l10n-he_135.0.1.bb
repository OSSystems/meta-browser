# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5aefd60ba041a6a63835a14a4aa3ebae"
SRC_URI[sha256sum] = "d5cfeb6bffdbe34a15999c5c748b2d412a5602866209e927ac2157817c324873"
