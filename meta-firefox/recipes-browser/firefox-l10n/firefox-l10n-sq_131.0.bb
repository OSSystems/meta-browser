# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f6c4198a9a2101e2207b41a2cceef4c5"
SRC_URI[sha256sum] = "f1cc3e2e1c126ab613e06409c74c2ea5763de6f30484122cd9a1d5abd7de8498"
