# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "851185a6059524794678bcf9f4273eeb"
SRC_URI[sha256sum] = "6772df26ce7a3dc3317cb3bfb76e65cf46a865fe437e9597f974e754cf7a90e7"
