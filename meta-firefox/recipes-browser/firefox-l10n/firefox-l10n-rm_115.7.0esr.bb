# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4ef15c378568dad96d78677ecb0ea112"
SRC_URI[sha256sum] = "15f3805bf93f69448400e1b6adef6080f652138a2afbff468ee3af2ee073ee67"
