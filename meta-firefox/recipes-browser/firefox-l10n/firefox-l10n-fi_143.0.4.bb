# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c4892554954f3a36778fa9075c7faf20"
SRC_URI[sha256sum] = "ffbde97422f5682f3eacefcef23957e28c539d16fdeba71a2f872cb0ad7f8339"
