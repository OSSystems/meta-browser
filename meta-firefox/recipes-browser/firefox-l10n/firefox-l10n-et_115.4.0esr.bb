# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f3caa2ff8f63d8af14ecfe09fae7fbdb"
SRC_URI[sha256sum] = "8d6fd902de91df589865b1edfb2e03e6ebbe5edb1a4b8635b2662e4376dc7696"
