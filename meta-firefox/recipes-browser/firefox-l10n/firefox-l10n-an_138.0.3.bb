# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c97b53d4b474cfb3cd24f0bf75321f0e"
SRC_URI[sha256sum] = "5234b860e9daf1d5c818a087f7dcfdf95d96c5783a31e4a07f1aaa88755a29a7"
