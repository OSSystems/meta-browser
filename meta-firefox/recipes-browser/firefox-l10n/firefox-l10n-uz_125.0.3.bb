# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "00cdfaad61ae63c0ca7b4c61b2b5fc31"
SRC_URI[sha256sum] = "3a39ca9805b90a522cd24d545376fb50d80cf0da4f808f6fe16e4ab050db2e24"
