# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d279cda33df32857fa0bcf1b53d6bcff"
SRC_URI[sha256sum] = "d11e68e85ca0f271ffb6306f1c5bb742c4c0d42267f17a22682f8276168ca959"
