# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c07bedf371764c1982fbd266cc33e32b"
SRC_URI[sha256sum] = "49c015358936b4bec0c9fc69003133596b8ca69ac9f39a1640de4c53f01acd7e"
