# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0dbe912a3f4230a62dc93ced460df01d"
SRC_URI[sha256sum] = "386d5bacaa370a22d503c4c42cac5b1bbbbdf6226a18718780a425450769f120"
