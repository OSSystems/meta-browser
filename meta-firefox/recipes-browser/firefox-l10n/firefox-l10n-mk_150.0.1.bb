# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "99459b9fe97af41cb3757ad267f619f04b037004b6372a9a3db5564df3f15ba3"
