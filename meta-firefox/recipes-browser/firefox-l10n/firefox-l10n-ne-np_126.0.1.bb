# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fe8bf7ea0a329f1e94afea1553ea3a20"
SRC_URI[sha256sum] = "d105bc8644f348752615b9262e73a25e1b0ed7c97892282c25e8dcdd01ef4529"
