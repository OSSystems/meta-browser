# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7d4e203f342ba5aad4b427d1be685456"
SRC_URI[sha256sum] = "8fb6f9caacfcac9627d68fde60fa399132850c197bd27375350b7186a4588804"
