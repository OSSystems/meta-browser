# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8680185b80e4fa040e19d84cd11aed30"
SRC_URI[sha256sum] = "636c104a33eb3b48de344e44691b7fc1443581f0711a5257d4f3952d396b2fb9"
