# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e50c2f1521172a1a5794d5c06fd34dfd"
SRC_URI[sha256sum] = "b1f8f4f1babf8e3e11417c89c7f0a71bc1a19a7aec149102a29e82c6e8b1f6a7"
