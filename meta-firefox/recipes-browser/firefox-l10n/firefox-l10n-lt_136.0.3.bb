# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b4b4b6655c0550b8c33f92457db8e438"
SRC_URI[sha256sum] = "adf26a5e35b89689efe7aa7c3d14028c60c8d1c9fdad98cda9dc1791c6a76e70"
