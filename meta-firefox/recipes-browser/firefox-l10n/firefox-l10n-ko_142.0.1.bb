# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8ea9db932fc8e867435b92efad787861"
SRC_URI[sha256sum] = "98953b4c7573dd208184aa236cc69758d891e041b6ba64bb59e01a10b54608ec"
