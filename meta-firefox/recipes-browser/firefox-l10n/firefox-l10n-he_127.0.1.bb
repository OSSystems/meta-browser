# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7e942436a024b4cea89edf82afafa403"
SRC_URI[sha256sum] = "6e38b5f6519cde4bd4e447f839a7bfbd5a4a6ea910abc0fe6e9e1cc818761d49"
