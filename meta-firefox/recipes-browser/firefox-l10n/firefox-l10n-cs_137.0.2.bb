# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a715972eda0a9536d8851f57398dca84"
SRC_URI[sha256sum] = "5bfedfb9d74c00baf4dc7d150142cd28e9af09d52e68c43519f1fc7ea6ce071c"
