# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "abfa4a5f2dd607a63f8f9d28757533b4"
SRC_URI[sha256sum] = "c0b33d8aaf1c34f2f2510ce66ff3cc85fbee9d0ee139d76f1730d74c47dc2832"
