# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f897f31ce7adf73ea71d350b67577ec1"
SRC_URI[sha256sum] = "3206221fcbf7a32f4bc686ead9192b880926808a2f82dbd517bbb5cdb958f0d2"
