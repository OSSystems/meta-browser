# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "158b3b1585c97b876f66c8844e3b412a"
SRC_URI[sha256sum] = "afad4cee3974cc6a48dc3e821f9ee78b1e5b9dfe713210fb4cf1604842ab36b7"
