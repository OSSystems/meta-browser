# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2bdc42322638e91b018e4f2aaecac920"
SRC_URI[sha256sum] = "52b41fdd637507623312b4ec8b7d748cf42e617ba25cbd446db3474b484d12d9"
