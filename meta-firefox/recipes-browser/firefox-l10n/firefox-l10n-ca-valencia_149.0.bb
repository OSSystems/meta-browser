# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5affb48c43a9702c4b0b5f02eba8fc93"
SRC_URI[sha256sum] = "4b79a8aef300ffa99381e196832a969e1c1b14173dcc29a9e533deb63e8544d8"
