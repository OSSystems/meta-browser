# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8a7333f6461ea0510664ff98d9ffa2cb"
SRC_URI[sha256sum] = "9d99889e18b4465395c8c9816647bd6a9c3f294579218ab95db15fd5e2ac6876"
