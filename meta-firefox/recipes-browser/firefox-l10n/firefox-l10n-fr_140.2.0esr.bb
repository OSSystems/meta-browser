# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d6166cebebadad1ea535e8fdb777f5d0"
SRC_URI[sha256sum] = "b97952d580866eade80e67bc0c0eced51d1b72a7912a4b7b35276318bc857004"
