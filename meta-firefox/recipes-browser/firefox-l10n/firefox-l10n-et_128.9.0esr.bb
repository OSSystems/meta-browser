# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d6fc05ca172f759064702aedbc01e733"
SRC_URI[sha256sum] = "a6a96e0ce68bee2143d3219aa6fef64b0845f7da3858d26aac8e4748a270993a"
