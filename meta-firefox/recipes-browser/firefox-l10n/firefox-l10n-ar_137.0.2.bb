# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ceda9bffdd385e2b398bb4503a799ee4"
SRC_URI[sha256sum] = "46bd64e3ad2dc42714934b6202596210d7a5b779766385583f77ae7955d41e4c"
