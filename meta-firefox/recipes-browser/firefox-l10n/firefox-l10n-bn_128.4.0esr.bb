# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fb8bfcc517c09e484628d886865f2118"
SRC_URI[sha256sum] = "4f5d5e5d7f2f5ec06fa32c2249232ed3e90bd5a960d1855f47f3db9b8f3dff9e"
