# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bf0ccb6e747669a8dcfd2718ac6050c6"
SRC_URI[sha256sum] = "25d867fbf68d55f09e290f375cb0241f8ae0d5407e2ec7c2b4e541672e23d41b"
