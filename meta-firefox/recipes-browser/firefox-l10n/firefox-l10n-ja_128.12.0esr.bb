# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "35f9de36798e54b5b5bfeb76d1a7c6fe"
SRC_URI[sha256sum] = "a1d3a00cf0ec63dc59f455e8f2dd849f2e7be68b3ce46802444daee82fe96acf"
