# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f03baa3f9b538af74960e237f101d504"
SRC_URI[sha256sum] = "6db6c0fe06f88177da0dd2dc14b2d44beba1cec25dcbcd8ed6bd7f4efd3765ef"
