# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "79e251f47737bae9567ab4bd4d10ca60"
SRC_URI[sha256sum] = "9a32351452289ee2cd53b58644333e19bf4e412cd6f2adaacb23457e184cbefe"
