# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "50a76d195d769d47b8784cd323d1debd"
SRC_URI[sha256sum] = "6688049446f4857b61b15d6029ba53f99e17b92d023bc5783812687e288b477b"
