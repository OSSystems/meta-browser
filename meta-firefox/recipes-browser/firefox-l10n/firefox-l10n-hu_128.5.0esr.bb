# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "279c99d1165999d0a3abffd9ef45410d"
SRC_URI[sha256sum] = "aeafcfc410a3bc1cf1abbf0ce2a14523d8160810453747c3f0334d710802e2e6"
