# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8145478f4a2726b7542dfaf7a2c5cf3a"
SRC_URI[sha256sum] = "bfb6e5ac46e33b798bdf4c84973c9bee22131830c48f48784d688a4cf376aadb"
