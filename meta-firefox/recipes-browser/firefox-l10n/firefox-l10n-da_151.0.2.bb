# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "1571914ec9c6683af309b4fb7b4c614ca4e9404b96e3ae3a4ed87661d99f9dd0"
