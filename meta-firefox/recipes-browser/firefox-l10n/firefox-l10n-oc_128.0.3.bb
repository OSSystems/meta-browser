# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c989d5f3f8afd0d8f27cd73545173640"
SRC_URI[sha256sum] = "9cbcbc6a4f81502033feae40bda182993b1bd965afe50d56f67705d87d315fe6"
