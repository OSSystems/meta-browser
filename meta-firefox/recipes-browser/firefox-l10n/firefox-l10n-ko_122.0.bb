# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "baedf3523e51ba1d97c315e7ba2e5747"
SRC_URI[sha256sum] = "7619e97fd56791bcc67ac64396fdb4ef46193cacffbe342f164bc835e4af7851"
