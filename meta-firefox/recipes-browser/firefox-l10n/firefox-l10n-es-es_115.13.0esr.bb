# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "37440234fa54373a05b8bf9f3dca0d9d"
SRC_URI[sha256sum] = "508a9d25205eec118a6ee386fd4c484eac0b4310869aa1ddba86c4d7c7c0c6f1"
