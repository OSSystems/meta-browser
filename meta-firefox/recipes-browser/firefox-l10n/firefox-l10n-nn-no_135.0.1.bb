# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "746c4ce4a066b79e793c83d739fb4f77"
SRC_URI[sha256sum] = "98abf74721e9ee3a872315037e34c64315b0095a2a97ed799cdfdc5858e35cde"
