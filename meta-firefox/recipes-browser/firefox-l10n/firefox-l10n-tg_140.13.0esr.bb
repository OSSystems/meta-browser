# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "925f6d58374fd9bbd16f7b95a05a9525bff6e37eddbdd5867d733c644434e4a5"
