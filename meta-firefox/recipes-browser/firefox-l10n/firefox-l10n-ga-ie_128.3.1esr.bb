# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8efb6dbff0fcb558e41694eca68b24fc"
SRC_URI[sha256sum] = "86c5856bc66e3a942009c5c5de0210b7cfaa23b635a415d559fe4ead607403dd"
