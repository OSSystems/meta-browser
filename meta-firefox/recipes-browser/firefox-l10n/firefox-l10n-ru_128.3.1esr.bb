# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4311087f4c9f9c39cd2261bda8674f0b"
SRC_URI[sha256sum] = "1dcad355804f769f9ae97030dd784e2d623363ab45bcc96742b87cdb2297d058"
