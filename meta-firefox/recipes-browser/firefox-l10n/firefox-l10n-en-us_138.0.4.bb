# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "25b755354d4c903227a35e1015853de1"
SRC_URI[sha256sum] = "8bb93a3b8fb573ca8ad0e59e9b8ce26199d8ce5bb122c520c8dec0fb079b2669"
