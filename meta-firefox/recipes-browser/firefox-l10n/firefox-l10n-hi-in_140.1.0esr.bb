# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2bff70319a94db44a68f751601006b95"
SRC_URI[sha256sum] = "1fa134a62fdfdae5f9cac0d8f01b8e442b42deccae4304bab6b3ec8639d734cb"
