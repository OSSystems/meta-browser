# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e1bd4c7a6683325a659bfa3088ea6c05"
SRC_URI[sha256sum] = "65ac4d0ac7e73f5455ca299cd783f33c469d24d5782d74924337c7da7ee16f4e"
