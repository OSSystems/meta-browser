# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "cbb31fab1f18fca5ba681cf502b0fc3a8fc54db0f45e62099f0037d4e68d0564"
