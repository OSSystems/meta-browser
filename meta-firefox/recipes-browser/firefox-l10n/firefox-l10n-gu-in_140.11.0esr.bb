# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2fee663b892a89d2bb5c81aa40be3868df595ce5d347657cf1ee2f156cd8dd9b"
