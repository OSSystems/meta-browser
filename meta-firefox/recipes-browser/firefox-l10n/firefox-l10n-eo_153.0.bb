# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "eda9b8ecf56d295779f4cc786bdc05bb94464f8054df3863fd49eff6370588f6"
