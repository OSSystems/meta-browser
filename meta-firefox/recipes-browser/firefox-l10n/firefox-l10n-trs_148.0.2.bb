# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1ec6daebeb8d168b5a62e61a8b604bb6"
SRC_URI[sha256sum] = "576b5252974ad187165f9ff70efd6b1ddc922fee7b9c1addd5f0ea7c3196c89f"
