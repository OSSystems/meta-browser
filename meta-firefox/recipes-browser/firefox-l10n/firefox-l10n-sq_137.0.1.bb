# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bdb76ac60d5271e0c752eb4c612f57f1"
SRC_URI[sha256sum] = "2fe9d9289d5c65b1a84d965be216098753a73ebf14cbf26248c596df5e197d7e"
