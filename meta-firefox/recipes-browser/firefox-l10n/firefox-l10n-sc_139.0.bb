# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c711781b4c985d20a2a4abc0b9d78088"
SRC_URI[sha256sum] = "4c0b7a82fa711ecd86c3f74b4f253d2f19cafde01e045f4e9f5cf5b027ab091b"
