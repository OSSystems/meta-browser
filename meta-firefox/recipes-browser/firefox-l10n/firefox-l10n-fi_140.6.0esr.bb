# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5ad0bf10bd7e8108a25b9c20abdf1d91"
SRC_URI[sha256sum] = "0afaabbe9b4f95dc6683629dab324ca3fd3196fea3bb84d810e0771e8e994df3"
