# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c3166a900add235441684fdc721994f8"
SRC_URI[sha256sum] = "b3a186421ce2d74f9d470d85a30ce7f1fe285f2f60d5810821f3d62df0794deb"
