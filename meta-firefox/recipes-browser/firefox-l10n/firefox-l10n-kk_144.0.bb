# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "904d6e14bbf2a2e4bae7629a10011d69"
SRC_URI[sha256sum] = "84ef2448f5a6c32d4bed85d7bae0a28a6a17cd0a1a9e220bba7c1e5a3ce28f65"
