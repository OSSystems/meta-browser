# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "95bf44157141afa2b5402e310114222b"
SRC_URI[sha256sum] = "644f53df5cadfd1296aa7331407f996a1533413c161f884135ed029317f246f5"
