# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d7a70f96253e0b48ace6d3033a5833f6"
SRC_URI[sha256sum] = "b94111b6383c01cd7527cf079cd524238bbd6709cdee0a3ff636e2a21bf91809"
