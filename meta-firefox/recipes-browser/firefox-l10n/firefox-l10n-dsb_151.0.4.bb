# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "078c8a4c4bfe577f95c8a98b5c19c29765b7704a98e45d05b3219cc559c2a601"
