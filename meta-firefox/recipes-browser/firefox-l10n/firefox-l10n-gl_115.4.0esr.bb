# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5f72149fd572ac04bf32760f993fbffa"
SRC_URI[sha256sum] = "c705341194890d1112b7b25566c97b7e14a64d05f6a351f305f4d3bfe1bbfe9e"
