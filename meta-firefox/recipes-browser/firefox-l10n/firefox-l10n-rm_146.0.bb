# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "219cc44dda635b817ea333b1304c40bf"
SRC_URI[sha256sum] = "3df1a3be0b85f6ba66f9c08067be19d1882477dcad33981f6a8740d7d25c29cc"
