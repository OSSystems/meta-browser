# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fa7ba7888ba65426563832f0d0d20aee"
SRC_URI[sha256sum] = "80bb1fb6e60f87f2b4f45732d0df48123d0e0671d5cc5273ec2da655cd874b4e"
