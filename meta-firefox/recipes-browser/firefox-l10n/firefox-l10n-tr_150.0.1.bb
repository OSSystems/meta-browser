# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "9da093a75cb30cfd40921c2c6b1f101e0d1478c219640cb2bae4a338831d01b6"
