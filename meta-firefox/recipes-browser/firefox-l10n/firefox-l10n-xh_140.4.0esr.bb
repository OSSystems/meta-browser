# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2c248a9fb2b4d54bbb9a05432dcd7cb5"
SRC_URI[sha256sum] = "b154272514b680fc69553e54af3455d2ee417023dd369f2f87b39677b245760d"
