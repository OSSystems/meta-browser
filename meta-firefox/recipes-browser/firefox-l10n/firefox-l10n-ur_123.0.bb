# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "05b311cca39db9d5d196102fad31cc36"
SRC_URI[sha256sum] = "a122e7d2c3032a13071657d9e282dad588e7a1674a168fe810646a4453f5dea0"
