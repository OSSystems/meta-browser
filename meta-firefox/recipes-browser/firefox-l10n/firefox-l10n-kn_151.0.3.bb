# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "b59cde3b0edba98aeb8c613911d12f8f2400614c280aa8b68e7a49986e74b66c"
