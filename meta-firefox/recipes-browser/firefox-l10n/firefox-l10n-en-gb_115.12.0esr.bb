# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "faaf966d4a048932ee01cbfcd7feaeb4"
SRC_URI[sha256sum] = "fc5d695fd0ed443fe2e121b609d58562af818a8eca850d46bad448425413918e"
