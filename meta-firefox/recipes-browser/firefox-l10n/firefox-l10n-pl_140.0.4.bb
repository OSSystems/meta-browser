# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6276d017773ab605db3f39b4d8ae0225"
SRC_URI[sha256sum] = "fab77df8e4705e22e74ef3387dc0c8fcfa8b37ef97ce53dd4b016f8feb202e34"
