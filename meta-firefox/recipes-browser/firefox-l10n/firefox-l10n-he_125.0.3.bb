# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "54fb9934e2a66985f5a1d8a305875576"
SRC_URI[sha256sum] = "d4ede615ee5e726c361c6284d80e744f2668d8b27487cd6bd8ddb72f68b1fe09"
