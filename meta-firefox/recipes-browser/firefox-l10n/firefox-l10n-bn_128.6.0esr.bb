# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5f84e9a69367cbf901e51b240abb4ed4"
SRC_URI[sha256sum] = "6d651ca54091a92220856427ded18afe8b6e161940ebbc1eefb54302b61d7abb"
