# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a2eb333ae60d1d0a204f2fefad31adf2"
SRC_URI[sha256sum] = "f7654c4e0b358dd26e0edfaf02713af4cc6048f32008a756300cdb86ba9958f3"
