# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9a833a2bfc82ec380c310ead93e05300"
SRC_URI[sha256sum] = "db0bb0ea676674183542a7034132ce7d4218d057a86a46ddfbd2e98babe0210e"
