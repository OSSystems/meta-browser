# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6db17c14e69d0af9d334546ce979765f"
SRC_URI[sha256sum] = "97d8aef4c3247ddf7b0aee93457b58cf694bf6884ebe351fb6141cb7217cc67a"
