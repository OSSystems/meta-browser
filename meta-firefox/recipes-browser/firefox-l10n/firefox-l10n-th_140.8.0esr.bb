# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5e88397919b70f5dee89708e6f5bfb55"
SRC_URI[sha256sum] = "4aca74d6d29069aad50d57983f15b7eddade6c8fead79e7c6bada2b9adda6b44"
