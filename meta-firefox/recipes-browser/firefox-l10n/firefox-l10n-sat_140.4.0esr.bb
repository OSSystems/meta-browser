# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5902d01634be3124f4de62958c9a823e"
SRC_URI[sha256sum] = "a05f733b9eac9c50f34e024076deeef504be444dfb30dd83dd622bc18c0cf4ac"
