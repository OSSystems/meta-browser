# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b8a707c81c29d1a2930461254d875a48"
SRC_URI[sha256sum] = "150829f80833819342b40f9fd8ecc745d7f94598120559f3bbcc2bd8113bad9e"
