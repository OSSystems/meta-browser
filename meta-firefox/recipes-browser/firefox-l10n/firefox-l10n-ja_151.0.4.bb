# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "850d5a9e34111c23bda330c63583206dd36627a40a7c44382bebab09fa4423b1"
