# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "503148906be5a3db963737d3969d97d7"
SRC_URI[sha256sum] = "c9c2688dba1ef47fae957583981868770f85786b12c8b1147e72f0aa8eabefbb"
