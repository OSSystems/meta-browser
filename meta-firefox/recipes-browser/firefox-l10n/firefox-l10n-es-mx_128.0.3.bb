# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "26c8e3fad8f087c63f62097aa368dfc6"
SRC_URI[sha256sum] = "9984f421a5dbec378e3356e899c70bcee40028f87296bbd2ea10cb2de32ef557"
