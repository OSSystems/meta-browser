# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9e30b7581527774456f1a751ea7f51d6"
SRC_URI[sha256sum] = "8ee29ea635ed1a6545d390a305c48894769d852aac7a4738ad33776d1d6ec6af"
