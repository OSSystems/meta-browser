# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "60ed0d151868a1772905feefd747de52a880e3e406337eb0334e7bc6a8c7d295"
