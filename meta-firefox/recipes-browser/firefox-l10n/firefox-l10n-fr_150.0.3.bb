# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "086f178c9eff41f4856c8c9deafcaa10e296c57374858be8b962019f80da6d9b"
