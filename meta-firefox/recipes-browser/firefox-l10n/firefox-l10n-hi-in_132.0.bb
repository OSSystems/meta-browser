# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eed74c5018b1c054e298d5038e35ee5b"
SRC_URI[sha256sum] = "a38bc51e583e606e22a3c68b3bd200d97e63e6e2266a6346155a44d747596738"
