# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "572596eecbb37e631eda85e8ea630b06"
SRC_URI[sha256sum] = "516cd6f976d2364690b6b532040185c3ba3bbdac278a5844f49de140895a709a"
