# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3bd971b764aa1235edb3e0d4537f03d1"
SRC_URI[sha256sum] = "9672ff8087a41b3c3e060f0a58f0758103f54efaf0352b97ee0f8995feea899a"
