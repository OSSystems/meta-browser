# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cfda0e1033cf65e336f8fc09698413ba"
SRC_URI[sha256sum] = "8dab9bcbe6b712329bb2d9573eb15c0885f373ef08c226670b3cf03e862aba40"
