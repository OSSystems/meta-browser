# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "32332cf030eb0182c1a2e42b6359117e"
SRC_URI[sha256sum] = "81a37feb9be9020609f525c0df983c8be338298da11dfb8715416e390d76af28"
