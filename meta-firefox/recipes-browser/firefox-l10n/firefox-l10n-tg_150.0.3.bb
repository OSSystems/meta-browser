# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3a458cb8ffc4bd5f9995a6d510f92113a28d3548aa6d5fdfe26bc9fb1f2247bb"
