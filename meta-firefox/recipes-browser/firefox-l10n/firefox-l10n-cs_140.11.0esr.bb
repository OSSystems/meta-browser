# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "1e1016d556e1c84052f56ef90fd1df578aa8eb94c828beaaf82a785a937fd692"
