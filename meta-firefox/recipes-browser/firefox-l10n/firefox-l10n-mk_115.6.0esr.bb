# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6e54c443b513f4c822ed348da7de315e"
SRC_URI[sha256sum] = "13330b2b8b9577e1d8f60858163cceb5fdca0e02fb138dc91d2cc010a612185a"
