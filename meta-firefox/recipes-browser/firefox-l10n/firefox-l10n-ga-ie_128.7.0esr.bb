# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4f14099504a1a08ef8f1fb647225d705"
SRC_URI[sha256sum] = "7e2ea734ec11ea5b022b08545f7c35eb3b187d6109a9860748a6411075193773"
