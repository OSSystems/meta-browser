# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2e08d56d6c3ccd0b964d0c22ec107368"
SRC_URI[sha256sum] = "28fe587166c440a06e4a05be85743c001989bd642ffb87fbad14e3a9d4b2670d"
