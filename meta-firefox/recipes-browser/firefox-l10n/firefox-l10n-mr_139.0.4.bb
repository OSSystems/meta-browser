# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b6d4ea4abda524cde35119a89038d727"
SRC_URI[sha256sum] = "702d7174c1b79f0b6ac3203b86e1bf61db8264cf8c10d3775d97e2a156e1fcbb"
