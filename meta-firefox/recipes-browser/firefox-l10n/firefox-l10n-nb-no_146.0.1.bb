# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "069286815ea803ceed353938a15ca6d7"
SRC_URI[sha256sum] = "2b1d3e92a02a71408cd9915fc5a1740576ef4c6b83831e565e0c9bff496d3918"
