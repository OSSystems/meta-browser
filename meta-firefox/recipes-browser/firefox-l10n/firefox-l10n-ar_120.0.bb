# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0e4974ac01071f3e3080d2ba90b085df"
SRC_URI[sha256sum] = "8587893eb98f155ae0658bdde956a935abdbdc21765ead4c53723da37f695166"
