# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c644c0e102a7742c60268693f0dd419c6d49a3fade98193445395ea24630eeb9"
