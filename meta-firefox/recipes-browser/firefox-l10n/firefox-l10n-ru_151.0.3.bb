# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "61d3a59c7e98798f5bac288964764d1ff6b709ca860088a5d87a39ddc377bc85"
