# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "53f5c81489f980a3922457dec6f2fc1f"
SRC_URI[sha256sum] = "d45540648b7985871d03d24f860e80ed3aea99fb8aedf47f5c075c11d99a7a0c"
