# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4c68c30a14d14cedfdd48dd28de2fa70"
SRC_URI[sha256sum] = "a2ee07671919e122860b2afa74c665b36827ea35a7c349506d4c2093da5e2b32"
