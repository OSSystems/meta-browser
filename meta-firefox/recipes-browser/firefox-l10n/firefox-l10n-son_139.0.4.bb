# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c76918ee674e0516bf30491067a41f0a"
SRC_URI[sha256sum] = "b4b437d55eb625f3765fd423bb0409c235807afa8c5b4284f0ce4a3040ecfbe9"
