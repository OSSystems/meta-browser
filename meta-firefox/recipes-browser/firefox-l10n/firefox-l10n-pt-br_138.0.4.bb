# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7d92342b14eb06f8abd42de8aff21174"
SRC_URI[sha256sum] = "f654a9a4a139012f1c8b3612f8a322ab745d3dc90f7ab146489d9580b23c0348"
