# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f914b279eb88f1a65b7bd3cff8bd4da6"
SRC_URI[sha256sum] = "450e51b7f40b1d6a81e2f19848839051d080f0072d28ff7f8347dd632cd53122"
