# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fb3b1eb9896447f6f87efc1049053ef7"
SRC_URI[sha256sum] = "53d7014e5cf894546983898909c4f3fa96c4d2e6dad11153775b8101aa315d0b"
