# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9104dec2cfd7c9cd9fe6f3587acb5946"
SRC_URI[sha256sum] = "99e8c9456147d501bb651c4b4664cc453af0f27e8759f5ce8fa1a9c79925aa6d"
