# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b23caf9743fe4f550966afbcca3f70c3"
SRC_URI[sha256sum] = "9c30cbd263fe4279e7d3dfbc7ae32dee36b53fb014b5f3fd3097050a1a3d3556"
