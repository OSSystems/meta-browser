# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6b7e5ade9050061b57b8884e87d714a5"
SRC_URI[sha256sum] = "ba97ea44e65614476476be68c67835395b6c8a23b77a24a04cf575c67c61a7c9"
