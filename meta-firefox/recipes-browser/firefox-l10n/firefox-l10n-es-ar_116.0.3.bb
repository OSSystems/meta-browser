# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "59be920eed4f3cb9a5f604a5e3d68141"
SRC_URI[sha256sum] = "2391e38b7c64e3f5b57fbee3ba5e231f1044ed210b7939048f298e6c2d590cc1"
