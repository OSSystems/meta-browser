# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "790de02e9fb63ca621170059be34f01c"
SRC_URI[sha256sum] = "78acde2fba3a03346417d1339f6f1c05170e83cb56c38f1849c5ad8dbb621a4a"
