# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0bef84fd75b7d88eeee2dc00cd87d45c"
SRC_URI[sha256sum] = "b1f087a4b4f0cc9cded404797fd36eb509e62976ca01528da2719c4df466b165"
