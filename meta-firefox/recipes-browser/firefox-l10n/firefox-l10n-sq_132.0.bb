# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "10a775b8857e93d7a0b6bcc25ef7cba0"
SRC_URI[sha256sum] = "92d11da5ef5de1cf7aa3a471f36ce63c85278580584f9e7f12f35c8a6a05fa61"
