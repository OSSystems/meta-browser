# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ec7337f0c7d2bf6a91795de72c1c447e"
SRC_URI[sha256sum] = "3b7d0b9b0968f689dcca4fd19f6adb14fce1b0c422bedf8f377eafb4780e6e64"
