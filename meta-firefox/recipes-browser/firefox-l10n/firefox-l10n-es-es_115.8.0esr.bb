# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "674f9affa1d0ad97c33159e9b640d1bf"
SRC_URI[sha256sum] = "a9e9e2ad0cde64a9b24b4b29e17cb2b092f1a7bf083a1762038ff0baf44c43b8"
