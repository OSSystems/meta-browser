# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ec1f24b6b24b620a1bb5676ca61a9951"
SRC_URI[sha256sum] = "54299dfc74893e11e9c08df4a960c69134a4eff26fc9432dbeb5ef7480067d5a"
