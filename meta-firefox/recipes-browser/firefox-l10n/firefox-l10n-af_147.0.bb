# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "42e43f71a0b89622f1245b1cf705e397"
SRC_URI[sha256sum] = "a01afce1f3856fde69f14fe5d8e057d2e7a5ba513e35177b7846bb241b821fbf"
