# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "938c5ab4ebeae1c1434892f76fac3885"
SRC_URI[sha256sum] = "ad5b75f6d0db3961d7564ced940439f77d6a7b1bcc83de1fd92ea6af9b816777"
