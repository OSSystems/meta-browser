# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7a32c2fc705ab78e084de0d83ce5276b"
SRC_URI[sha256sum] = "abd67c30681a7a2889261890d4076a8754634389b7e1ecc9c10455e2b91d60ce"
