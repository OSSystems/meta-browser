# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "676e602cf2bf1fad659a278fa207143bcc83730b72dbac3cdfddb87200862978"
