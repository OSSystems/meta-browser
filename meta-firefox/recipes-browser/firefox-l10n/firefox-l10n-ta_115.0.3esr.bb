# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "87186d0c46fb168fe99f250abb198231"
SRC_URI[sha256sum] = "9a1ff8730ae9f61007ca789dafe7245f11d5c140908b10f334587a398bbfe300"
