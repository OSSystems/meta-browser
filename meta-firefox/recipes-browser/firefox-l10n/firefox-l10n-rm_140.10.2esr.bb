# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "a8d68612010796fa21ebe20801379dac8fe9ac8458055f9b08f4751e226e8d90"
