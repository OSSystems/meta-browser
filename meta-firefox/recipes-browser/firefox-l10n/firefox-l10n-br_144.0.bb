# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d3b570cb4e97f3125367f068e77c56f1"
SRC_URI[sha256sum] = "0cb1c575acd4defdbb345e0753bc322a00a3a266ebfa7f856cbf061036b394e4"
