# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "889568736bc7ccca0f5400daff50b1ed"
SRC_URI[sha256sum] = "4e04ce07364a56cb91e84c1082c16aa73f9a7925119a88a7b412e3a1962de2a6"
