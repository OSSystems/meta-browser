# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1b3e847b279bb52b18cc733e9d1a358b"
SRC_URI[sha256sum] = "6923b3b18f9309ac6331808677e477bf1601e5654606bcb252af6aba5d3f386f"
