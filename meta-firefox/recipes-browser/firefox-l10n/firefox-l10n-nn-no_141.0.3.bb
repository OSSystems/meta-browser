# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b6b1958d904349c7483e87decc8071cd"
SRC_URI[sha256sum] = "e4fad76df2eb0288be6f863fc56c2f59387ed6a44c20aeb26015f6d9d2b71ff4"
