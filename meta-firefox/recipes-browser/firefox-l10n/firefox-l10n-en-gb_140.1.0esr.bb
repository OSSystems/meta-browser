# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5149b1034b8d05cd88796eb44c8e9d0c"
SRC_URI[sha256sum] = "1ca2fe64d084611340df03a4c97f1e9a1487cbeb6ede9caa646bd6cba37adcff"
