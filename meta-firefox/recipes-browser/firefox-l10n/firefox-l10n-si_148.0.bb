# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "959634e4a9bcaa24e96e9cf95817ecdc"
SRC_URI[sha256sum] = "bb469e8262015250ce30994f9a6f5c25025145dda171ee6787c8cf9af9d24673"
