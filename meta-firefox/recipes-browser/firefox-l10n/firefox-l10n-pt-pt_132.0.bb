# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e650228d3037168fc908843d8e26a669"
SRC_URI[sha256sum] = "69f96041d818ee1d737349a69ad069f16793700f39c376f3bf256b4dcde3001b"
