# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ed0cfeb19913b0fd621406f39cd38f5bcadefe03b134defc812c9460c76f46d9"
