# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1014ad7f39cc6a09a77d8c253177f3f7"
SRC_URI[sha256sum] = "86219f1ada3d602c7849c89d20318bae04f59917d1fa10831cee2205416cbfa4"
