# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "036baf97470d6dd5bbb94c4a9843020c"
SRC_URI[sha256sum] = "646674c56d5f4883c852a6ebe02a347e734224461f6af3001aad92c8e1a22686"
