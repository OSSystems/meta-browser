# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "74433135c68bb52e6627b0b155d14cb5"
SRC_URI[sha256sum] = "6ee772b71a114146aa7d952fd4fbd7b1af636c60a90bc247c4e8f0741da11536"
