# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b4913ba6947589c852695955f690da53"
SRC_URI[sha256sum] = "4af344ea83db31042d8cc75b3c138083bbf2944ad68280d016a63e2124440058"
