# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1b0710a6981ee854f842fe056d1b649f"
SRC_URI[sha256sum] = "c8d9428fc072001bd3bfb9cfec01dd4fcf7f1de415c999b20a0edd3502181e39"
