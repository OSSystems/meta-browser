# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "be164c50ff524fd789acbb43f26eb945"
SRC_URI[sha256sum] = "b12e41ced05411b99583d75680846e0e126d66598f4f4dc7deb5dbab475ab6e1"
