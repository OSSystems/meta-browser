# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "74c9522e77d289e78ca4a1c2cc82ec3b"
SRC_URI[sha256sum] = "7e691a22b5dd92b9be92342d380cd4517c08d9ae45578af81f74d962244a7a69"
