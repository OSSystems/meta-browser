# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "386a4b000c4d8e5b283ea034dc2a14f0"
SRC_URI[sha256sum] = "876212100b92efb3b933205a9649c81343f68ffa436c81f5d7ca432f38123c83"
