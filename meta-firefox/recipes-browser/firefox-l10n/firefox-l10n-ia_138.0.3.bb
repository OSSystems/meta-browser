# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "967add292c1b969db3130c5e602ce8a0"
SRC_URI[sha256sum] = "4be537c6b43d06f40bf29aa19765c64a4d68e4fe1db2199ca64589e2f5e55bc6"
