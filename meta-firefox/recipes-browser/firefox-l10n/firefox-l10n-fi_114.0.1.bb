# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c4a3bbeadfe896c852f64b386cd34e67"
SRC_URI[sha256sum] = "2c438830d6aa73c634e75222977c97a6b95e0ca5465c4a8784b1f9a85aa71038"
