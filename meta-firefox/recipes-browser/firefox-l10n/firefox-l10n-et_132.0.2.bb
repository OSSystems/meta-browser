# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d36f848ecd3d8285e1d53b173be866d6"
SRC_URI[sha256sum] = "3e36228927fe458a191e6849d65da47187eadcf37452f6789274542aed606141"
