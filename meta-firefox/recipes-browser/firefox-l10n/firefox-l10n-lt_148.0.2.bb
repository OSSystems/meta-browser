# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a7a7c331b049b73332ccb7c02db7878a"
SRC_URI[sha256sum] = "8e9ba608b4b447ef8eb7939e9d5d4708f5945b14e3714368df9409d6545bf73e"
