# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2c7d365afef8a5a0572210e29cb0cca5"
SRC_URI[sha256sum] = "a6b3d4bc44412257cea3d25387091ba992aa8d6c524fb9f17aed8f355d3fddc4"
