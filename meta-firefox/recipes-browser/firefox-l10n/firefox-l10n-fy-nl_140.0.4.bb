# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8eaf14262432c469d890af29493a83a6"
SRC_URI[sha256sum] = "15326f3a5127edf5b96c30c82701ead7fd4d931da9672c7fc30731d94842af7f"
