# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "acca3ff60266e6239e7608d4a471ca81"
SRC_URI[sha256sum] = "31e8b5036a5b3a1bc2af693a5fd7558e202132cb6b00a189f89b82f5f71fc822"
