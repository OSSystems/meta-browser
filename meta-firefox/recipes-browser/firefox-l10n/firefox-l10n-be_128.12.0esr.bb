# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b1bb468aeae61d92a9f5b938b32ad73a"
SRC_URI[sha256sum] = "9e506f13999a27bf72cf811784162f301341bcb52135c54044315805767f593e"
