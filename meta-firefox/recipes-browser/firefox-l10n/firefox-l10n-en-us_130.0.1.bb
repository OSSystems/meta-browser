# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4c5d62047306a46a933d6f935942dd9a"
SRC_URI[sha256sum] = "ef15e2e37a742e58f31d729576922b4f0e1958e3d0e04209286672fbaa5edc3f"
