# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4c8e3eacb1755627924133082bc1689a"
SRC_URI[sha256sum] = "a22aac483a2d2593d45d7b22675fde3b886f0f76751b613d94609064a57a902d"
