# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "69a2d68ef93808a761bba20ba6df6d56"
SRC_URI[sha256sum] = "4a3e5bcb7611a0945ec0e340551aba977dead65fbdb08f87a534b5b06d297c45"
