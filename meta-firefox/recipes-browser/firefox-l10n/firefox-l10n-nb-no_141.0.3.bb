# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0be03641934cd512f832180cee8b00a4"
SRC_URI[sha256sum] = "ad284fe976e8fe98e5608d95914f8f950cc150ff945cb23865f3382fcad168fe"
