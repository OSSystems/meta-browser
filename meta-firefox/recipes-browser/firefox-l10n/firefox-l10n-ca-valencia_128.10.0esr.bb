# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "588f66b0adf1906d47c2c93e9e1ad83f"
SRC_URI[sha256sum] = "75e6d5a22a7663793a4ddffab8258f8333506dca4c9d6065ca6566681b0e4331"
