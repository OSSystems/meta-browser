# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9819eec1db6d156ebaa546038ce4a5a8"
SRC_URI[sha256sum] = "f5a6de0bc95095da23829dd17aee511e6707a02e34ae72728de319e4f06285c7"
