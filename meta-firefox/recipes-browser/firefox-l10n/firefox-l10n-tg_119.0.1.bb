# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7e59f938efad2f32aa2313313898a9de"
SRC_URI[sha256sum] = "9846353b2867f64d825caf52ff174d094a60f4eeedea26eb0eea21bd72611ff1"
