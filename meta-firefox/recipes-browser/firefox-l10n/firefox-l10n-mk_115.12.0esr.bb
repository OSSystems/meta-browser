# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3c261480762995728b683e65f74013cd"
SRC_URI[sha256sum] = "a9b6327f47709d4723104bea09eaa723b1adf67c3ed01d66fabdbabd70b07e13"
