# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "4597c51a38252609b4e87e7d88952f057b288e058d41d464757ca19248b67df0"
