# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3bae63d0c15026bea197f1516ca5d1b0"
SRC_URI[sha256sum] = "515b85838d8c6d480effadb1fa0c60ba9944e2cbf19d69bce9c32c0a586fc7bb"
