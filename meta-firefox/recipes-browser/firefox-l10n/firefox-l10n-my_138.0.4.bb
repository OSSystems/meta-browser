# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0690a656018691beea750bf4a34e90a9"
SRC_URI[sha256sum] = "be0cd956ffffc0695dc5b32ea11c845be0f1f7cc94415c3bb184a5a767591eb3"
