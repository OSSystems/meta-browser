# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3a4042d43143d4d93fa6cde764b9ed06"
SRC_URI[sha256sum] = "4a4210a63f994a1bf4dbc5f1d699791469409657c2d15f40b0502127165cef0e"
