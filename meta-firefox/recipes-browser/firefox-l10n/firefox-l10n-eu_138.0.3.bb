# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ab2a97e79caa697a688bc62cce50277"
SRC_URI[sha256sum] = "1b07489b29b9f7422988476b4243f798e8206635e1b2f95e0481afc66ce9c5ea"
