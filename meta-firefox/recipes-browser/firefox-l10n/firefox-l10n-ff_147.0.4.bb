# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c39eb7b1b01116aa55663b258d916df4"
SRC_URI[sha256sum] = "79e60393376abc9cd6eeff422de76764104a9066cb841cae52fa1c1faa3b2a5d"
