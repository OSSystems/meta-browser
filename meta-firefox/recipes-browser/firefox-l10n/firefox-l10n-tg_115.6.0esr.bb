# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bae677eb153453b3eb75903c83585dda"
SRC_URI[sha256sum] = "66fe37374a78a24a61599aa29c1e585bec49cf417d1e7278fb9375d9358affb2"
