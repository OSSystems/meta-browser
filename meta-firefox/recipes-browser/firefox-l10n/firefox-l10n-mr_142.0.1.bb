# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9b729cf746a7b045e1d1c5905f77d9aa"
SRC_URI[sha256sum] = "34ee866c4593222faa9e1f1170b8ccf34043461b2ae229431616d5979529b5d8"
