# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "61e9978638c0cd469e67ea96854e4b2f"
SRC_URI[sha256sum] = "7b21108e8ee7e3540623b7d7bb500e0ef9dbc0f2320dd11050279fa028f455e2"
