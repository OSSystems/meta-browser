# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d47c7990d0dd149a323a31dcadd0d31c"
SRC_URI[sha256sum] = "8bf2a56aacf65589be0c58810874667a1ab03e89d6dc95e13d03fa90f50842ba"
