# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3bc92bf320bb1488919a4586ecd5f9e6"
SRC_URI[sha256sum] = "2fd9e80fa23a1d2f950dda151e351dcdcd11ae6af9fcba359c5b3a7521a5b13e"
