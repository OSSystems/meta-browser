# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ca571c2df9bd610c673b7ec42d93bd38"
SRC_URI[sha256sum] = "035b24d083c005729733d2a0832e4baddc1cce1b715001ff3529fb0e0d4c8244"
