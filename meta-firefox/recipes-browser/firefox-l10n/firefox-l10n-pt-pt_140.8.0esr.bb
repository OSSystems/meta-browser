# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a912bc3078169c94ba7006c73484a05d"
SRC_URI[sha256sum] = "1090f19d64932742f67a186d1bd1415f276367f34e35a29a4c4a76b61a64876a"
