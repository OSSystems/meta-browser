# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bd1b6a396ddc98a6d3e421c4efb1f802"
SRC_URI[sha256sum] = "bc2f35f4b354af5cd07b646bd11711adad9f3c03e73705480474357f08892028"
