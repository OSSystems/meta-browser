# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e3bd9c3ee27907ee863f77b8988bd563"
SRC_URI[sha256sum] = "fe4db4bb97bf835570dce3819fbe1348213d6769cb1602fc059b173265a6f6ab"
