# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "627ac8716c7fbdf5211ce0f5ea5dc6f7"
SRC_URI[sha256sum] = "b716c8f63f69ceca0bafc6ba95231076038b8b98f3011dff4b53776974ffa168"
