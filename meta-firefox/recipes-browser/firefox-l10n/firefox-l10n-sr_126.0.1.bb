# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a53223bcd3a46f98b4cfeb5d3f8248a4"
SRC_URI[sha256sum] = "3694d4ceb12f3ad65da4963ccc9869b5f446514f3ba9b3a6bbcdab0aa5f11271"
