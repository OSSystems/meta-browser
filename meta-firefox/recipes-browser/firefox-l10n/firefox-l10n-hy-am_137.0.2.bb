# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7b001dea33754a3a6b274d545506ed24"
SRC_URI[sha256sum] = "e69331cb7d3797cd9de5ba14f4fb52cae19b7645f9e3cf88c289f61151887538"
