# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8c3663d135e16eee8384d0f9eadc22f5"
SRC_URI[sha256sum] = "027a4b6e2bfc8dd8c949643c28223deb3089e636506d7771b571920463fac9a7"
