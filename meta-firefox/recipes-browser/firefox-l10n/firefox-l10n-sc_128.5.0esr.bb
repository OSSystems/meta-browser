# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "84b4184a784f14ec069150e9476f2ed3"
SRC_URI[sha256sum] = "bd36298957a83eb1f1e3cd4f89dc172629e1a49f20d6a080589a0efba2cf3fa9"
