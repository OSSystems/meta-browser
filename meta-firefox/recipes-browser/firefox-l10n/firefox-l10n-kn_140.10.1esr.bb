# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7fe2d53ed7a0dc516fa2dafc50f7f67d7e8518890d6f50bca9d5665eb234ad15"
