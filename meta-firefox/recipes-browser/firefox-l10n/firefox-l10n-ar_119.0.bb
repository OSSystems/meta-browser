# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0334d89b243c14d72cc8edaa2961d9a9"
SRC_URI[sha256sum] = "5f4d01e8cfa1d6342c89c1dd6aba943c16bb0b3b15324764473c138ebaa9801f"
