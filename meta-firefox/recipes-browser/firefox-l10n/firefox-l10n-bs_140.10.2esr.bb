# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "67333df1f74ead5805552106dcc059591d1276b7cbbf0ce6e0bc20ec26afd130"
