# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a27db178d6cf53178a569bc9bc61d3b5"
SRC_URI[sha256sum] = "26a089bfae45663720b4ba7a4f213127455a16ba925b7254f217d0a93496e4fb"
