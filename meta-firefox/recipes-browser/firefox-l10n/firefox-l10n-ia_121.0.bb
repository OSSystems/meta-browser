# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0255763ce5913cebf772c7bace268e28"
SRC_URI[sha256sum] = "6295dbfa9f8e1265c1fc5805bd9408737022bf661b48e03363cc635add70becb"
