# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a792a453cf5a603628c32cc34435016f"
SRC_URI[sha256sum] = "9cf9124bd74e994e46c0c0243903c3e5ad86b4629e5e42ccd55da6a3dfb094e9"
