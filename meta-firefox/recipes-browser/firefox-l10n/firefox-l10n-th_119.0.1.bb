# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a512cdb48aed4f22951c432eea22e381"
SRC_URI[sha256sum] = "722226ee49ffb92a5e92a10489edd6ddcc33813d78fa30e4791df3d741395b4f"
