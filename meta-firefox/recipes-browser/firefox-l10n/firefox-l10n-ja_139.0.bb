# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "90bfe608efe013327d58c400327e0bf3"
SRC_URI[sha256sum] = "cc1772de7af7e04e908f342b981e82f399c868a7febf0452f6f8a38480437c28"
