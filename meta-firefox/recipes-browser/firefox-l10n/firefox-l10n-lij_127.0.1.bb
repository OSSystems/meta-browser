# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4c97335da13d623c70f816314de64a17"
SRC_URI[sha256sum] = "e2ce31b5284c5ef7ae23687b35556dabd667e6c6b8805bfc475683afa9d18d3c"
