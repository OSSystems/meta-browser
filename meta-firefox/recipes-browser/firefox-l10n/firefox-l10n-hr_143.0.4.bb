# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9d2de86fb52acd2fd2072bf5f1f7bcef"
SRC_URI[sha256sum] = "293ea451382f34ec7fe0478914ee548c0cc14795ea24de379e5f0a733375b7d1"
