# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2d77e158b3c552d9a3d09c29c33bb61d"
SRC_URI[sha256sum] = "2d3da71c9bc4f9096ee81dd8bac18bcdd868f3f7e1d3da3d8775131131673a22"
