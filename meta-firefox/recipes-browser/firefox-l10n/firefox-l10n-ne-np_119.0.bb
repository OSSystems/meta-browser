# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a51f23cc3cab0ea679f5726685e0d104"
SRC_URI[sha256sum] = "5092251e295cab8cc145614ee27f3780c9497d356ac021fb673b034377b4b649"
