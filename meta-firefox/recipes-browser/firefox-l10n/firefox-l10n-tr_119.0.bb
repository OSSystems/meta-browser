# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0ab312943e45bcf75efb4dcfde9adb67"
SRC_URI[sha256sum] = "15bd18cdc18d169d3e1867a2c867f66bb41d332f3227c458d3c15e56934b1734"
