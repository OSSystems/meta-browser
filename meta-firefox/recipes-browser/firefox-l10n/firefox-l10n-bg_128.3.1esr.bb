# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "668d24595f8e4554320778854624d637"
SRC_URI[sha256sum] = "bdb202a2fe2e3b50520dcfa7b2868926ad4a5ea674be3ab60b3db999d0699af3"
