# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e1e2f26469a4601777ccd2c41112ab90"
SRC_URI[sha256sum] = "2f2dd204840b81bd5655285c6949ca6b9f1ed5e379b2fd2acd44a879c7325423"
