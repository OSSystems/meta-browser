# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "96281b7662f62c79bd111ffa42c967ae"
SRC_URI[sha256sum] = "62797d16b611523585b116ed66977eff9e9f3fae82150c610c38c550b1e4f6da"
