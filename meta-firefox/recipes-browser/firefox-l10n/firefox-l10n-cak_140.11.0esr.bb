# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "a17c159de98c7bb352808e477881405873a3b930d768e438c673f61c0bc18c1b"
