# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "95c9af2a4c9b7367bc80b6e3f705959a"
SRC_URI[sha256sum] = "eead83db547331735cff4bc796aa0b5ef13d5e497cad665821c5eec7b328f87e"
