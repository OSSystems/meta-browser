# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3f654fe4142678e179264657fe5d2a69"
SRC_URI[sha256sum] = "bf6b81195dc8a48cf3be76a37700afa8e31bd74fee435ca56bc932d90df50172"
