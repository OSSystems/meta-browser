# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "13069e44f171616fc25ae004ffd0a5b6336ab2ce23d749dbddc01c5955433472"
