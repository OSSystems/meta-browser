# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d00c16ffeecd4956e82fc4bf5ee862fa"
SRC_URI[sha256sum] = "47f49d27df6c9fd1be919db4713d38ed299cebeb1d3e728cf5bc03f18355575b"
