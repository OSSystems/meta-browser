# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "40c628e7e1a4bdab5c5b5a3973d973b2"
SRC_URI[sha256sum] = "9e407754172b18b529755113fdb0d3c626a6429f5b3c0ee112ba8e8eddaf642c"
