# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "de3d35871a965ee0c99f9281fc290042"
SRC_URI[sha256sum] = "8255141c1872c6a509188092a7b13e34663a9ecba7fd4e091101776f0c50fd6c"
