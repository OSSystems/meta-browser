# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "54b4e2faa359129a8b56cc1c0d682150"
SRC_URI[sha256sum] = "2d08daa79315b365f23c3484c2ba4d057005aafadd7106f78c24c9612a9923ff"
