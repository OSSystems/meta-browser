# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f48a7f76242bf4e8f9770d4d883717e2"
SRC_URI[sha256sum] = "c882cc53184bad6c110c009821953889fff9c35f50883602926a6d65184a51fa"
