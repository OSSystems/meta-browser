# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4e3e75e6cc102cb7ae6259e1abe2f8da"
SRC_URI[sha256sum] = "a9dd81330cb15f89084558cf29d3f32639b05da930ee849ba85dd086d3769c37"
