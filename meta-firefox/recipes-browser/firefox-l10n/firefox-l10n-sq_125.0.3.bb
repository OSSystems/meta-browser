# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ac26c2e7c0557dd1f5c5423e9d7a2cf9"
SRC_URI[sha256sum] = "fdcfad4d3e2e46ed97a1ef1fc3f6e0095d66ca94f30d22af9c9ac3419317ecc1"
