# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c18ad388d837f488bb86048ebb0c1d1a"
SRC_URI[sha256sum] = "a130f0d6b069479f3074b8dc9df13974881dc3aab6052cd5c439e551d885a8c9"
