# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9aeaf02c6fd4f909ede991693eb21c34"
SRC_URI[sha256sum] = "271f219a9b5d0fff535288ad322fd744028efd3d8ec64b7b5197491228648890"
