# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ad490dab4e73ff80430411e85f5e8163"
SRC_URI[sha256sum] = "bb72d8101d89ef88af494b1ed44a2e2294c3aa0d87b8ac0a0c17ba20f4b77403"
