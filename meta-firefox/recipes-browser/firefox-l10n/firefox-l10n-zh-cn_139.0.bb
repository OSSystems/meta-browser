# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f9867642f6cd7ecba9a1e123b11d78ca"
SRC_URI[sha256sum] = "f2530922350e2493fa4ae7a62f6c4e19bd93e15c15df7d4e392055f66db4fb1e"
