# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "15bbe8a38098f215b611a1d33ea8efcb"
SRC_URI[sha256sum] = "52980a55b85c7bcb7497ff058a8ebec00cca114809e54f9bdbeb2ad84b52a1d5"
