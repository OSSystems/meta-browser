# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c0c58e2c991b4c8927b33f4cf3684e49"
SRC_URI[sha256sum] = "635dbe458b9a027b0b9133e0e63b341344c3e4d1093eba9c7edde32a7c023902"
