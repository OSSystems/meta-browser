# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "28fd1ecc2c63c2b2444da6a75f275d45"
SRC_URI[sha256sum] = "bb498a0577a422436360ceb4d571189904c6977a472bee88f00fdf29d4d15ac0"
