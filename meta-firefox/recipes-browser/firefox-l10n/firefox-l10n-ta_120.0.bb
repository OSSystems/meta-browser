# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "65c29476ce19a1dbb809a543b4adcbb6"
SRC_URI[sha256sum] = "bd5a0a27f86784600817ff14581604bff196fd6a0f639277ce528dc44770840e"
