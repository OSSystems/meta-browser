# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9b9b2bfd659cce9ac15803e23c1a8794"
SRC_URI[sha256sum] = "9f4afc30db5d9edffdc3e61197d1b6064cd73eeeac49cf22a227fbda53fb97d6"
