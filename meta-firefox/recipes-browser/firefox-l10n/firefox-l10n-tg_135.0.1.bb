# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7460e9661061a845dd67995caa4e0de2"
SRC_URI[sha256sum] = "eb42ca03c8af63437467d46142b059e18a2a571bfd522919ea34634f1d52673d"
