# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "adefa281a591baf5c82fb96f77590f01"
SRC_URI[sha256sum] = "50b5a098ff1ea6795861a4d862906cea1426056429114b00eee4d225703f0640"
