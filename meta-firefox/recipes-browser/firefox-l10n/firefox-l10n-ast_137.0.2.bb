# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5eb860a691d56c656fbc716d2cb32eaa"
SRC_URI[sha256sum] = "0e1441a878ff388c75df19900463f8b17759019c86f586e8c2346e06d6948086"
