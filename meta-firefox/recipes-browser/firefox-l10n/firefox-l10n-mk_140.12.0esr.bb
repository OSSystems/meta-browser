# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e20075782b5ac730ea87b22d985787a7699485837f74b3223e7a1bc9ed0b6c22"
