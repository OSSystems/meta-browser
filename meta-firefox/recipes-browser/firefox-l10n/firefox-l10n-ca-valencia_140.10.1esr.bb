# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "19c51b053539f75a651317aeae7d1a3a30f0349b5beb8ca850d0e02451fa4e7d"
