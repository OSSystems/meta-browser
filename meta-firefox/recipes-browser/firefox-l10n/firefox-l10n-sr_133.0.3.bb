# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "abe2898f9d5440cdc2c55cec14efd7ab"
SRC_URI[sha256sum] = "6b31c472914c34feaa510b67b33c57a5b146f03a2b277904f2668eb1e1625119"
