# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "466fd349f1ece173b9b310c6602c203c"
SRC_URI[sha256sum] = "c5bdd59fe2798d72a3791750911def19ccfe05c4348c409bd4fecadbbe9ecc42"
