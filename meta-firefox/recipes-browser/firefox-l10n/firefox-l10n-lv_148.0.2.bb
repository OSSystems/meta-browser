# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b7d172351967de43e53875d2d8bcc51b"
SRC_URI[sha256sum] = "9b896b5c48e4670f931dd66104798cddc3bbe1a5fd2345750f9c02a0c6451e4d"
