# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "39ec22648545951242e646349b1a313a99a2bdb0b06c6398e2c79a925409b7a0"
