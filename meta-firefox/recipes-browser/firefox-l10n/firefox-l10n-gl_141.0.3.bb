# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6df320c1e20c2cf8e6c2c7ef6596f4be"
SRC_URI[sha256sum] = "8a1f3c3bf29cc9f31769baa1c4eb5b20a1c33623b8c591c96568513bc1d40b68"
