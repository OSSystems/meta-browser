# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "41f57c4154110dd85663ba6248ec6dc6853d602a4ebccdfc917128be6cb25d9d"
