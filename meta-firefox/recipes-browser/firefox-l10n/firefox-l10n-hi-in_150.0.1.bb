# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "9e502c80290fd8528e8384b5c3163c905e7adc97be9c6a983b0330ef74dd80cc"
