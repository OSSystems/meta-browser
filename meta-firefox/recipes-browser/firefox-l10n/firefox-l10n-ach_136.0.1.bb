# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "80fee2589b69cfe84416737bc0886f46"
SRC_URI[sha256sum] = "18088d6a66b0ff943c406721172fa33468db24d5d59b45ffffc5fba4e6462266"
