# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d4b8858426ed611e9f603aeedeee41d0"
SRC_URI[sha256sum] = "58beeaa63fe555177ebc2ea3eb424b0b659095f075ade22d6f8f17d0efd91d3a"
