# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "62ca4168e59414b8887a51679431044d"
SRC_URI[sha256sum] = "d488bbbbc51fa0d53d3670baa665befea7e5b56d85337937d48a605e1fc5ae36"
