# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "22ee36de47423ce29be9bfcd65f48da1"
SRC_URI[sha256sum] = "e8fa33206bca94ceb380fa478bf860be862e76e9bda81c89a67fc22cbfd9f67f"
