# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8554c664dc899688620ef1c85509bac5"
SRC_URI[sha256sum] = "f9db78d902540d9d4a1ff064b6bd32cfdb2a3e0b252dc89386a1a63dd2dc2f68"
