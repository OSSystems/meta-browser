# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "535e8998b71b67e3f6500a8461a96dbd"
SRC_URI[sha256sum] = "8b32f700bb232d637e42aa59fe872ab384b25707f55600051dfb6ac293d6bd3f"
