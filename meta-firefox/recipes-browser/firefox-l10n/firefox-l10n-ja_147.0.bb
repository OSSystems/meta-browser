# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "36d0926499574dadb7ec44567493887c"
SRC_URI[sha256sum] = "b19c9c898b2230d30c3b531111728df2805026c4a52ce778d69c92f997a83763"
