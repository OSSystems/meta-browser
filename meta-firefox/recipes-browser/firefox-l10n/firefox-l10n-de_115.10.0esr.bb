# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "200e95400f50e5b69aa03732c5314adb"
SRC_URI[sha256sum] = "4e13d0ec40400136c34f34e6623a7179078ff8fc444cc10bd58c6f7f33004705"
