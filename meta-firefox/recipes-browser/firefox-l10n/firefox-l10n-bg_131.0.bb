# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1fd5bbb88e8be7e2d41bf0cda1026f32"
SRC_URI[sha256sum] = "e04c0e43c6ba18370533d1cca193fd4b0dfd27062638baa2031527c4d77cbc45"
