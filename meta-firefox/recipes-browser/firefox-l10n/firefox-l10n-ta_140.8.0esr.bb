# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e8e0980b2e626dafee143ff4c3ef4eec"
SRC_URI[sha256sum] = "f682ea0abcf4ccc307d98fddd1f6896a97a8951cef18704c8f4b4db94fa1e0f6"
