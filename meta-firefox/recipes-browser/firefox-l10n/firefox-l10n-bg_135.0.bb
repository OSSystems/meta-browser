# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d8c884071d51613f2852eca68aea312e"
SRC_URI[sha256sum] = "adc9570c70d83a96f9dbeb8014a246c63915b068e3fa13cafd26891ec730ec65"
