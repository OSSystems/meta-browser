# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "144a7ae1fd28d9e9ad857ab0d3eabc39"
SRC_URI[sha256sum] = "7017ded9a82508bd8688709d3008bbe7b71dcdb6d6270673f02df9f07c79e3b5"
