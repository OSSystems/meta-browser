# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2ced78b85539b6746a2446d7f53441e1"
SRC_URI[sha256sum] = "f81200c104a357f9a9a55c50562743855ccab70ece24f6fb6717c786e06e146a"
