# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f4a982a2260dd7ef98705b90fe16e680"
SRC_URI[sha256sum] = "27ee29d8a1d007d9376ff2901e7d0295f4d370616021d246049505fdc12fb30e"
