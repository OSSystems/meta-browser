# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e41bc928d566b0c2cd981640ac4a0d0e"
SRC_URI[sha256sum] = "3413f88b84e75658057302f5abee112e26a2214fa50277b82101860db5a7eee7"
