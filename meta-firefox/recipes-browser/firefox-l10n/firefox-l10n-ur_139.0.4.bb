# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0b9b468d739a6128a872862573400809"
SRC_URI[sha256sum] = "5e49b815a48a5e3f29a41cf6595ddc8fe34b204551fe9b5cc1add910807f2957"
