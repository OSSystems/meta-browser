# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c6c9b4ae01e4b4890477ad65ae3fa10d"
SRC_URI[sha256sum] = "9c57f5ccd8c3a3347394c9b3df2d2d60e06763bd9ce715beace2e08e2b24ed3a"
