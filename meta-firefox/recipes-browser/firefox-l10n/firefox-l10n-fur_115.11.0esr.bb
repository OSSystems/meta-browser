# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1f4c68bdfa5075eb2e7fe8d9fa399cba"
SRC_URI[sha256sum] = "ae18f521a641b70f05d1c1a51882a7cd2644d9aa8ce10ab90a6fe168c451209c"
