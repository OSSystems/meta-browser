# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "af580ebf233c2914cf032e97cc51ccabf4670fc407e6705965397abdbbdaa91e"
