# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c5939bdca1160e27a8be65a35b8d0c40"
SRC_URI[sha256sum] = "291d269b5f62d1ba26544d2b99cce87d71ae3532c7943665529ddfaf515d2686"
