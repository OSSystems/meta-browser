# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c269f03b1581b15d1f1c9818ba2820f8"
SRC_URI[sha256sum] = "c7185e8228f551f3f39e5ac2adef7c8bbad043afc9569fb64c9f6e2503452e19"
