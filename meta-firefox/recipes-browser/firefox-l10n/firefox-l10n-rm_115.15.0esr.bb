# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "141ed206ec16e66657ddb3262b944e84"
SRC_URI[sha256sum] = "3d89f22d77b679b5f6906068d023b5ea4b46cc43b7ad228ff032778c63f9964a"
