# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d904745a0896c621629286dae1e3ea6f"
SRC_URI[sha256sum] = "cc3233900cbec78cda9a3a0a4ac0a8822023f5d59092ba06ff7c5b4c79264826"
