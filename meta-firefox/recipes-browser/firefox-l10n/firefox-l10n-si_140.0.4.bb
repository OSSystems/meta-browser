# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "895075aef66a7358f1c0e83653a0dff9"
SRC_URI[sha256sum] = "ebd9213f82ab089a7548ab3f0903bbdf1a9bcf1d4c1bd94fcc44b43e1b7dcb25"
