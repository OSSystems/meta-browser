# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e4780a538e075f2cb34d1e6c6da28da4"
SRC_URI[sha256sum] = "b5675fd43de29fe44f9733741a1135a56574e284c0790272053cee2b1ef70b54"
