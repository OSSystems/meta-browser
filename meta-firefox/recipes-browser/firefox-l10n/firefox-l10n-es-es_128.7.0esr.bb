# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4e8f58fe59d7fc6b50b5ae4508d0e301"
SRC_URI[sha256sum] = "92d469230df22177540fd43ea89abdbdc5cee27c85e26ea85db06f19b551809a"
