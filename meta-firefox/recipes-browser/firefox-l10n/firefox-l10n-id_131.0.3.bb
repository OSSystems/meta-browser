# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "574aba26f6fc990542ef83a4d3009ab2"
SRC_URI[sha256sum] = "ad833d9181d33c3890bdbef8a76b1d89aa52bcd50c23f874461ca5dfc5dfb028"
