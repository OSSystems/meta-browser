# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5d30eae6a19884083bca0fbc59730ca3"
SRC_URI[sha256sum] = "bb8cb84e07f1287aaa41c64772ac2a8829d3c7e78c470057f1f89d51293a4186"
