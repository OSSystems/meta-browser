# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1d858a853d44c7a6cc78cdd48322ed1c"
SRC_URI[sha256sum] = "a659c2114638a2f0b60f34dac83afdace4eb4bb299766eea4ccca10c9d370205"
