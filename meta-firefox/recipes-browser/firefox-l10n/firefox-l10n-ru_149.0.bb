# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ec6d37ce4b153b4fabc5aa063755523"
SRC_URI[sha256sum] = "6b7f64ea9407dd1635f3c29b685676cdf7692bf3cf7a8be4a3ed938082e035ca"
