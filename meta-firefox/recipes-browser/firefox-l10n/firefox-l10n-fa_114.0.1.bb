# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a3d1dde87f1885438457e68ce88d2036"
SRC_URI[sha256sum] = "b0e0fc050805e2c7b4c27170a020a5aaa2a3e76916cfc9c3766f5e01539c08d1"
