# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7c333311ab7e4660944b2ebf8fcea741"
SRC_URI[sha256sum] = "7fd5218f7fb8f1e1437a14c77be5c169e77dff8cc1b41ca2df7bff44674ce2b3"
