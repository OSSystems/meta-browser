# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1e1a1928d68983014a7d53e92d71007d"
SRC_URI[sha256sum] = "167f862e752cb166753da9a8c303d081f2b4cdc5aaf6691b129c8dc48160bb60"
