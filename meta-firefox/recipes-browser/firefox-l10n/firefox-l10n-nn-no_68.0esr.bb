# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c27fb1ef45932e407954d0c51af6a09e"
SRC_URI[sha256sum] = "d0721e08415c7efde9f8561b300e1c2e9fc156e22f237fd6635772b85a91f7ae"
