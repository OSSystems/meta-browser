# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dc6453ce9925b512e655ea38ea536afc"
SRC_URI[sha256sum] = "5974318530a428b73cd8db5f3a63adc0f161bf0a061bbb673e833ceeea26de81"
