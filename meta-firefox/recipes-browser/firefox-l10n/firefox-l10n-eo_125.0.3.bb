# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7e187f119e43b7bac14155b0c5f79c66"
SRC_URI[sha256sum] = "50a95834f45e27bc5e17ab9562b382cb595611baa83f02a464c340cf2acad3c9"
