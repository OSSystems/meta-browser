# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "60fefdedb9044c790df9b24376eeef5f"
SRC_URI[sha256sum] = "b2da49b01bae5cc2bdde845a121c9e86d55293274b0dc65c568d5d7863387805"
