# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "8418af9c4de0a724805268a6480dd4cb5e2cd0ec58a4108d02ce285be4a703a6"
