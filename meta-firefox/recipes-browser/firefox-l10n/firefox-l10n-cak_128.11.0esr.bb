# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ee94ff4faf21dc52382c5280c2ead43"
SRC_URI[sha256sum] = "e393ec6f5e86b343fb4997682e63c0ffe98c846d1ac6fe3596be6d1b5c1d51c0"
