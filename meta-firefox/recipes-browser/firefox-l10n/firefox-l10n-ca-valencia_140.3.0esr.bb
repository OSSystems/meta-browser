# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "412e2f8c885f998373595164d0b898f6"
SRC_URI[sha256sum] = "306acd71be6cd10194fa40a451a6543ff9773d5d7048384df70f25ef683fb67d"
