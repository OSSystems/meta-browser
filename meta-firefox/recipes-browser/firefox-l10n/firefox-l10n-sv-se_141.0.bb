# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5608598c9980a33e975c6d72895ad1d3"
SRC_URI[sha256sum] = "b03d0eab66d5043f0fb8b80bfb876a4f3dd38a93a0fe5c9de4d8d587d3c5590f"
