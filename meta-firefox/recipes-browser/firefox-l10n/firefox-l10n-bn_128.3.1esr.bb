# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eee9d3b77609380fbb20b8da1f56d22d"
SRC_URI[sha256sum] = "949a6f5d35bd76032f2f09c16263debabbbbb9d52294edf2bca4c1dd46535d06"
