# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "41168914208b7f41744cae00a60731a4"
SRC_URI[sha256sum] = "84ae5f9d5498358d9516513ccf5de627a20324c1d0b7071216d424f117839cfb"
