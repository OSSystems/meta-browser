# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "34ff00053a430c429db5a32d80c5abe1"
SRC_URI[sha256sum] = "da41506c085b61d29490dcb2a43702d2ddb101394f9507c6b4c40192d4137ad4"
