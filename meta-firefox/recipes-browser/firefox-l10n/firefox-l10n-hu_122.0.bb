# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "96fa35ac7ffdb56b9d9709a8d69df521"
SRC_URI[sha256sum] = "74bddae4786492a0a2ebbc2e4b64ffbe5700169ecb26451d9c0d2f88d02028de"
