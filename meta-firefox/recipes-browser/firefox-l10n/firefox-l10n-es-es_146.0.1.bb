# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b7a7d34a17802b21c3e3ad007557e69c"
SRC_URI[sha256sum] = "881f8fb469771a1e1b4591062f8dd21a4da89ef9d8a932228566ac3b55de710e"
