# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b2c9aa7a16dde06e28546e256fb98c60"
SRC_URI[sha256sum] = "b19b991369e7864bf79d9bcdf6204199fc4e62993f37fb5a698dffdef18b8a92"
