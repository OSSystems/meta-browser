# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d805f7e348c8f4e55d3b9a831b72ea67"
SRC_URI[sha256sum] = "c15bf4add412fe2651a0ed8a02b11bfb82c387169c1f92218069ad872cc3e118"
