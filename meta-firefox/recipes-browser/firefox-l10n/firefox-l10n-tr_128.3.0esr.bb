# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f6da0c716365fc4171dde9ac40014dd8"
SRC_URI[sha256sum] = "30756c41f1a36fe664ad500dbfd4609f762abd3e21208eda60ec7cc04f804524"
