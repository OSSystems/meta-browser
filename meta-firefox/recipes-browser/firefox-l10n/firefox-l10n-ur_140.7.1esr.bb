# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8b0711aae46062e2eaf2449acbad3342"
SRC_URI[sha256sum] = "73fc7def645931ccb27f4ea930cd72c4a401f7afea3cf9b5100c9fe2b86b64c4"
