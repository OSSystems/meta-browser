# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6cb89828291042f2c9df13ed5ad02034"
SRC_URI[sha256sum] = "a717450b36887b713640851462ddad8242351938800cb860ffd2a2cc90745029"
