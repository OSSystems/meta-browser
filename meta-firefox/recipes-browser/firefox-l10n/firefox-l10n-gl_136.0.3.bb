# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2008b45a487f3494a06a02656a47ad39"
SRC_URI[sha256sum] = "831b02149b25dc290fe39e410de2b713bfcae65c121deb18edca192f6fbb2b58"
