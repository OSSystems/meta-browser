# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "71d444a4bbb757e642aa57cb8999cd72"
SRC_URI[sha256sum] = "9338afd93249fcd1e766d3fae11e935136b5415446e8dea64334605141aeb31c"
