# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ba31184fc33402b000c56fe513801355"
SRC_URI[sha256sum] = "dfa57e05fb0986696d430c11f34dadab365583d9b99cec28b205448329795b04"
