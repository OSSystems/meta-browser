# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d2e3f1de95665627f70b1fe4d88c4c53"
SRC_URI[sha256sum] = "1e5f521bbd2954f51f47e270f552a84701d26018eeaf91eafb9b7b81b45ba680"
