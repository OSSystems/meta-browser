# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "097c50f5b62c3be574f61c27db218afc"
SRC_URI[sha256sum] = "5af7b5c1b20648199433c094568e770267ba2cedb0cf48743a240e9d3d3d0e63"
