# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d00c2df84ecac57de4d3473bb3c2dd91"
SRC_URI[sha256sum] = "7feb1bd99851dd5339b40b3990afa61b3a7dbf5bec1c221742c965725db5cebd"
