# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3c043339fb71afd1c5c046808dba1b85"
SRC_URI[sha256sum] = "341aa89750aa68d105a45af53dcd01ff7e8b4ecf5267c9700407df11db565618"
