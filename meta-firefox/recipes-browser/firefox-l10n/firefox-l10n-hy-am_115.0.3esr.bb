# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b994aee7de5d7355f6fcec88c91ea85d"
SRC_URI[sha256sum] = "3dc7a3b620c0f9e47ddb4810e32c5b30cd0ff605b4887e39bc6824495e24ac1c"
