# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "13dd15b345d03e3df900874302699d54"
SRC_URI[sha256sum] = "be2acf53003f48ddb81024a6214eb69ad3692bbf91710e08950d076bd163cd10"
