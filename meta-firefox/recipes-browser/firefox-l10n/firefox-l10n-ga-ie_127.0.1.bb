# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1fcd87149056f2594e472fa85b74aa22"
SRC_URI[sha256sum] = "8f3ce820749cabbd581854ef2a45104fff7bb6a2a0e3a9a3737b4cbb0448c699"
