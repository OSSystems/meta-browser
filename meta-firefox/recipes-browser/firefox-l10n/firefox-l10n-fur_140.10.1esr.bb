# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "b8f28e6e7b56907dacc18c56b80aea7b6aa715746688fa7304b551250610aa86"
