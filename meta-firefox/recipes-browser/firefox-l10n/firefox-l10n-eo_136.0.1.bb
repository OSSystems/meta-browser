# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3a7606c18e6f0460688a01734078c7c2"
SRC_URI[sha256sum] = "93cbe8d01e01cfe4a28661c083250d741cf6fc4d36d3bb6f06363ffaf5d90151"
