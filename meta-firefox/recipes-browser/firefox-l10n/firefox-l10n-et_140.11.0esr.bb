# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "cbe95826b45c0a1a6f0f69fac97001f589834f16a1b2b2da97ae227b32311bc1"
