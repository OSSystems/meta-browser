# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "89c94b0e8c8c1f78feee94c78110db3a"
SRC_URI[sha256sum] = "9edc26a66e9ea8a691c92d59f8d5a6bab4b2c0076209e0517413e089e379f6eb"
