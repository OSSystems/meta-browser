# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "964d3cf21a2421f5323725c0c32b9fc9"
SRC_URI[sha256sum] = "1aa9d7c815eff2e452d6d8428582b5f35e90d06725c82473ff61c1327f7f5844"
