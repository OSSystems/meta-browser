# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fd38c80eb856065f08862edbb301688e"
SRC_URI[sha256sum] = "9659a6fca52520e4b562235bba02d473f189de4ca833a7e96102314faa1e4459"
