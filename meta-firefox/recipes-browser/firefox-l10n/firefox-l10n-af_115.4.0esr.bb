# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "45dc2a55e471d93ec736c70ce54bea09"
SRC_URI[sha256sum] = "1f751b3845e02cdd8a13451ac8c1298fff1f7e8772bbd772a4692ea3aab348bf"
