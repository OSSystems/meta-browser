# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a073ce9130257c5bbf72111aca734916"
SRC_URI[sha256sum] = "a9a4b97c0e3e7016b3f96b316dc623f8518c3a87a99e59cfd6e9cf142939a671"
