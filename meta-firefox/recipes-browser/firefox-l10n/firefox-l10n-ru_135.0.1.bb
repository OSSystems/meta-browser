# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c4de458d7eec514ed690e5dc1e76795d"
SRC_URI[sha256sum] = "9dd48c9b78e91e4ddd8d4cae8ad055d559a8aad2d2132d99d14e0c2f35224255"
