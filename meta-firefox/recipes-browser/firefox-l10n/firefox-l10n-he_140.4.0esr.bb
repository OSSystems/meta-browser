# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "971351b1559668d7d8438a5c443f1d3a"
SRC_URI[sha256sum] = "03afe8e24f7dd67d60bce82e21816229731e71ae3fcdb25b763654d26b721980"
