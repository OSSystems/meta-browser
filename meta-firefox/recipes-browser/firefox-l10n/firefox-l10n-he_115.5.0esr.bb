# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "19e2329ca0bfdd8797bf5d1d1fe289c0"
SRC_URI[sha256sum] = "803dccf40e0699fa9c6cdcd66084160e692fed154c89f0e32dce71a1d09165ef"
