# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db7ebd0358464e6ed22f1dd4813541ac"
SRC_URI[sha256sum] = "56ab51415dac166d91390a3f099d78ed7a0d0570e5b3d4484a923d684455a1d0"
