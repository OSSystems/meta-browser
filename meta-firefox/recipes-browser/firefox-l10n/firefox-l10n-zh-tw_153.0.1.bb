# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ef1d0dea6f31e5c710e3cadbffc68ef583c97eb7ad3aa43cacd073d4abd1292e"
