# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "dd24938172eaeeded6f0b7b3bb4d380088555e175d2fa4a280925bb10391cecc"
