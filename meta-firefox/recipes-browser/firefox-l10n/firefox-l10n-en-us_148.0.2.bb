# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8982ba35c080fbec293d4a05a0b95cf0"
SRC_URI[sha256sum] = "ffa7f535fb143ca140fa3a451a53271acf9732c5d0fe769e36f473cc75c4cd56"
