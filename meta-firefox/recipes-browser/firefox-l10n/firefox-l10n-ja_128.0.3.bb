# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e2031992128bbf03938ec8e2e8320672"
SRC_URI[sha256sum] = "ea572f07d32b83768d91c868921bf63d484c6ccb8f46b5710a2705abb03532c5"
