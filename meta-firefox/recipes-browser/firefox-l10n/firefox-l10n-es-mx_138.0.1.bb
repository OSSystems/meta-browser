# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "92acd6d6a6f71b28df49c89d9f06b1d4"
SRC_URI[sha256sum] = "8f4d57e691b666c9ade14471bcd38d2760197328cf8c0ede54c050f4bd3be832"
