# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d2141e58275949004c7a92dc4c011a91"
SRC_URI[sha256sum] = "d918dcd9b410c10dfc8e97ddeedb51109eeae2f9d53072f40914850a1ce7b189"
