# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "29594918c9b5019dc4f8f4cc2ff95a1c709c43078cbf605a3f39a456d54a0ed5"
