# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "615c55724fff3d5142bd8ec9312682c272750de83caeb2076888ada225005e9b"
