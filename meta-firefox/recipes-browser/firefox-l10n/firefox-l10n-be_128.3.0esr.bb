# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dddc7e181922cfddd37c54b7c471b216"
SRC_URI[sha256sum] = "bf1e1df08d554dfa0ee3d328ca43e6d204cfaae2447f74e7750f2a0087e223e8"
