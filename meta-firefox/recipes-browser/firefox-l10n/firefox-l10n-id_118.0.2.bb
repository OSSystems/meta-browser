# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5d64c1b7a50186d9a1eb36e50d700f56"
SRC_URI[sha256sum] = "897fca2b24f455dfda274ba501d7c448b3a3fe8b7bd243c4d4da7445c5a163e0"
