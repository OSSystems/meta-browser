# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "88fbe5300c97c2fab326c1bc46d50007"
SRC_URI[sha256sum] = "5632559e770d5d36217f6679a14671c99dbdd22ef2367629be77ac40572dd4d0"
