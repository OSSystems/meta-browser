# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "183a24f2283d52cb6ce2589923ee192c"
SRC_URI[sha256sum] = "624e96cdf21c53af75bcabe8932ae4e262324ceed708163ea13cad46231b6342"
