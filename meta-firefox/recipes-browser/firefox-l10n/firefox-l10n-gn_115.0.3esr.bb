# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "41a527d23be21ced9d5c1f025c49f264"
SRC_URI[sha256sum] = "24aac4d6fa56491fbc71dc06c108b3871d4d97e23f9837c09d6280bf94f92522"
