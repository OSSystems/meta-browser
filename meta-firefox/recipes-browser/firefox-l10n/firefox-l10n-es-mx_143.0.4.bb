# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d700ecee72b88f2baee85903b295ccc3"
SRC_URI[sha256sum] = "8a3569f2a2ef9b18c1518626bb151c1a69271003bfebbe6729ebc52d68bd8a7a"
