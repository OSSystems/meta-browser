# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "523e135d44ec300e81cdc5070b4d566d"
SRC_URI[sha256sum] = "34e6e3aa7fd4cdd3cbf65f3a3f16ea1949e99c393b6efd776c272a009d719a08"
