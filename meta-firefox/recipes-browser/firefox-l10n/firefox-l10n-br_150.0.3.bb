# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "65758b71a1e461b49e42b6d03cab765a402b7d886be312a0abf3fd64ff6d6823"
