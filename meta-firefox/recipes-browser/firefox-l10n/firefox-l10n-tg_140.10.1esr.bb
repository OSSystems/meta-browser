# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3243e6587aee99ce0ffd44be82d3bdd96cf16f0ac6a91c1557315a917ba9e605"
