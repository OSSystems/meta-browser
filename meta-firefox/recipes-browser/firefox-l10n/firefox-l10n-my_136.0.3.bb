# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e84a2a2f84a720ae67154d6a69a15e63"
SRC_URI[sha256sum] = "eab58eca34e1c6375c87ccaf5e3ad7e9f674fe9d509c5d1f9b732625f5526bf4"
