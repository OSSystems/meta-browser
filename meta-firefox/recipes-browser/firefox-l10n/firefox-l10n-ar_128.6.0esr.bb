# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "207b48190e64f70e14821de225c707b1"
SRC_URI[sha256sum] = "c98f4b5cb76635aaef69ab84b4e2b38b7caf86e9836c9e014242e7d6d9f08614"
