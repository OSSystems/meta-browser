# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "566e57a3c7277ef1d9d798e21d219d72"
SRC_URI[sha256sum] = "e56d845c76789df4ce81b909190fccd9d920afa6d21202bf245c98318a930c32"
