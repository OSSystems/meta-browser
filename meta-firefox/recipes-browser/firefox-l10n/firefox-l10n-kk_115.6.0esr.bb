# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "48b2f45874830182cb81e06bfea2b1be"
SRC_URI[sha256sum] = "687a366cd99f9e3c9bfab47ce4dd94c163b9a5d775e7cd696cb7808e3b3511bb"
