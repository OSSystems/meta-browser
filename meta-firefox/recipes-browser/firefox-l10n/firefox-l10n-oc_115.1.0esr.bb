# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f0debbf57ea0c0a0639d1d23cb62789e"
SRC_URI[sha256sum] = "4fcd59f4b44db5b8e025957480951c92e036044a61b7d328d84b022c1ca316d9"
