# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ab7f4c9b142305b80833f8f193be17ba3e3313f0b5fa0dd2a890c111ee88ef7b"
