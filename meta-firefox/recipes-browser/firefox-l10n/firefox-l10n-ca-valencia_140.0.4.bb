# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a5ff6731c0782ca29fcc774e859d0c54"
SRC_URI[sha256sum] = "5f05d4a0c6e9e9a5b14f06f7d5c2e13ad358ceb6bdec1e067d4bdec40d4bc5c2"
