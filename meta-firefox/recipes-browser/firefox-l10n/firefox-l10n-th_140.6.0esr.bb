# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4939503cd9e45727b52eb99df730f29a"
SRC_URI[sha256sum] = "9be97e5b8c2892105bdd47421a6520a01788cc006a7f12afcc9f945836fa20cd"
