# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c542ec7791e428feff643e82964b33ee"
SRC_URI[sha256sum] = "806850f0b2e80a9b542974ba137c85b3d89b1da7cca239e138a807d63adbe29e"
