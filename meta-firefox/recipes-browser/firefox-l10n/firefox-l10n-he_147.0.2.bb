# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "60b1c50e257fcbf5df3728a32d613e99"
SRC_URI[sha256sum] = "3279774924fa8c328911946a5a138464470d93a5bae1369f3e983247763cf6f5"
