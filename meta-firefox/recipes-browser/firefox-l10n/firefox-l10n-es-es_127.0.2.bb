# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e64e2383dadc3c857e90cbaa1ddf21b4"
SRC_URI[sha256sum] = "38c0c0421e893a1eb3bcd2fdbad6a68fc7b9ce00ad59ff8c3a306bfa79a35091"
