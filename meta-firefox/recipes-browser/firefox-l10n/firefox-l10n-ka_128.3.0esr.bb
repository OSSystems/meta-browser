# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "579d82f211ef846f11e3f9310d3f8197"
SRC_URI[sha256sum] = "904acc2a1ae80ec1319e6a7e93f95f5b10ac29f2ddbb678ea0bb679aa25287d7"
