# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2ca59f2c0526ad08be636278f4141a5a"
SRC_URI[sha256sum] = "81be417a5f938033671672a4e602925db959d4fb0ffccee56384f4eab7dbc92b"
