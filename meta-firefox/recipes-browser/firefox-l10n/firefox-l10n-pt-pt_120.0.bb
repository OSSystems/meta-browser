# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "593ecc6baf09ae012e6313a170c6ea96"
SRC_URI[sha256sum] = "a3f217ab87d8d65582f247763920f2b14ac92d1df4417f718ec9c070942e5a88"
