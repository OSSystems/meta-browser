# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b2360d0912b701724125b193fa47b3ca"
SRC_URI[sha256sum] = "8d174b7a11131a2ea59c0b979d58ad0fa0e0afe53e477d57467d7016c061ef74"
