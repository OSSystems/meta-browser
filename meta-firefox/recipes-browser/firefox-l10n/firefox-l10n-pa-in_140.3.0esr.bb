# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f9d45e83d87209d81da22afa729d6d72"
SRC_URI[sha256sum] = "4de2035cdfdb429c95c67395c3fe70b044d98fa7fb139c6b19e6106f01fad823"
