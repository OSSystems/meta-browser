# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "028b81ed3d7bdf2e6ffbd0fcb1d3bbb6"
SRC_URI[sha256sum] = "0035fe2c66dc16fa5be5ffd7059b67aff61dbc0ce901ccb8df06b6f69363f293"
