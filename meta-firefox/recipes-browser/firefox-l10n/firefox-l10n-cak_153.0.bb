# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "b2741a0ef87e0445dd99efd1190d2c469d70d77f95cf79aba0950597cd2b87b9"
