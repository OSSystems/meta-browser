# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f8dc6f47758301e18252edafd8c48ade"
SRC_URI[sha256sum] = "2ebafaa8351714e2d0bc887c64c917c1e86f53a5fe01e0084481d1e64bb05a1a"
