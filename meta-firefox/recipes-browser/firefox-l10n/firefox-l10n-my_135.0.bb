# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e2345cad322d796a6bacc22eb0d476c2"
SRC_URI[sha256sum] = "0f8783aa62d81c316104c4f3f0c146d48ce6ac3530cfa539e20fbcb7e45ec91c"
