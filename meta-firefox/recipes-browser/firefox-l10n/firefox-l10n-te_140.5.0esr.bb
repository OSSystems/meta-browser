# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "102eb2074ffc50214ed5d8fae1b76f89"
SRC_URI[sha256sum] = "bcaff209260a6f2e2052aebf2f03aef98c3d2fdf529ebd079178e434f0feb268"
