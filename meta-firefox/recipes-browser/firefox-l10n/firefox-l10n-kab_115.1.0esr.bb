# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "912e015e290a571e22944aa847912be2"
SRC_URI[sha256sum] = "89a8298997d9fa10074ccf1a4ed2be6b28f2bc2fd4025de35dfef500cac97d99"
