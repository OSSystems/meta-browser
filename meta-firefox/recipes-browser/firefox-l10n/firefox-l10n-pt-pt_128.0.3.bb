# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "003b57abe6072aa5366d341e368f5e4b"
SRC_URI[sha256sum] = "05c4067066c26de2aa81226e76333dee1efb6c37bd5c00046461556443ac50c2"
