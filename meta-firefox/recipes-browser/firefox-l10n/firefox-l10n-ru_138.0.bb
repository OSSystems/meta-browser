# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1336237b0f8151181a9c6fa7a8616319"
SRC_URI[sha256sum] = "66bfdbee946bd3253aadb9e8e94789d86ac4e076c99a8dfd5d7e1056cab58d25"
