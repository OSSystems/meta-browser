# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9d64a4eee9c5536dac7cda0fe49a1309"
SRC_URI[sha256sum] = "420988bc00b81d77755a61546e4fe828f3a481f6d68f12e218a0475c3343ab01"
