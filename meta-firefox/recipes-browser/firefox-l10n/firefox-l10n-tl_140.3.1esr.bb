# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0cbd61fd4b80ada6c967469f5feb639e"
SRC_URI[sha256sum] = "08bbcd4ce6192aeeee7b2e4bbe42937bd760b1c9d077765f2df0d9ed9692d860"
