# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b89786d347d60ff5cf5b304d462c9217"
SRC_URI[sha256sum] = "873325964e70145781c99fd0953f5fbff35e80da761881c6fc816a7d47cad586"
