# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eb76e9a1511130cf3b59f9f9cb334272"
SRC_URI[sha256sum] = "2bd400c7bc1b7be7d3adf8fcf78909327577cef07c1b3ac7a11b92c536800f4c"
