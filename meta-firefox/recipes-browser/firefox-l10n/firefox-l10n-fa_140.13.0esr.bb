# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "a33ead7b174ac187912c3ffafc8c336e3c14e8b889312f64e37e99013ca5ef3b"
