# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5b233d1db42a45e7abfa23c2593faeda"
SRC_URI[sha256sum] = "e3b9d3cab6e3b586ee5c5de1ad44a8bbaa5f1458200cd266352e65a7f94ec374"
