# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "484606abcac0b7279d689ab6a822e65bb24de9d62eb3bf0332962a556e55e43b"
