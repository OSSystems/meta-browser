# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a26b9f401e7cc8cdc9d5e0de07f068fe"
SRC_URI[sha256sum] = "28c322a19700777ef7028d91fb54f1c5cb6fb1ad828e80af77c0341e784ea68f"
