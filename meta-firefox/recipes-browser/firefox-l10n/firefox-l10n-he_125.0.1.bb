# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "07e1f838a176124125374e725dc91305"
SRC_URI[sha256sum] = "c1e551786423b71272f2f7b71a0f06a3ad65b2f902cfc965c22bd359fee9475e"
