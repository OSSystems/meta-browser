# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a3519624b12ec68698939fefda4f36a6"
SRC_URI[sha256sum] = "1979a7f4542a02c2fd2db5eb114244e875335fd0445dc7c9ab963d23bf02ec05"
