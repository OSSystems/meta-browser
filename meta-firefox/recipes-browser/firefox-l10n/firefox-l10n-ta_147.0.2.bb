# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a38568fcf4d6c242cc5b92a9f7cc0b74"
SRC_URI[sha256sum] = "0c9efdfa29b99001ac2c80b588700bac10253f79827cc5fdb8acae9f4fb4f008"
