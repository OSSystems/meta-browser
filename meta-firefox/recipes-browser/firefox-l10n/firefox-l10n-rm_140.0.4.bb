# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "46c78c519a485f5e56b21727ebd2b916"
SRC_URI[sha256sum] = "fff08abee43026d9899e656b8df34c1b45ae5b754b5f24b85039414a1f9b5057"
