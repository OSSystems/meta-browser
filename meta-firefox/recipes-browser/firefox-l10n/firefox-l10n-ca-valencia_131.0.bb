# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b6800054fae4bc38191731afb58294af"
SRC_URI[sha256sum] = "7b216eb75385ed0eb1cfc864a3ab37986f589a69276e1eb73323b065812ce68b"
