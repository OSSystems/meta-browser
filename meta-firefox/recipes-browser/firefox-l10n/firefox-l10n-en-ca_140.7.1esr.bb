# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "adc3d38912c314395e3032c925c96200"
SRC_URI[sha256sum] = "8c0c53bbe1b8745d9ac0d8293046ca568cbd0f0616cca63f739e129c1e48b17f"
