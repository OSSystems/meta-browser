# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "72613f673e8ffa1c7e5095e7e655357d"
SRC_URI[sha256sum] = "c64ab2c8e7dc07892778f42ac1c1d6fc65d97ee903dac26dfceaca84725e6933"
