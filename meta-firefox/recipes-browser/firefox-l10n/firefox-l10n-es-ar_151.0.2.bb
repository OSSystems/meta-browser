# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "bbc60a55516f0f7dd90d8cf5d512cbebb1a51d71a145e3ba577f62227e567dc0"
