# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f9d53c81ae93e0097ebc83c6dc7ba5a6"
SRC_URI[sha256sum] = "2363fc447c077d6084d34c4c2f4df0ea37886db9deea177902ec40d7c20487e6"
