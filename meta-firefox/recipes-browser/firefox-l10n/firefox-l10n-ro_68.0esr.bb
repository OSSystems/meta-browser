# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "afc7107f728245b9bede4c77ff51cd79"
SRC_URI[sha256sum] = "624928e810b36262e05a8c6369eedb950a3124b888fe99972e7ffbb8de07335f"
