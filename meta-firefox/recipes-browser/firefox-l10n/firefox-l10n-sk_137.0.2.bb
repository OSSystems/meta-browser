# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e41afa93dc01c9f1e0e83c700310a362"
SRC_URI[sha256sum] = "19a404e70dbeceb10106d2bcc798eb24471201b4139cd59d2888da3ea742321b"
