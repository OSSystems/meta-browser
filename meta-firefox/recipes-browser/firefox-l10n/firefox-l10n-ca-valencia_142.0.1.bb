# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "878036830ac5b26d9049dca3736f5b07"
SRC_URI[sha256sum] = "f429b4494139e6fbef4097d7b2a4fc8bdcc7d61624cbf727ba2437746525ffc3"
