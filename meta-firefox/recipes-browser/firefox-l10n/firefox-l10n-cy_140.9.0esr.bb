# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a37ac81bab133f4c78fafefcf42c3411"
SRC_URI[sha256sum] = "e923f2fd7902b8eb3400ae88ac48195099838b6de15821848ee9e59d96eecd27"
