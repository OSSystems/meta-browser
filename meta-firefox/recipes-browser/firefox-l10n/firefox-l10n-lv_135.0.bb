# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0746e74238e6693ab00dd995ee382287"
SRC_URI[sha256sum] = "3b3c350fb90155ac27f3de2b5005f913ade861a7bae516d679f720cb497d5feb"
