# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fe6c4827349014d9352695caa5804155"
SRC_URI[sha256sum] = "6ad3dd7f0553269cf9cea99c1e8a79fa1e3dcd3dc836bc7352824fdf3970355b"
