# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "6bd83b272f35659f372d7a4c82ee3711778256d87ac33ccdeb567266b9747812"
