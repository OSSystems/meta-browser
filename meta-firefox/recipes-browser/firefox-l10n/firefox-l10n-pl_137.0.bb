# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "88332e2b3aa65589f7b8adb8ad2c3217"
SRC_URI[sha256sum] = "0557010e12cbe233e802abdaf43f3db3e33400c2d73d2a88ae7358eaa226b32a"
