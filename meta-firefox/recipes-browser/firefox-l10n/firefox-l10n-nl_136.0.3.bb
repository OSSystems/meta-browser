# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a782d1efd08ca5161a2861e38c1b180b"
SRC_URI[sha256sum] = "b6d7d83786ac2bf6e5bb6f09b35e49c0d3bcad1c589121df6737512d6b780e4f"
