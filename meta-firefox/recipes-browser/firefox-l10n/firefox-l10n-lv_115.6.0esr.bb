# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "37aaa84ac5dbeae5ccd35880b2f41bdf"
SRC_URI[sha256sum] = "805fd87b28cefc6126c3bed91cadfe278673b604a7422d15bb6297edec1f4911"
