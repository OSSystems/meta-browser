# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "a758ca265e721518a9f84472253b9af032203467d844e6c16425afbf274ec5ef"
