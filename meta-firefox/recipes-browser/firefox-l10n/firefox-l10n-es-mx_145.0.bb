# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5d56117ea59bab1596370293d583d9dd"
SRC_URI[sha256sum] = "b206f3b6d8db0ec2c545b11527c629815a717e74e3e59a6e7ca2310c23b70f9d"
