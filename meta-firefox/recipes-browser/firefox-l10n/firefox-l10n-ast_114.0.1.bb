# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aaec8a91681e3a68fb7e192564bb750b"
SRC_URI[sha256sum] = "4021a887bbc044ee6ff3c522f9b8f5c1b1870ae791a00b33f659a26f7f543c9a"
