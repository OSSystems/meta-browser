# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4651a39ddf045bbfaef018a10e1d8619"
SRC_URI[sha256sum] = "20d239f7c3e58f191ee99198e64c6d52d011545f234bdc04cb58a7c451d6d1f1"
