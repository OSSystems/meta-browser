# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3e8954e66328bbdddf8f61f29f3f3140"
SRC_URI[sha256sum] = "1903b159fd04b960ee39677c1fcf266f8401ad95c1d2442a9fbf8f9062c6e1c3"
