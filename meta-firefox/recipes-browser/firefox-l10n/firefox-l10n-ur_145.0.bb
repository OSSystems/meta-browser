# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "57f2102d1ae8cc6f6e832e5098fb0667"
SRC_URI[sha256sum] = "da2a88277c9819a4030908aaf92658b42a4059aeb623961add461bfcbadaaafd"
