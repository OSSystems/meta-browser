# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "03b22f80d81c89dd7b71a147b50a65c9"
SRC_URI[sha256sum] = "c9fcd46d8f83542dd4254e14820886399545e989f0f696b05b318793b25993ee"
