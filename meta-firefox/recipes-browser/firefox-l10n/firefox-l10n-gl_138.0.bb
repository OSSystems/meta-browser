# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "230e45cd9201b366119ff9d040eedbde"
SRC_URI[sha256sum] = "992ffd8080ee24106b56737d997f7de6781fd9b99b5939ddbe6f631a8af254df"
