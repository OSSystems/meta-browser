# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "91ea62ec7da46e4ec6e1f5678100ccc5"
SRC_URI[sha256sum] = "b9b41c4ab36ce58ca71099748ae116be6b3dd784ed9186ed4a114aa699f8897b"
