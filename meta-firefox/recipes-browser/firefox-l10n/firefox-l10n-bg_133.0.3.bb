# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bfdbaf790cf4c992b9d041dd63a1b0d3"
SRC_URI[sha256sum] = "1580316f3bf8b45b06335255fc0684df44a2d9d742683ba5880328acda465e70"
