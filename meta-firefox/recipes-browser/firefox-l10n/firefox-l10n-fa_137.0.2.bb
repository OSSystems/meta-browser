# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "71531c8539662b3bdfd7a9eadb1e999f"
SRC_URI[sha256sum] = "3f6a749e5f95831583adf61e14f3fa4472f266eda55947d01d97019da9879fec"
