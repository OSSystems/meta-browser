# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "64e608aa0c37bd114bd48c6536673dda"
SRC_URI[sha256sum] = "bc7808a897fc43e7a63f982ac1024d2fba33572e9ae711b000e309a601971d04"
