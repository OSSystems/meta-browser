# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "53e8d417fa9a5701c524effacddbf5cf"
SRC_URI[sha256sum] = "c0b2eefa9d5f1ee82cad5c36e54c97ba3c7ce16cfda292a19ec7bf3d42a99120"
