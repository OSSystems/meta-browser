# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9b5d8a9637388a0b9d6621782a5fb4c2"
SRC_URI[sha256sum] = "8ec2c95919963ed1e05be1ec5df06ab426377581972557cf95963f1193dc5550"
