# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6d9ff27c96a4273d6e7f366889fbbe1e"
SRC_URI[sha256sum] = "f2717699a8273dda26aea52fbf1b2c8f228ceea5bb1a5aa0478a22af9262698d"
