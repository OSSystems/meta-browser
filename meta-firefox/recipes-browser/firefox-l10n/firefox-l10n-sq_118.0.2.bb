# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ea42ed581591238196c027bf6594e1fc"
SRC_URI[sha256sum] = "a04b153335735bd845a9b1982e43f0c5f44328ef770ecd0b9680a8bf7c878e1d"
