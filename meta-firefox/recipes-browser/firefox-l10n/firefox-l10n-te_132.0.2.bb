# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a9a8ef7839a1e67bb2e85dc1aebdb2e2"
SRC_URI[sha256sum] = "9774d755742d81996788d53ff30b74c7277ae33963e7d51d703247346280b475"
