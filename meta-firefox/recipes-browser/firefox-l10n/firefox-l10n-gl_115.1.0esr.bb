# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a53702e2285d7c3e09bbe3150302ba49"
SRC_URI[sha256sum] = "057fad8083ae7598997234e558d3ae8d82d6cf94ea5ed8c48400b0cc5dd4f0d8"
