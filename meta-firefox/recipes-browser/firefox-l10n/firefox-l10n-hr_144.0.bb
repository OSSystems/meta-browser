# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e0f1aab02862d2b97af199cff73e1e8c"
SRC_URI[sha256sum] = "a02036a7ead3ab3dd05b4ddfc3b2ff5da99619fffdc8bc75e12c566805bf23f9"
