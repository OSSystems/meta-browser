# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2d5c8b232b39c2686585cdee76d57fa1"
SRC_URI[sha256sum] = "f54ebf58831e8b559cb00e748dcceaa3c761288dfa0e557103a18ae7dd90baf5"
