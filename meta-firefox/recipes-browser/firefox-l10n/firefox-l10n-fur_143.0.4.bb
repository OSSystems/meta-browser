# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "41bba894d70f5cc34a448e5fba445c1a"
SRC_URI[sha256sum] = "e60565d4bf9f9c2b9d634093f918e6eef7d3a222723f28961c1766065b5e0362"
