# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "86eaf7c9ba5d529bfffa23fc9265f97f"
SRC_URI[sha256sum] = "36d0d1d1e50e00837a11bde995c0b40a5bd30e194f4ad7b92f64b30d34ae09d8"
