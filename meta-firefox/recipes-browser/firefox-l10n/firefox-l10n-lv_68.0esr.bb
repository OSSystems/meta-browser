# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0b53b9fa9d99027f47d7c6f4f7894a0b"
SRC_URI[sha256sum] = "bfd47eeef4e22255f2302c0f5ae366ab8a4d181843f31f27352922b80a3de772"
