# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "79c102e6a31a2aab28b4a72de181a3a7"
SRC_URI[sha256sum] = "22d8a7a827306d70373c8c443dc83dbdff052024aa503d2203991f6ce5b683d4"
