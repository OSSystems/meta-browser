# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ff2168bba2b5e0127c3b3ca66859bf84"
SRC_URI[sha256sum] = "cfcf341dd8ecb0d67b44b9dcd11d5e650a16b4f47f6da1c9378886284a1eae54"
