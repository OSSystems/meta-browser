# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6d29efc6269f8d4c2de149dc7939cc51"
SRC_URI[sha256sum] = "657e3e0445d88b04ee24f640efba65bc1a1b334053a0b38cbe3662ebaf903784"
