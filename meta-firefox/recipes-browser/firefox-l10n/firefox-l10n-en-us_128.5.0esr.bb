# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2c158e30491ecae248985212c49db2d4"
SRC_URI[sha256sum] = "cf3a93798684f0fc8936ec56135452e96df5bb857edb7a7e539d6735af313fb9"
