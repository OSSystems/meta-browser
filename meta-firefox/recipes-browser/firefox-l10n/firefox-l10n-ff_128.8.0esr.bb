# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "73d13e20391339abb5b9c83cb86a118b"
SRC_URI[sha256sum] = "9fc45ca068b6e2035229568107c1528896df2d756d12bbb25f6bf5d59a8e7bdb"
