# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0ce501d9b1a8016998132063931d2aa1"
SRC_URI[sha256sum] = "fbaa8fb8b5dc95b9d75d3a28e6adcaa42df1d31e1b82a709583046ef4638dd28"
