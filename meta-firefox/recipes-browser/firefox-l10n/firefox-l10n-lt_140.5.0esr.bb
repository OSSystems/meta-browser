# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8808cf77877d27e01a983482afa30fff"
SRC_URI[sha256sum] = "adb2b4617d94d5ca478086895bdcaa0cd6be765057201649bfe8e52a5a8ad417"
