# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c4f00863a6cd9451c0e3d5bd440ba19e"
SRC_URI[sha256sum] = "dd2bc918be123455bf9ce336994c8e7af214daff56395eb3171d63c9adc73161"
