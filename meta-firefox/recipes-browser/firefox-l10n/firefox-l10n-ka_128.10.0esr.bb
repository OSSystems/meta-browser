# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "95eddff315664f0b5f87bc18c376871b"
SRC_URI[sha256sum] = "ee3dc1ea4e00d5aee2c49bd9d92ebf5f9d4d0e33b87dd9aa347b8ed69e2343f4"
