# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db9b9c9ea47db1a021115a5a5eda5180"
SRC_URI[sha256sum] = "757ef89d1bd21d0aaa8614e308d96c1b5b227d4edc9c627c1929160874b65c63"
