# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fbe71798adc2a4396e33a63d123c098e"
SRC_URI[sha256sum] = "75c7e85c73948f8fce75a3816037494e010c2484135b2981137c34fc994936ad"
