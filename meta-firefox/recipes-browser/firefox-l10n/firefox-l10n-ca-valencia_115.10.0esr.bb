# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "62f72b2b73abd86860aabdfe286a24c9"
SRC_URI[sha256sum] = "555ed2fbf37f4e6ddfa8a1346019126fcee77144387cded79546281d975cf16e"
