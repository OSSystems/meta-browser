# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "76cf1c027176c05f43ca065533b88197"
SRC_URI[sha256sum] = "83d50a2d4e20a7b80d90bb8597ae65ca25093ab17431ebd9902347d040a21ebe"
