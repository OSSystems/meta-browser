# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dd46a39ed8e032ce8e3ced8f1d6a2223"
SRC_URI[sha256sum] = "d161c8b63bda2a5a2b6965ea5b6f927db5ae4c9d10e543199967fc99f3522ba9"
