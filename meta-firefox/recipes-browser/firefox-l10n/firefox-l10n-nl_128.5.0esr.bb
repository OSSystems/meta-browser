# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4aa51c1f166cac727c0a9a4db0fcc468"
SRC_URI[sha256sum] = "905e0a1f539b7971fbbb9e68e8cfeb0370aef0f347717a1f473c6dba80582646"
