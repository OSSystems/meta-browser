# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "27cda31363b114992fac72a29e6188c6"
SRC_URI[sha256sum] = "76495eb595c9fd4b60dc4b10b3f61af9a66539a8bc7ab43c92d186e820b2c463"
