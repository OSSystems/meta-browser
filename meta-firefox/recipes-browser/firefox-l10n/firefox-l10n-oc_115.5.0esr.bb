# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cad83ad7ad4c4cb8d9b863bf056209f2"
SRC_URI[sha256sum] = "379f781a1116ffa2d9b97111e34f69d589bf55e47cfb8116a5be2fbfedb76ad7"
