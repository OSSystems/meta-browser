# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fad43d14fb942c9369f94c0896649e3c"
SRC_URI[sha256sum] = "266a19102baa1d4bc6e04112926f3dd91d4debff585a9183594daf9ae4c76aff"
