# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "cc05b49a1625ef8c5db2b966874d5d15586179480f7a1b01ee6f391cca416322"
