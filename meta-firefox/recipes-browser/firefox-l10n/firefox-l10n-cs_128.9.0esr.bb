# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c284044ce748c36c6fcb6cf745d6f8de"
SRC_URI[sha256sum] = "7a1ac972fbac570d9ab74c4d707ab00abd714a3f7897d819a2d3b78d3b2423ef"
