# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c116f42692db2f80cc93a8c591aacae3"
SRC_URI[sha256sum] = "205b6334e396b7cd9c60cf0f1e8c062b12f637eebf99d4d88fceb67e5985fe1f"
