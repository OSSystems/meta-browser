# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "55de2ea69c3431119e8a19ed0975942b"
SRC_URI[sha256sum] = "1018c0b910ec6d8a363d63014695521d6dc721c727fee1e8a9a57bf5e219348e"
