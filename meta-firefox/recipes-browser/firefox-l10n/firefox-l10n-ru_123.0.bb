# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4890988c82db4d4ff99ff8ee136cded3"
SRC_URI[sha256sum] = "b51736f7b493e65f9b9e76b9b34757cecd76a6248525fb6dad76326480b38e5f"
