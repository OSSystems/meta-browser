# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1c92c47efdf13cf9f2d146721e72eb7c"
SRC_URI[sha256sum] = "bef2d26b2679f84285e60bf3a5937321865398c92267c0b3faa1da850e8630d8"
