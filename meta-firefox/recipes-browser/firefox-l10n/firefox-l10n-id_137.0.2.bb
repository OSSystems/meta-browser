# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c8f5252c737e171358f6cbf2dfc7e11d"
SRC_URI[sha256sum] = "28e59b380ea7e5da0c1f69a4dbbf2fcb75cf22b00b7a623936b47289ac37631e"
