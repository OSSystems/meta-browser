# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "62197085683728d6e910f2ecf733a671"
SRC_URI[sha256sum] = "c37c82dccaa5852aebed339429a3a16bb5ab1721c08026fbc56a9d7bd5d173b4"
