# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "84e4aad36df329aaa1dcff14da1c4d74"
SRC_URI[sha256sum] = "cd755e22b187c382a0615239fccdbeaa0cfafd77b266f3fd103c3849728c2841"
