# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9e403ca6337a725750a7d755ed376b05"
SRC_URI[sha256sum] = "3ea6620adcd3725d56e359d60b38b1abce958137e9cd1de8955318622c5d9cf3"
