# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7435358cbc1453c4b96a317c7df2d35b"
SRC_URI[sha256sum] = "66bec925b680985488126c5da754578b523497dd24ada304029fb70320831960"
