# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7414fc58e5d490679144999877161864"
SRC_URI[sha256sum] = "546a280e4c983e32c8532c89aebc3252c7af45a744ed1cf0d66412ce1bd18680"
