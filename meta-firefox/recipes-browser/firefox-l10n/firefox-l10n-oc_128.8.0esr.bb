# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "31453cfb1e359957672b8f7ccbe6f1a3"
SRC_URI[sha256sum] = "550afa0ef4214ac668e49b138329651dec7da9bc37afcf90afba70c772338a52"
