# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b105df3accae36e30e2cfdac3086b826"
SRC_URI[sha256sum] = "2b4cac1adfd6731e2e0159f808279021733e8cf6c4cca9c4e75492c50d356942"
