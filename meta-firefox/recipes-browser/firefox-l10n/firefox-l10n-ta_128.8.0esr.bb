# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "45cf67b204d58c2ffdb9115db79a217b"
SRC_URI[sha256sum] = "64543914d430a24ad54234f5239e2e01c6ba38e72273559220065c69f9035ee6"
