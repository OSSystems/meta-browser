# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "97c7c57dec3a966076a9fd41ab59ca95"
SRC_URI[sha256sum] = "dac1302d3181f85420812e68d046162e08116ffe956831fd87d369c459ebc638"
