# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c6c287f0eb4df8d3776ff44663f1f9e0f02246d7670f6acc79c9cd48fa7e38f7"
