# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cbca616ed2d92fcc5e30bc64788620c4"
SRC_URI[sha256sum] = "515e89baaab89581b3231c34750c0f630bdc19496895db926d1caa524e8e0221"
