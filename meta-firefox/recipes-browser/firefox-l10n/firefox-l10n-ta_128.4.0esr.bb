# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "769bc65d08a4cc9274c1611989f2cb9a"
SRC_URI[sha256sum] = "e982d1a43d5050e1ec106bc03d3a9a76c8cb62175c16d253a3732889dd41a0c6"
