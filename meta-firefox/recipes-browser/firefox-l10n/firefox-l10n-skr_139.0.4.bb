# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e065dfc766822d563edadf92008cf0fd"
SRC_URI[sha256sum] = "68c8e2a032ce083b4619cd5bf70be5d81bb6d234a44a883cecf7f2c11fa53ff8"
