# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "62c1cce90797681d46b8728b5390019c"
SRC_URI[sha256sum] = "661747d2bbd2f1329a510df9aff8f41351a0a883fc7f7dd27175a2d08735b840"
