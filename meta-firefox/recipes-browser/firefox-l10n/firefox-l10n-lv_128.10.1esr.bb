# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bd1ef542b70ad622d9873d3e61e7a9ab"
SRC_URI[sha256sum] = "19acad792b27bde7002cb95d3f922623733c4d11eafdb7aadc496986f317697b"
