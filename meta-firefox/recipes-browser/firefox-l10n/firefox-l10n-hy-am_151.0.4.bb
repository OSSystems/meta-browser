# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "f822a4500a63494aa17dd9b4f8594472c6e27b2e0a607290da228164dc8d7dc3"
