# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "122bebec2a8ea363d3bf4b462ad625d7"
SRC_URI[sha256sum] = "e92b8ef1cb824f272b8d06c2f3783319965249f976f32eed01a6ce43c507a1bd"
