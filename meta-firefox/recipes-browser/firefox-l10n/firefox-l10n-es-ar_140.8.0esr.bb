# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "96358f55b4fe8739d4c68be897bbb99f"
SRC_URI[sha256sum] = "a1ead2a7bb6fb8cb3fb355280ee49a8636da3b0662b7d7ad810e3ec6285000df"
