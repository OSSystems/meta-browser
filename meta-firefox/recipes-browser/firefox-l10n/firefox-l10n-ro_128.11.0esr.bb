# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "20f5ea20732013fe7459ff36146a9a94"
SRC_URI[sha256sum] = "48f55decb03199d54c8e2b8b6171aec65b5a24fe18dd7024c491bd5120070604"
