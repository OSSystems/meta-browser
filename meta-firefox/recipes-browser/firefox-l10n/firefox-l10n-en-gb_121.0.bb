# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dc50251fa57b99b7929df19e28f1e60e"
SRC_URI[sha256sum] = "1d897989fdb080dfb4347b07714d0629dbc86792e2b8637400aa14ba3dd10169"
