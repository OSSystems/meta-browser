# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "52b3830776282002fe8955e31f2529f2"
SRC_URI[sha256sum] = "4a65b7fa202f7e6c30ec41059240d9cd5701c7b135167c5093a01bf243e40447"
