# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "828e34dc39dce94bfbda8410ae5d9803"
SRC_URI[sha256sum] = "5c03a67c2037ebe3e8e564397cb994f23bbff5cbba4828a4f667c182c45fa1d1"
