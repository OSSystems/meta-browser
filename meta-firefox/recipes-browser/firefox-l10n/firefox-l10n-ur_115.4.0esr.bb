# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d4fcfb23c5498b72a47b74ddd63f6ec2"
SRC_URI[sha256sum] = "ef9347e7533330ba9e83e5b0ce4caf8ea832aa5d0deeae520cc6e696301e4057"
