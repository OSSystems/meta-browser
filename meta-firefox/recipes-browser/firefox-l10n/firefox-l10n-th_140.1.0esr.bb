# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1311e0b8c69133a077c0baf318b7e230"
SRC_URI[sha256sum] = "bd17943ad81bce1c18371dcb4be42914d79162ec761dd464f7bd3400cea1290d"
