# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "018093a0965f8cc0d13d1b2c24b7ad1f"
SRC_URI[sha256sum] = "5b1a68b753e7a083592946e4ba4737eb1b1497e0c22bb4f78b7245c808e59a84"
