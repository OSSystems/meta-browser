# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3bde39030ae02a6f22cddc8c523836bd"
SRC_URI[sha256sum] = "7efaef390d6152b4d25530eeaa3da68d8fca1807b94acd1177a5dd084e822462"
