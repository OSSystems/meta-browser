# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a2d8716704053b455d2462e142899b4e"
SRC_URI[sha256sum] = "681dfb8bcd2dd0fa27f5e3755305a5280a2820b6085fddfa9d41b4df689ea946"
