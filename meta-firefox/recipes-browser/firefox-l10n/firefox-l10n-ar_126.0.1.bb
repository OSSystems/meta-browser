# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2056e9bd09e5c31b2139ebdc05a779a6"
SRC_URI[sha256sum] = "44554c247f2cba929d319690de5060079646a5a56abaf12ffe6c3360d8da0d79"
