# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "05d6ae3c495786876f8bdcba8b4e7ce3"
SRC_URI[sha256sum] = "31707dcd3bac6f567f79f920d27ee48efe30552c8983fa4222673febb326e797"
