# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "109121edde5144cab75fdaf686c1ff41"
SRC_URI[sha256sum] = "1a43900cb711c16a87169677433633f5e2b5fb1729ca1e28bdf58d56fce2f616"
