# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2fbe6cde8de3187c60f827fd955781ce"
SRC_URI[sha256sum] = "233689b4c2272fdd352baa5421f1c02608dc773eb0cec960099585c4a943815b"
