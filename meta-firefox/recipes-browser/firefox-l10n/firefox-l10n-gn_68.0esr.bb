# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "40a2b82e7e9b6e63c35a267337f026c2"
SRC_URI[sha256sum] = "7d065755d731e6e2d2c034cfc03d65a0000a0486db338e147e7a9b550a1478ec"
