# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fcb92b1911ac710f41de5e81fb1d7af3"
SRC_URI[sha256sum] = "cf4811de010fcb184b8ce6361d37146bbbd20e72c076ed8431e9f6f5da2cd8dc"
