# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "80e8bf5b6baf1a2fa4e9b314e4accc04"
SRC_URI[sha256sum] = "d6e13b59c494ec7fbdc23da4eb785868aa1883cc7edf63c2840d1cf7b36433c3"
