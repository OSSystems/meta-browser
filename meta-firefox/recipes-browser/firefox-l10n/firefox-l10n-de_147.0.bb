# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5c2e05e84e1f1120eefc500889f0bf8e"
SRC_URI[sha256sum] = "fddaef7d1fad97013440658c7c96b4109e3885e4338d5a03b851d9d6f0e2eb1a"
