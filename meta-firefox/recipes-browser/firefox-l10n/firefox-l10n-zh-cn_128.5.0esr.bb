# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "45fd2ed4a13ea205ddec016b29c774ed"
SRC_URI[sha256sum] = "6d7dc1a0c10a1dbaedf4a5f30f6670a254573255181bef78838751dcf9be6162"
