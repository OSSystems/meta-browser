# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e699c150ca4144e5438a7db532ee8fd5"
SRC_URI[sha256sum] = "e6363aa2bc41c038c71ec3057c490f642ee0141a4461dc77674be5754f36400f"
