# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3e65f1312384892320d9208d8edfbc76"
SRC_URI[sha256sum] = "9b1bf8534d3e0f73f37300208791c1dddae22f67247c183e821bb3462695188b"
