# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a1e950043a880e5456781a2727b33d91"
SRC_URI[sha256sum] = "e0384cf33df8a2ca668b89eb6696fc893945e910f7a7ed31154f2b9a67261e39"
