# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "27cf31304093d132953f56c2a40aecb1"
SRC_URI[sha256sum] = "5f4efff5322caebbf4033418a0e3f0a54674f7a3eeac4c0b92cfe2e52a846bca"
