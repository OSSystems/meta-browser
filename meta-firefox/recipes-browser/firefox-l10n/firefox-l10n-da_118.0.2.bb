# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a0dd6d1bbaf496798b83eb81503c8ff9"
SRC_URI[sha256sum] = "4c2d26fcca5ba042a61769395a1beefdf4e635f2e6d3c3ec9118ad0093aed766"
