# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "75c34ff696e62660ec13d7fac2149a79"
SRC_URI[sha256sum] = "fb30a016965051d1a01614cb46ff0c7b8966d5d31a5b23ec76876b1db9858517"
