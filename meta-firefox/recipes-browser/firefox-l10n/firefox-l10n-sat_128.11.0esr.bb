# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e79e5edb164057bbcd50cd6d7d4d951c"
SRC_URI[sha256sum] = "91d5adfdb0de8e1d8cc7a937157b776631cecf00431eea3874829c86a123a6bc"
