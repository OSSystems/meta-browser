# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ac130c789cadff518e095b8dbc606241"
SRC_URI[sha256sum] = "577a50fddaa9746624718bd5173024804c23a0e54a1f77ee1d06844eb659b937"
