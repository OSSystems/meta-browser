# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3b527c62224eb5588c86771a28eb303c"
SRC_URI[sha256sum] = "18b703bc6850437d221eeef28146a228ae0302e9bb476741b1d151c9474ea747"
