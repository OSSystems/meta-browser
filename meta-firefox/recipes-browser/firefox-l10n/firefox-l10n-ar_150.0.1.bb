# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "6076efac36624217931da0dbde8a2ecf78e058b9716db2415266bd9ad52b0642"
