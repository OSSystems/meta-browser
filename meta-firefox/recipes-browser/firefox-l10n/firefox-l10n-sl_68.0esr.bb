# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "835a1a743a543d9c420f027acee8b62d"
SRC_URI[sha256sum] = "1cca2f2d0a40ce45f124aab8aa160c11c2aaf62965ad37970968460628c34434"
