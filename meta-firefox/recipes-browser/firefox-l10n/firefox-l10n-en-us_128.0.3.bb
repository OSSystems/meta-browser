# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1110013b9740431c0d0c58f805c0299c"
SRC_URI[sha256sum] = "32b19d15f781aaa64ab04ceef18e6199c5cc6ca4203af16cde5d5f1fb1a5bfdd"
