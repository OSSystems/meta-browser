# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "65c40d480031865c2953f98ac5f22aa3"
SRC_URI[sha256sum] = "7a6cf73590016454d3834fcad1603bbe3917096b20cbb3af26ef252ddacb55ab"
