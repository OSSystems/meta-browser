# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e11237abe22e9e292dad69cc8fe9abc8"
SRC_URI[sha256sum] = "ce6f9d03bfc4c11cc9c6c7e3ddcb131e02501872dfe170d54347141e58c5a021"
