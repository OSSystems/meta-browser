# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "89bbc5ff9e4184ae1d15fa31785531f2"
SRC_URI[sha256sum] = "7774df1cad2479115b3b63fedb2255ed55222ffaa96c3deeabb187aca9b9152b"
