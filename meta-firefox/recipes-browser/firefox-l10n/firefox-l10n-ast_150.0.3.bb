# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7a0991cdbf2c5f2bbfd75bb0935fc04ae0b4c66f11f883c2cb08290ebc7a12e3"
