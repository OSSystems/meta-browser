# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "59ffab41d197e6a507668724267faf35"
SRC_URI[sha256sum] = "28d5d4cdae2d37ee71a5a332da92d7d06698931c747b49ceedc5f2cb634229f5"
