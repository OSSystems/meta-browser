# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c0aa2cb65c4d318417a00fe0e8f064f5"
SRC_URI[sha256sum] = "14c25a01a70ffa71376d0f00d42788490ed3cd4f7903854c188f3ae45134912e"
