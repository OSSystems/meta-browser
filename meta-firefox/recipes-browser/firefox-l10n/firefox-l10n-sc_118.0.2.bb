# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f99af3e509769a6a87899d43f1edcf8c"
SRC_URI[sha256sum] = "7b0471e0403dca804c458c453f7842e4bfc8fa39072e170d45b0357fac37f87c"
