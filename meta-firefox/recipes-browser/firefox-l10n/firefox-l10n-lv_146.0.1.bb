# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b9a41100db88751742375b80386f7181"
SRC_URI[sha256sum] = "fe6a409127a83f04fb6b4cc98ff04d65bb999f80aadb18471f58307c83a42aa5"
