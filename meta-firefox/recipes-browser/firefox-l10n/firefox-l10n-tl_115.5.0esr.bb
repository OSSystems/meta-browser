# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "81ecf55e38ad347584b0a227329f4585"
SRC_URI[sha256sum] = "ae69c38095fc3eca66943188e2414c2d2d01f80e4acbbf1ad645d1ec4b6ce7f5"
