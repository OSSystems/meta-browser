# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "21c27b36b551444426764c61b6ff1360ccbb00d7e16eed41d4c127e11efa4dbf"
