# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "1644a635aa5dac44a42b52bb13bfaac6529d9a2ab9997254cf0c44f435b750c8"
