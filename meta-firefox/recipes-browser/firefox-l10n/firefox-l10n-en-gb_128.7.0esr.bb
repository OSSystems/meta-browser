# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ffeff33b92ebb41bb803b04ccea965e6"
SRC_URI[sha256sum] = "25798464ee8d187052ebeff9c15fa4ec8e5e6984ab6d7bfb9e61171dc3a8efe0"
