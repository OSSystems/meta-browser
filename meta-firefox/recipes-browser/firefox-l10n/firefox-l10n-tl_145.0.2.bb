# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "be93275a35afd5a1cb487bb68938da28"
SRC_URI[sha256sum] = "169f62ebf19764defac901a0c68499f1373395ab922a0986c9ee3d4250f6a88b"
