# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e995b5ec7564691448af78b2b77df98b"
SRC_URI[sha256sum] = "408bb3ecd27f37cb80301ed2887aaa72f6ff59842ef009d63a1a079a86291dd2"
