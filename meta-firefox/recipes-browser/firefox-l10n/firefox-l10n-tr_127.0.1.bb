# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0b12cb310d0be1f874f13f2bd5db95c1"
SRC_URI[sha256sum] = "0b85d8c2b56f9542505b473b60274c23ffb3bdeac0103e9c373763a42377751c"
