# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5d7fdf2111aa307b0c718a07a3459688"
SRC_URI[sha256sum] = "5237b7fa5b4fa35083e25037da44f3fe0fc528f7fa19747c5f91f07fada0a8f3"
