# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "cd21a1db8d2d4a809aea1f5eb567c202dfa45327416542c1af9c3b959a7d6753"
