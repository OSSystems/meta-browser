# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4644ddd6a4556aa331a41dcb18d1f9fd"
SRC_URI[sha256sum] = "82d103e36499a9b5eabac97aa3220912b14fa92d0cf167acd5d0adcf8d973d47"
