# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ed7e30e11946928f660afd826e3ab0cb08efc82bcc4fd0ef00a4f3ef9969ebc8"
