# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c33adf46f8900596a138ecdfefaf2350"
SRC_URI[sha256sum] = "21db2fa98cd6864db3580e0c3336551a443dfdfe27b8c49bff46b7ac90737d0d"
