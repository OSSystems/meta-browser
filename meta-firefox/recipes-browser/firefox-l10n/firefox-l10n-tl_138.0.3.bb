# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6ebc71ddb64389406d845201e134e6f7"
SRC_URI[sha256sum] = "6e702bb25bbc47c5231b5c003d38d5e4c3be36f915cfa9edb043f406f7d3f3b7"
