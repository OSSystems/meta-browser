# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2280d0a648800647b79c358057b9a9a5"
SRC_URI[sha256sum] = "70f0f8d209acb5ac09dbf75636f0ab6e28b89578fdef294621445c31b34b8f25"
