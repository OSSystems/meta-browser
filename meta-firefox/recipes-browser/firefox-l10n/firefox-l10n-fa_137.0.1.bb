# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f39c0025ce48793f3880e33d8ba0ee8a"
SRC_URI[sha256sum] = "87f902749a7d7267056cae5ffb0b36f6a343a15fdea88e1d28575e7d5968a618"
