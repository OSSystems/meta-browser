# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ff30f3f29881f881a0c6558ccb7ca2df"
SRC_URI[sha256sum] = "09cef829af3203e55532ed78947c4960094648867b35faa36ca037c4d3fa5e45"
