# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4307a12d7d9898ee19a6396be74a43f5"
SRC_URI[sha256sum] = "42c9be7dd2dcf8c95b3e738e9e6ce54691f80d45a3feedf6b9a4818ed343f60e"
