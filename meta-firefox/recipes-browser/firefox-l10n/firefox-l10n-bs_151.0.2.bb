# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7aac6140d5fa35bf24d921e468640b71c538d9123acc873f6ed5d1b29eaf0c8a"
