# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5336ad57d6eef3a0ad1afa9320c53b07"
SRC_URI[sha256sum] = "cecbdccfdfa30d8386a563baf92ad2cc2acd2a671e22e908df2d5bd61960a5d2"
