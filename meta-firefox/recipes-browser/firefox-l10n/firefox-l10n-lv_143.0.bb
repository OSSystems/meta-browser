# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c0b4ae1000c7f021936b3cd9d1c9c257"
SRC_URI[sha256sum] = "a91c211ab55cbd3116682d75b9195cdb314139b792cc1391108af42bbf73363c"
