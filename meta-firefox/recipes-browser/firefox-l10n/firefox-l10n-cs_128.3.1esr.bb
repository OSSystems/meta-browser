# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cfbe7dad18aeb8c32d414c05554c5d4b"
SRC_URI[sha256sum] = "3ec6717085812b599b0af182b1824bee6a6aa63835d6198e5de426820c146759"
