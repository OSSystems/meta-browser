# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cbebe73e96b480004a3455e3e16b71d9"
SRC_URI[sha256sum] = "cd109fef4a79659eb96abaf33c9631701d3623010f01f8793a228f267768dda6"
