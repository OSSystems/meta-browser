# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2e6dca91c52f1de2ea20717f815bda85"
SRC_URI[sha256sum] = "2307e2645727657aa4e2255bcf29b955b6e606a2c9267a4fac8b1c20807f347f"
