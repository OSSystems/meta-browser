# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a777596ce56cae539ad9647ecc3f286b"
SRC_URI[sha256sum] = "02ed451a6a563246d95adb926bf5a2cd37685000c4d2d711a3bc76e630b5325b"
