# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "14e8e6660b8a175e1de1647f42b5bc04"
SRC_URI[sha256sum] = "270dfb36867cb455a565ccdde0851c29a3febe50d51648deffe8331cd503b4aa"
