# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6eb90401123cbb07fc9825de889db739"
SRC_URI[sha256sum] = "591c182856c87bf9d7d9a56d18dd86347a0e229708e3a51cf8c3fda914c4ba21"
