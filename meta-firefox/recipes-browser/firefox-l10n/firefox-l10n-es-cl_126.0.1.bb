# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "da75d4fddcc88827feb5bd481759d0c4"
SRC_URI[sha256sum] = "f74b3dc9b0c9f143f9b3606dc3346cc6e3f7609a63163b1751a9656c3f6dd417"
