# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0203e66b708a802a649abce6c54e82b4"
SRC_URI[sha256sum] = "8641e80b285623432c2f1420266a22e8de41220ded57e075954a21f0507b902d"
