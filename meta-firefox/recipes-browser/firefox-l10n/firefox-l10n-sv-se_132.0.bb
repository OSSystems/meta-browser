# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6d34878914f45267bfbca2d03a8170db"
SRC_URI[sha256sum] = "94ed283f464a36b6e3652847cbe44da8d491d706bdf808298aa3c35eeb98dd1a"
