# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a864348d015b74d890995229bc49167f"
SRC_URI[sha256sum] = "26689b858c285e06feadc5b332f273e13d10dc3919a0837c379586a7eb9e2c51"
