# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8194378b6d3cd30166c5f6c6e4eecfe8"
SRC_URI[sha256sum] = "ccfd7876e88b095c8c02eb6c0764dcb48729a2a7b44d205d3adce4d51d660be3"
