# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "90b2890414d00767479f79da9a0a828a"
SRC_URI[sha256sum] = "0d20b60edd8abb85121ccdf150e32ccfcd5020c0004b57fc9913f2ef1017a981"
