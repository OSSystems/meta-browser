# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ceaba007617a135b4e995a36297529de"
SRC_URI[sha256sum] = "359624632398d1b82814ca6546ee62fbf99f67ae39d8c8eb1e45969b4858b476"
