# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "afe557353b89b6bcd276425b99643697"
SRC_URI[sha256sum] = "2125cc0a8fb6363c34bf6c05bbaf3570befd680b2d66df4519007701969b0f43"
