# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "faa17ce65334cfa4ab5927588cd51e7e280da5314c528e7d644c853ec7a8f7d7"
