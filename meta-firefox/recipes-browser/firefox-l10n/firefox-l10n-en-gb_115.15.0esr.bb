# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "900701973de992ebb2bf8ef8c871c048"
SRC_URI[sha256sum] = "4afaead285d991d50ee9d3441b0bec71d462e3dbbc2fc91366139ae8d3c0dfce"
