# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "75062d65fa6275a10eb2eaefd22284eb"
SRC_URI[sha256sum] = "f252e8781c976d6be964c5844043183e389cbb9696a994c5d72635f70f6af91c"
