# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ba24074485fe25ae0963a9f9a4036783"
SRC_URI[sha256sum] = "b96d49dd6cd01342f7bd357655b02873ddd07f923cba1d2831c492105fdbde32"
