# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1aff7568e6ef8337dc0c5675bead3998"
SRC_URI[sha256sum] = "3a8480cc2465513c326eed87da53bb77634e1212542d5c5d670bf45b948ad4f7"
