# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2c6d9d094036ea60899a121dc1c62260"
SRC_URI[sha256sum] = "678b3c1e454666888e178d93330acae3e04b9e557b05571f2fd15a6f6281cc99"
