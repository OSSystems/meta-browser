# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dd0be10767e00b034daa8970f6de2ea7"
SRC_URI[sha256sum] = "f9d676ebd79f4d16a0947822a4a62403c9d8a2522503103b52ea9e714fc1e6b2"
