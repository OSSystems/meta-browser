# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b31a09afbd0dfe3fbe528c974990ca65"
SRC_URI[sha256sum] = "c4610df03cd99c5d934cedff2bae15235ab66bfc0de79d4518a83b979e2ede28"
