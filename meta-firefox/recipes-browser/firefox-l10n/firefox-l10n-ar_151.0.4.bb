# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e2b84e77f99c0a9889facbcdc57a7bf2f579c0f7660bb24b6b362d47f101caf3"
