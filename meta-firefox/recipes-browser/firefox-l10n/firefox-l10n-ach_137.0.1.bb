# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "473941a6aa0b1cabdb936b9e797217e1"
SRC_URI[sha256sum] = "5e76f0e7239607b7b3fcac18065df2073551020b7161b4ee86015204f2d8cbf1"
