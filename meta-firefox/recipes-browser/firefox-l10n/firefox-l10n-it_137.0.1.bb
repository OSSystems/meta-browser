# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "96c4971a60d8b60e8c18d31b3736d253"
SRC_URI[sha256sum] = "d8fd39e255c57f7479cc4bcac61226c00ffbc3f68f8746763fd8ae9657709fbe"
