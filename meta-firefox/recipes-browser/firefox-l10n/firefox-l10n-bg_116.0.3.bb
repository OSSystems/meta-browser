# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c4cb237d32cda580db5d0b96c7d65ccc"
SRC_URI[sha256sum] = "191640f3610cedbe6068f46583c23b83825a0934b48a9ab0dbd1cc5ab8a50e15"
