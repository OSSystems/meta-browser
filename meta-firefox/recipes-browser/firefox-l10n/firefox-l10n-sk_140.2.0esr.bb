# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "20743226a27035b6193619034e4daf27"
SRC_URI[sha256sum] = "257202a0b6a60f8baca78ecf418939d2f66515fb7688b37517da7d3476d712cc"
