# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4fdba6036e310468461be14264406978"
SRC_URI[sha256sum] = "38f599c2f9ef7d6f29f27dc676f269809a935ff2b8eb8f328303a18754dbeebb"
