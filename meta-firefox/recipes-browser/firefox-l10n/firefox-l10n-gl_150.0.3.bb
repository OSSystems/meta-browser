# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "1f0e31727418df89b2e32c09e72eee8c1e7656b43ef0fe617731c303e5c62e45"
