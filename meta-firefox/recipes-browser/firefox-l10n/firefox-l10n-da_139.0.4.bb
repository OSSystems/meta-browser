# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f16943631400012a119fc6c8186097c9"
SRC_URI[sha256sum] = "cc7af2cbb6be29add0537e8d23a6374f9a3b2ce1fe62e423350f5b5b26f48b9b"
