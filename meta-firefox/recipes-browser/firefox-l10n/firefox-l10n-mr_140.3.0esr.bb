# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "597528c8f7a24de6c8e3686727a2fb31"
SRC_URI[sha256sum] = "cccdca0ce4bd1acac83baea3d3dab7f77084a413bf7cbb8f3b17d42bc96db005"
