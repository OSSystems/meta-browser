# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "46cf4c286769ccb37af1c406b16db6c30948fcf16cb4ce715fd4a9cd5ea175a3"
