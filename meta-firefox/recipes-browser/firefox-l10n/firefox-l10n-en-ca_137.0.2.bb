# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dd6d3e48c6675673f2276c81b9e7fb3f"
SRC_URI[sha256sum] = "102117824eec4c62f67e8f1669f81a395c92666cbbe008667dd301b9649394e4"
