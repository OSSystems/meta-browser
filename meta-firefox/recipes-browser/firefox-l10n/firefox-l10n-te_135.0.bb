# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "661ae3bf542e1b363c38829f41f2633a"
SRC_URI[sha256sum] = "cb982965b56c67cef270ecc6ad4a8ee3e3e13f20b173546e70ce8e27f775154d"
