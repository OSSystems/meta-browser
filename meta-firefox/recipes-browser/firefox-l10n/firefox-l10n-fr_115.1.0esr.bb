# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "27f40488fd63f20eb2240f21388c1214"
SRC_URI[sha256sum] = "0a9dcb60d5de60ab3c286483b7a5430a55c8496b76bab6424adcbaac54b44ba9"
