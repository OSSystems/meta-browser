# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "68726ea44a0e50b1a26992d9fe3a9162"
SRC_URI[sha256sum] = "e31a9415da4a5995d557fbb4d7db5a9dc8e77c4d6eea94fa710114a2fb679c8c"
