# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "83076161a2b91dcead2605de95fb6281"
SRC_URI[sha256sum] = "8ca42775c4d3dfc1f9c987172278cd1abc175af6327c932051c11b57cfd76e22"
