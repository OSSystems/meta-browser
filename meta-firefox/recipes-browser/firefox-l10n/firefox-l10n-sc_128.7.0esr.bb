# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ab5e032da5a64a66e6db5f6b0a4fe0e3"
SRC_URI[sha256sum] = "d3d08a4e1563415b7dd328f70b28c0a2523a79728ad09848082152c5fb865f97"
