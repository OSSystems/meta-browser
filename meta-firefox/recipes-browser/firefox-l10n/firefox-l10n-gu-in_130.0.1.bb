# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "faed7210020c2744bb8f0f773ad01135"
SRC_URI[sha256sum] = "b2205bcdfa49815b8e530e03c3595b8be9df62547f95d36a3b55d68f54e70227"
