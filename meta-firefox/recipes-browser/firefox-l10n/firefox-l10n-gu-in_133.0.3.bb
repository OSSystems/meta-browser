# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a9e4b73e7b36d73f17901024867ede1a"
SRC_URI[sha256sum] = "6e950f9207f8fdd368c452242c37f5918927c7be5554e687636c282f35d3e9ec"
