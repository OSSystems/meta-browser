# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d1a1ef71ce414befff21ae11767144ef"
SRC_URI[sha256sum] = "649fc0b526cf7db2b77c533370c47e2253df4fbca3ce52723537d330dd2da29e"
