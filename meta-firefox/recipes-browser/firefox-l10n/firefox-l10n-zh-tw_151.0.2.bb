# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d4a1641379855eb5ec3bb51501251b784875c5040ebe6501bccced30daf1183e"
