# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dc980dee93af6ad24f36b9d6ba6e1985"
SRC_URI[sha256sum] = "430c4f0ac19dcdbf2550eaaea0292607df3388628a73308072ac6552640372b7"
