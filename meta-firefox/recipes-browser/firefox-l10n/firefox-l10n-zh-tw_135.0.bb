# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "113cc1c42281ad67154d42f7bc77a00a"
SRC_URI[sha256sum] = "722bc2daf5fa6220cc20ab54acd92c30f93538e200b0444ba25e5e6456636491"
