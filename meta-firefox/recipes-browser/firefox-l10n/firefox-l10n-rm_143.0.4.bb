# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c7ec1be54d83cd1034bdccdeb8073bfd"
SRC_URI[sha256sum] = "4b96f6413c9b261ea639ee4024c9e12367006bfa7143c28d30d9fd0c5c4a5acf"
