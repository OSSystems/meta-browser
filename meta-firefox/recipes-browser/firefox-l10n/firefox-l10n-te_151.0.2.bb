# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ee9880136155f7339501fc9656e97132199f5b1474f868d4d53656af2308bf8b"
