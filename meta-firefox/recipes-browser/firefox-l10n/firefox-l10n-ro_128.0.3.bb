# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "301c9163bec89ac90c2c36b9fe971d71"
SRC_URI[sha256sum] = "6d025a7c3f02ffff02d6d6d1ee31cdb0daa368f09e7165b2b81d51ce640264fe"
