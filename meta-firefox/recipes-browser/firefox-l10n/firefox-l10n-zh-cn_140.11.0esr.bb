# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e2df508d1f6d5912895c95bac59023d95782ec64e3d2a64c84546445913625dc"
