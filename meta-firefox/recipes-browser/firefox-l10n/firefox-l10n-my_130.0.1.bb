# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "76a5f178350c3cac18eb0738713d2f89"
SRC_URI[sha256sum] = "0518ac2021512fe40d3e0c2e5ecd6d34b4d33cd405709909dbf46da224274a4f"
