# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1865c881a04822738e99733a3bc02d0c"
SRC_URI[sha256sum] = "697f710a358f9dfe117beb9e52d2b92af93df51eac926d66f6ea14b0278611d2"
