# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5fbbfd7c4169d48d1c1071b2ff4720c7"
SRC_URI[sha256sum] = "7a884c28dec13b2a69c73152de66930f38b94865ef1b675040882b57f91de53a"
