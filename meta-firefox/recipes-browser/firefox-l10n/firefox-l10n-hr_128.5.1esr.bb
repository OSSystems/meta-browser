# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3dbf6c745a3fd03cb468f2c4e7d7a5ac"
SRC_URI[sha256sum] = "63b1b13d576c6780937b71d146327366016eeabaf2ce3a9cf5d7fc2f02c65b63"
