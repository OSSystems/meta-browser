# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "24519397e0b6350cac9c5e00bdfb6de2"
SRC_URI[sha256sum] = "3577475bdb388bf02d77938b109dee879363538891d1f4ae662602004e187979"
