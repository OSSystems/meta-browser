# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fe4020ae75586bfd3376df25e3bbfb19"
SRC_URI[sha256sum] = "1f146a7d264ef74b4a126274b6e4ca343ec46bf63be21d32f5a8e633f21888c7"
