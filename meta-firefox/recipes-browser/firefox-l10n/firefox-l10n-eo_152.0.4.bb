# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "20174ed917a31af13a6a8cab3a4d9aff15df84a44f44b7824e3ff162db648a22"
