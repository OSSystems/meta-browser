# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c274f4e8e02e18d9099351a924339585"
SRC_URI[sha256sum] = "dd338faf603932b9653fc89a18d7c84d4ad14e2d2d267c2d7b18d14fc6bdcb78"
