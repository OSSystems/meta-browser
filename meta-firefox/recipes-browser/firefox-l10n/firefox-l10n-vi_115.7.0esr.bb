# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1d36dc9efa10c0bbbdb062b4ac6c5eb3"
SRC_URI[sha256sum] = "d89b2366b143bb366a6da8fead08485fe0b465b0a6594ff9fc69a4bef12cb160"
