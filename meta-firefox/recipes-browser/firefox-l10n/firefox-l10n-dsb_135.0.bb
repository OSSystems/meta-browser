# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "40b84396d89cb06d4ff9b03c32ad2803"
SRC_URI[sha256sum] = "f55556126c5a5c7fae091dd6e42c13b218291a597d29f6bef9314c30c8cada0b"
