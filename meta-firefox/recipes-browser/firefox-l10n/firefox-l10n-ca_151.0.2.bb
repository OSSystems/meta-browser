# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "24afc106ad0683ded95769639e962d2de552c8487055898d6be04e69cda1bbba"
