# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1374c858ef9793063fe58090d0d4f1aa"
SRC_URI[sha256sum] = "1a271f1e239c1dd9c2ea1776b8f7d8c2e20a287eac2eb2a5c9f90588fc7f8cc3"
