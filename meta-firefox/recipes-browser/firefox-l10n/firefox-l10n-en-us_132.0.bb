# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2e4b50d2f7922db71619b2c9b35ab08a"
SRC_URI[sha256sum] = "4c18aef6a040012dfffa739ee915fb83ee64f2ecd60170c4d3c09cde9efda84d"
