# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8704b5e57940a311356c12de8d75d77d"
SRC_URI[sha256sum] = "1b232a3856eebe056154866e514292782cfcfe95ee7c38fbc03a7a22ffde14a6"
