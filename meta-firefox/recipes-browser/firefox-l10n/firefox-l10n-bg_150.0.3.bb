# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "f5532e387426e5d03242aa9120f1a0a0044ab311d3f84b70f4e6ef7f592343de"
