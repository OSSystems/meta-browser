# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e9ade51ab4db8afc749aa9fc659b0fcb"
SRC_URI[sha256sum] = "5e187564cd42416260db0c810af21bed7458d75e77afe4fe4ed7af4051556e73"
