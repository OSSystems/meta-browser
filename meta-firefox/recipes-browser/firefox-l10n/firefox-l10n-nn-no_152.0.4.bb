# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "83a8cf5094622349c023a627033263a6908ef8197e8f6b482d5b64d7133cccf7"
