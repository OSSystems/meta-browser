# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "6d6a19525ca00554c8bd5516d1f245abe0a7e58a600709771f1c32d9f5cded2d"
