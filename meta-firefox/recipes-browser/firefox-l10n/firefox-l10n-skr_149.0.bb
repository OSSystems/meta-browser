# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b0c897af457dac1ba306697cc3c9e851"
SRC_URI[sha256sum] = "3f4fdb4c0b530de4adf025482f59ead99d38f199b617e6aa24198d50e0d57e67"
