# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4b855353e38f484a5c69cf0af2659b2c"
SRC_URI[sha256sum] = "517b75c11d1129a78f8ba9e4c0443fbbbf74e9ee286b2223f99f309a357b5bc7"
