# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "1daae0c410b8fb50acf8b83a82f96719481f5d077018043e54322fb3d1d1bf54"
