# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "1bb0f955c780848f14e3861ef2bedcf988ed31b4842f3cbcd2fba60f42d66bff"
