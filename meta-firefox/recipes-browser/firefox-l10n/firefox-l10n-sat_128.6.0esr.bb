# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "53b513bc813c94110943b5c9b2a299e3"
SRC_URI[sha256sum] = "1d850e9fe97ba2141da74fce58ec037d190e1ff5e193aac6c480fbf14010aa2e"
