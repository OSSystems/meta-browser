# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c57f03e82b624ca4197a85b740cfdfaa"
SRC_URI[sha256sum] = "37192e4d2ffe9f120509959ebbed42255f9a2fa84173954483b66c1be4d83e86"
