# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fb70620288f666a103f7c883ebfa2fc4"
SRC_URI[sha256sum] = "c3285b89a3e9663313ae86ebf9182c86d6e416d91fb5691c47c5f2cb7ed13ae4"
