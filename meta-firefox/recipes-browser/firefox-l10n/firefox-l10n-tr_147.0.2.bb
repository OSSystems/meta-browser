# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b7d590edc0dc4daf134a3d9d6b235d04"
SRC_URI[sha256sum] = "80c7525e3c37c136fd5afd2c6d0d3a56f6c55f49ed3f4d12225044d716f340c9"
