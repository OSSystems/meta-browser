# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b99d6315729f2fd464a1887cdaaabed0"
SRC_URI[sha256sum] = "73a0078ddb26289e3805e92b7dabef36ed1a726ad86a5e2f4925d559d943fe81"
