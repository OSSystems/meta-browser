# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1de4614693b0325204e3308fbae84bcc"
SRC_URI[sha256sum] = "02f78e36df5312f7e9bbf17510a4766780f01b91051288e1a2a0b5982785cde1"
