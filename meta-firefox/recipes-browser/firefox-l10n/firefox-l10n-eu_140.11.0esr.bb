# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "29d16f8e3a9be44bb7dc4bf9d98ce0ded49e1c6f1181372de58ade32660f0935"
