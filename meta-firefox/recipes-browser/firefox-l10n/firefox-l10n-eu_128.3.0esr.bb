# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "90fc90a99215e72bf5f8a368dfe6c554"
SRC_URI[sha256sum] = "770c46cbc874f83f4d3052eb969746b2f33ae8a725fd619324d9348d5f6d61bc"
