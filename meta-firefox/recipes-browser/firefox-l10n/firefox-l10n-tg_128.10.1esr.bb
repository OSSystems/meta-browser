# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1172201eb75b71a81ff38ca23e29463c"
SRC_URI[sha256sum] = "60f54f129374e1bbca95862f53932fd3a34274fe741f8e7b990201888d62a9ac"
