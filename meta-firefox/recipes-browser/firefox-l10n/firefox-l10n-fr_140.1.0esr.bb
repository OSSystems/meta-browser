# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "95ec311486d34bd981e40967a1315536"
SRC_URI[sha256sum] = "380da2e46f9ee039145ae92c4f22d19e4fda520e22ebbdb7469b49ab37a38703"
