# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "05cbeabc1bf91f97b6ed1f63c94c03fc"
SRC_URI[sha256sum] = "01a5e8817d5e9e05d203cf15aabf4e069c637d251684a1c63dd2415085dbbb96"
