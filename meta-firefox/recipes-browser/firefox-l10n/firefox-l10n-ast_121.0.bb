# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "40cca00e74d75d763116a7e053c1519a"
SRC_URI[sha256sum] = "ee12bbbc3956e76625463b80050a48629549443ea0135a877e3456968b2b4a60"
