# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5a1aa9146a58032ffcd574e7d6cfa4bb"
SRC_URI[sha256sum] = "e7140df67290e35d4e384d34c9ccd2c514d9d8e0f92a09f31aa14f64e5ddec8c"
