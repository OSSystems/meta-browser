# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "698eefcb19876fed489f38b322e047e7"
SRC_URI[sha256sum] = "53667f63dc19793e2d15ca25d4c44fd93612a0b7678bc7273e7c7a3c63da71d4"
