# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cd236dd1c546b916a925a0c5f6f3e3a8"
SRC_URI[sha256sum] = "b28499c504039355fb52a1b5be32619c84979adaf7e09f29acc02249bcf5dbe5"
