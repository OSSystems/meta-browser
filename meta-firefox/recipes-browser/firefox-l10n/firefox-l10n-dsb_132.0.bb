# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "162d5cbfb2e01c1b5b1a09819a5812f2"
SRC_URI[sha256sum] = "ec26c66fc7bcfa21e52b8907e7d502cd74fbc561427ee6d1598dffd2dfe34f6f"
