# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0f2c22e22d590834111448b16364912f"
SRC_URI[sha256sum] = "5035e8e1f16af71bf87b49abcddf618efb997b0fcb9e66bb63a96423f2dd38b7"
