# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d78cb79735f35064c705cbece36d32ed"
SRC_URI[sha256sum] = "5993eeccce8709fd2a3ba08c1fe42d8efa14b6c36dea5c6f621ef5b1a2aed697"
