# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "016647aa2ded519a1b2400dac3220674"
SRC_URI[sha256sum] = "a5d8d01c5c6de12e2c8050fc2b50d67176bb9b148df82ee531bde2bf6eb6308a"
