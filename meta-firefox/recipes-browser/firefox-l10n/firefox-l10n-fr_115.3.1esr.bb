# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fdc734a03daffb80bba39f0a32ee63df"
SRC_URI[sha256sum] = "5f1422412cd3c7fc7367ab55fa9a2b158f4195cea1cb16365210d917e9f9cb68"
