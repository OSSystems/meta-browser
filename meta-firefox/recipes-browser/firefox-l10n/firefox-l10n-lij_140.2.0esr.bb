# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4d995d0dae673f2d6709590c38689ea0"
SRC_URI[sha256sum] = "01fb89a8c75284497ec8833ad06844ab480932bb0afaf2e4558e2eb17f86ce13"
