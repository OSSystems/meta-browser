# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "706969faebdb3dcb4b2ae09816faef5c"
SRC_URI[sha256sum] = "a4614a1dddef7ebf25336dc44831428bedbe9f1ffd4b7e066e8be965b115983a"
