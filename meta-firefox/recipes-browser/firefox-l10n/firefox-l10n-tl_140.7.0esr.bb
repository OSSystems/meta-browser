# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cb92393d0f2e9b1cf623bb8a5047b146"
SRC_URI[sha256sum] = "ebadcea4c0844dfb26f982e298edef9fc7776178de5803abc0397f60cd4ebff5"
