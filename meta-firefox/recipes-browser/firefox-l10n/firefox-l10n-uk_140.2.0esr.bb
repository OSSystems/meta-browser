# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1e3d3b9184f1040c7babaef17e9d4094"
SRC_URI[sha256sum] = "4ef30039b2afdd8ca43a8183b5a87a6dab1371ab57b7363eb54d5dbd4b7a9238"
