# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f506865b0d9f5fd9bda966328befa065"
SRC_URI[sha256sum] = "195da335a6f6f8473cdeaec807ec1b2c2cf549f241b01f30a828b8271ff15564"
