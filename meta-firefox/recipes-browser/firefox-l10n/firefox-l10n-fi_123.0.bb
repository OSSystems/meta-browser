# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "53a07a90bd4e2646f37ed6bb865205c3"
SRC_URI[sha256sum] = "1044a753fec1da3613ea68fc5e6abf439c9d347789f35ea96209cc9fd971586a"
