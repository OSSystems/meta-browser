# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5e5716ba6e11280410633a1f2c223c26"
SRC_URI[sha256sum] = "cebba4ed9b0c5fd3716ac3d6bd34a7796363c3d84f66015529e51c8dee56f812"
