# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4648db5054cc97359258f3642b48241e"
SRC_URI[sha256sum] = "ff5625eaf2094d1cacaf4b164a807b7fc1a76e721d37b2e5fd180cf43d145485"
