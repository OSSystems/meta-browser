# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8649a2611bd79b0d44b4a6fdc93360cf"
SRC_URI[sha256sum] = "716393542509b272965d75a31a1d534b121a8d5d230801cd84ade1c401452476"
