# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ce9d0d4dc974f8d6c4b714eaaae3b3a9"
SRC_URI[sha256sum] = "8879d75e2247e68d180f81514e4ae4d308e0f481981df01fc8240be6c29dc765"
