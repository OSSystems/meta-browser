# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9766518c985efd5528236c25cfb48fdd"
SRC_URI[sha256sum] = "b16c38e3d83876666e2a97b0c768569776b5729b99259c19deb4a0e5ff931eb5"
