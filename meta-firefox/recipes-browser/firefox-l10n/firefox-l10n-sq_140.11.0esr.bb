# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c7dd00a29423cd9b6f6d786fb05417a77a841b56eaa5ddf89a01608bf113c106"
