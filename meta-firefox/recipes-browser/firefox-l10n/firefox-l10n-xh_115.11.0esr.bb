# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "80b77aa1ff98a1aab0997dfd9ab9febb"
SRC_URI[sha256sum] = "59cd7f715ab4788b4b0e783cc09be7bd3e312b384acbfad8ca2a45144ea7ac90"
