# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d7298be6143ab3bc36f6c3f4753ce2b7361367b408f8c8151e2e5b3fecd1628d"
