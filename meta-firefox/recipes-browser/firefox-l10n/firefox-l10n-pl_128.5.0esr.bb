# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9d9b25f6e82ca96a8ba6ace4903aa8af"
SRC_URI[sha256sum] = "45e4052b0789df71e53ddec4726ed37effc1f6a3dc59519bbf3507fc2ff09626"
