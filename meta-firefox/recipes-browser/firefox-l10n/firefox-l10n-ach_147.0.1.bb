# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1ef199f27d9b1dabe7b69b18cc53838c"
SRC_URI[sha256sum] = "fc6643c7aca982e0d7597913c9d3d11ce3e9f46b133a107f61f47c698a806b8e"
