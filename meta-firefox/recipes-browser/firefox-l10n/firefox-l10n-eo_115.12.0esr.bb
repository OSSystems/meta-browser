# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "485b41a00e1cdc4501b0735c86a0d90f"
SRC_URI[sha256sum] = "c2b224238473cc9d9fd62d0754496971b02fbb6a7f21ae73ad5c0ee571f3d8ba"
