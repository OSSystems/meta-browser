# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "134ef0b4ba1e112cbc408f619f93ba01"
SRC_URI[sha256sum] = "bc1be0cb15d234e4bee578f1c53641995ba3d528cef50222eb26376c17f3673a"
