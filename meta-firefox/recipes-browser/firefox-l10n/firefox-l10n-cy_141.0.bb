# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2652b593f2fe16503affb46d444e78ce"
SRC_URI[sha256sum] = "1aa821681aea3d76ec45a7388ff71b4e76168ca6b7cbffd7313be826c55fd051"
