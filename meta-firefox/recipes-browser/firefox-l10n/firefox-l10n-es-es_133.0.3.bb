# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9b65b154231941a066631fabb49e1a8c"
SRC_URI[sha256sum] = "c45cb9975d843210e5b199017d54d83441df1ba38220fd762d315615432177c9"
