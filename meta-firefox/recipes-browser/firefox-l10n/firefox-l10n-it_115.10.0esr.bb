# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b3ffa97d07933f56143e91fe14fd0717"
SRC_URI[sha256sum] = "14c2634f26e8840af4238c77f8528081b7b98ff7b25b25db7d7176c78b4e304e"
