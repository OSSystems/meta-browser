# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ba21417c15aca83e5bb65d0ece34daf0"
SRC_URI[sha256sum] = "ab35cdcb3b98a8a04845794f0b57cd49012367e3a79f27b46437e5f96d33e754"
