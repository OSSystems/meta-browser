# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6e04d8358110187c2ad3d4536663c4d3"
SRC_URI[sha256sum] = "fed053b1f0bcc208a125983204a2cb4660a2dc60601b6b0702074db07e5ce609"
