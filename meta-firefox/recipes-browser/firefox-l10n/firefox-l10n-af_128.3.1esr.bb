# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "98f82e4b679d77c5ba0ca08c1af131e6"
SRC_URI[sha256sum] = "16b6f7dc74dc03042d837dfece86b8dfb9e9b5f3e83b518ba38284c15b0fae39"
