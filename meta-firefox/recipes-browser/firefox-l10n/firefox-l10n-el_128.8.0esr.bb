# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c5b28fd2c110d237824d57855d1ccd7b"
SRC_URI[sha256sum] = "50ba572a89ca912a59e363cef462426e2d8b7541640dc5bb8ecd963beb8febd4"
