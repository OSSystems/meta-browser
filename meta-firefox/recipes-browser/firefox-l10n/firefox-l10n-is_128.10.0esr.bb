# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "92764d43c3343e9f804f1dd59e343e44"
SRC_URI[sha256sum] = "e37a3461e58ab22a9ce8c846a3f1d86aa6d5250689eaa88560bccb61457b6a1d"
