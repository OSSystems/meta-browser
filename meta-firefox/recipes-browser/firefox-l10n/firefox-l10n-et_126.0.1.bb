# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fe48bd51b2d4610cbb1bbc02f1308525"
SRC_URI[sha256sum] = "66c3e3f7d13c3d7d410ccfaa879b9452f14f75195b9750c5144f160af42dfb07"
