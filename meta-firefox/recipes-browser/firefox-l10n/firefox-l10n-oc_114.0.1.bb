# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "571d04113b9fabed3869bfab0ecb83cb"
SRC_URI[sha256sum] = "82f50c83d49e32788f22113a40f372d13bbb8f2b7d8f33ba524fa4d6e18a3eaa"
