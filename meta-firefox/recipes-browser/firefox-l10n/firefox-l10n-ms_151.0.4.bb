# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "9275686a3ec4fd5879e7056acdeb9f5ad7bf00ff78dc83cebb866e5840bdaa3e"
