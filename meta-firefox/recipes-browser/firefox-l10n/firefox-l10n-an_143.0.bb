# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e6b86acf9e8cad6f3008a187dfab9a78"
SRC_URI[sha256sum] = "2a31cb5ceea894738dd31f134470f05b61dd99653d8de67a7f2bacb57955edac"
