# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fe34a7319dba5a399eab724e750778e9"
SRC_URI[sha256sum] = "0becdf9014bde5e6d7aae8165f3a0702e589c9a6854325c1c9558abe12bc8304"
