# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4c275f0a1bd774f44a32b9f2d6028da7"
SRC_URI[sha256sum] = "a161cb4be456a67a326535c0a7f6c69f4cbda76e471168aff4d0af959d933a09"
