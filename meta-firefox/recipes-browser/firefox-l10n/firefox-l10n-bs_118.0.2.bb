# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "589596fb3b82cbc4b3adff84c516a8c8"
SRC_URI[sha256sum] = "220baefdc8b45f88fc4611c8ee90c0a7d4bb30f7b6ca785a4c042a2382715f97"
