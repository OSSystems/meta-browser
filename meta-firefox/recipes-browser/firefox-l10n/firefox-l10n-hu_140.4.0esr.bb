# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "05ba89427f31ec6c7e982f117bed37b0"
SRC_URI[sha256sum] = "5b35abe58e7a05fd80bc54142cc567e90bd4cf17c726600d7fb2f509ed1cee7b"
