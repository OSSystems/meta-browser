# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b9faea977bb90824b98b651347baaab2"
SRC_URI[sha256sum] = "ed2a7e39d00be4008b12358bf6ba3eb9bb73079ab932d3d07fb1d87c07354e6b"
