# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7806ddcc3692079e81a2639574714acb"
SRC_URI[sha256sum] = "8a7399a8ec3c118e0af3cf7f0813da8135e748ed5ba613e3d20a3f6e5443b641"
