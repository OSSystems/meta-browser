# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4e13680a0bb8858eee192278be4c496c"
SRC_URI[sha256sum] = "eb2e7ec6edbe388ebc2e931d4082faa2819ce47b701fdc3a07a35fb07bae94b3"
