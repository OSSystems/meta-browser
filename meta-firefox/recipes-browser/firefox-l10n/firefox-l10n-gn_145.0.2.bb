# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1ddecb11cfefbc9ed7f589fe2ef2d027"
SRC_URI[sha256sum] = "56da4a29d449cecfc2273c7420524f17e0deec36c663747deb92b20087feaac2"
