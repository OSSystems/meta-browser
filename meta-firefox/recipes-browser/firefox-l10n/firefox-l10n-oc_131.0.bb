# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3b40bf467e5d0d952644fa79f6f502fa"
SRC_URI[sha256sum] = "91959c34dc34db3b996d6f0e25d3157b1a67840de7e9f40973ed40245ea1bf71"
