# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4eb874170106f67a3f4b35726bcf2a6b"
SRC_URI[sha256sum] = "670bcdc8944ca7854e0020c72d63910b77d367cdb2db6048c9e87f8711c9d587"
