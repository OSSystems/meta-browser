# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "189d45f26e35d374002ffce75be4836f"
SRC_URI[sha256sum] = "c19a60161443867ff32d388671abab6e74d7a8d0efd602899bb2dc579cccfc89"
