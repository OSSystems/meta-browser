# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a9f7fdcab280e72d58ebd1d51568e474"
SRC_URI[sha256sum] = "b8ba8dc6c6b4d5dbc1271b8fbb30d8cfe46b3e9bb274b11c186617b055a51d01"
