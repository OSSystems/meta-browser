# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b65fe850ddcf6a046c676d836c6ed810"
SRC_URI[sha256sum] = "1544469ce93a58730f8798bc7e1e92d1d1671ef1e5735a364f69308b4925fdcc"
