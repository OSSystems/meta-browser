# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "19ef9ece6b324e320498e38c2c885001"
SRC_URI[sha256sum] = "145879400a0b61f8d6c09801473141e715e8861db26d1025e386cf5960f8470d"
