# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e3a969300f662cbd6e2cf6e5a2ee21d7c36b750258ba91f3901609caa48d615f"
