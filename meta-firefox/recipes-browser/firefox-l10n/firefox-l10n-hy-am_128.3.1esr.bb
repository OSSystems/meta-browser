# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1ca00e3429415ade3f30e9924d2ab9f4"
SRC_URI[sha256sum] = "168e8b0a4387ade0340e4103f8e61b39f1571cd3a98ada9a6a3cede754cd33e9"
