# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "58a015fd32929195b68b05da34576722"
SRC_URI[sha256sum] = "137dcd0a0202384bff119a1a8b7c3e2ad688f5a73b74d4794b1b7812f5baec0a"
