# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "88d1aafefb9a57850feb988b0eaf2fb9"
SRC_URI[sha256sum] = "590f677075a43134a368f667c573a287de1a1e0043debdc96d4a31c1d5f906ef"
