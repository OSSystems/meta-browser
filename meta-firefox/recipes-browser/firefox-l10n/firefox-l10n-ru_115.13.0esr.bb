# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7692b040f89cbf110d2556d8edc135b9"
SRC_URI[sha256sum] = "8b812bf72287ebdaadc6d0c7b99c874fa6a3a159fc739d06dba55c1d72745662"
