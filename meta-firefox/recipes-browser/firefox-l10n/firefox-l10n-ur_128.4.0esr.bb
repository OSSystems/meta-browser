# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e8bfd6cb161937aa86fd2bfd35ebe94a"
SRC_URI[sha256sum] = "24eeca7f2d83ec1b05421762bbdf6bb51f9fefa752a7306a49368abdbf0c5d87"
