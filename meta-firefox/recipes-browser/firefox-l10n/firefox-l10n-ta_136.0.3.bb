# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "75f489bd6b517add3502217d461102fa"
SRC_URI[sha256sum] = "6b0907932ad25b6d5a75be61c9ce878c926620f71cd8c210a50c1d9a73c58ebb"
