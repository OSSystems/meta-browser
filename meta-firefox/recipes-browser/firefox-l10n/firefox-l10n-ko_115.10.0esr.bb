# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "82aaf1d6dc5320c012d8be3feca9de92"
SRC_URI[sha256sum] = "7b09152e06c57b6ff95eec13d13c7dd178ab5e14f0b9e22ab2f07b28682b765f"
