# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "31f7ddc9455e8fd9a80234a393facc48"
SRC_URI[sha256sum] = "724a97ec90eabbbaa136de275bab792eaed7ab0533aff8105fe8bc46d1dba0c4"
