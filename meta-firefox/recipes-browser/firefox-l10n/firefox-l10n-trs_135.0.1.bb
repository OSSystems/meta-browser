# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2f926a59cd176ee62985af81aa327dcc"
SRC_URI[sha256sum] = "05ac2e0dd419448ad4f1e9cef3951397e8a615faede9688e08deaddd8278744b"
