# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b9238d3a79ed9b0a1f47672fd2cc41af"
SRC_URI[sha256sum] = "665dd9538028935ddc2b9b9003d85fc2892a6d5ce2cbbc27d75aa075489b2f3b"
