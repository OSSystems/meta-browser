# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "943d1e56ed7f083fa88737f071a572f9"
SRC_URI[sha256sum] = "50c8de68eb034c24a8aa88ccc47871f18617fee4c3c69bcc3c919fc824bf2a3f"
