# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3aeec106a1889c5f17a7b0cbfafd5a22"
SRC_URI[sha256sum] = "df16592514a9365f4a3ba5f09bb80a05c4ef61084b4b9fe45e69716dff136729"
