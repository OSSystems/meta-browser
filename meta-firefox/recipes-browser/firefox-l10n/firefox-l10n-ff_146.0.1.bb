# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "68fe5e2470648d989de42e24ada4cef6"
SRC_URI[sha256sum] = "db3b2d158d8c8d37c4b810d0956ba88e5b13f0e7578878752fe538a31baf48f2"
