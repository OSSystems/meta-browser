# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "409630b85378e13694e9e93aa1ebb26f"
SRC_URI[sha256sum] = "3956f686df3c46e00187adcefa55e7ff171f47a7b3ffcaf1750b78e8644e899a"
