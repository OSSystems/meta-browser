# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "142f6804c25e8c08180f80e62961a600"
SRC_URI[sha256sum] = "0d157e98f0394a79f4007badb912eaa9809dfcf335f35cc2b61e917400a8ed36"
