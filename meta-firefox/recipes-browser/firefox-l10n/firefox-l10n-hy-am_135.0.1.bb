# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "84ec480c770b630b0eb1776f2e4443ff"
SRC_URI[sha256sum] = "2c6401581aff5274fac566fcae7eca8aec1f6e5fa36fcce2a1147f546852c3e3"
