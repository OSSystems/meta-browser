# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8c7b3488ecf8f7fffd55f4a529349673"
SRC_URI[sha256sum] = "9f9d493e567381ea3272e589c40401732f3e4cd17ad2c231a71730674a628784"
