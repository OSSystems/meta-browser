# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fa56a8a214b0f2ac8e2e6cd59706f9f2"
SRC_URI[sha256sum] = "cd48645e7c5b4ca65f8b1a5f6d5fcdef84d9d800c51c9818e084d14fd2a05df6"
