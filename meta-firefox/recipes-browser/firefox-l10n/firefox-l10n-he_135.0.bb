# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a73997f55ab94524e584d0ef9aea851b"
SRC_URI[sha256sum] = "ab03d30040c604b07b577793d827edc4b555b07c54c095f0f96463401b0a4668"
