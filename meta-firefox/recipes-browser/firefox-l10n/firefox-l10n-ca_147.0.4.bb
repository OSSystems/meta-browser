# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "914519cabb173ed3accde9366a1fc3f1"
SRC_URI[sha256sum] = "1c5b0d194011bd8772f4a1ab4b031f42fb0d60c70c3c60208b30758c596ec154"
