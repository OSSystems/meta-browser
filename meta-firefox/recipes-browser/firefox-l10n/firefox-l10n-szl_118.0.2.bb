# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "de477bbd2214d0dfaa4890d514ace337"
SRC_URI[sha256sum] = "5a9cc54a21c3241786eeb8c8dfe05478e49107ecff7f68a6179936b025cab651"
