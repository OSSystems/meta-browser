# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b7bd58d08a3dff16f107bb356ad246e7"
SRC_URI[sha256sum] = "af7b71b27fae8911c41e1713dccb59077c317a4c802c49f5a2685e8563e7d2fe"
