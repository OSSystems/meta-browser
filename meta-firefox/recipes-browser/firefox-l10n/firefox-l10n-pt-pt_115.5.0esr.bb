# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "84f85d4b524c86d73943534cdce069b9"
SRC_URI[sha256sum] = "254cb82208cfa8eff01cd61808e33846902d5b95c72b2720fed837c2fa17a00c"
