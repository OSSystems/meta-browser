# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "74c02e04f9ddaf7a6529591b5fad7018"
SRC_URI[sha256sum] = "595830d5eba327967a17297473fd7b8163efa6747c18f88ad82b81240f1a0d43"
