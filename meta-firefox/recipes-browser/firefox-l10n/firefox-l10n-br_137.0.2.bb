# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f93297f356055fb924981ecb2721bb4e"
SRC_URI[sha256sum] = "370b057f222960ed56d7d96c24eb5f40a34d723da8ce88180db47f5d0236514a"
