# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0a46fbd685b543343e20ffdaccab6452"
SRC_URI[sha256sum] = "3ee441810fe25318919782a41b58424116e61207e2b92411b4af24ea3af7078d"
