# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a66d9c3f9da32782622347b4d0c8b6ff"
SRC_URI[sha256sum] = "d49d6d7f589b0423f61daed32123fd7eee2ca01396947960f6b09bee3d1fd48d"
