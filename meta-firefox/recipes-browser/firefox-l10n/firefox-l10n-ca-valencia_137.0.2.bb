# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e5f711b25108c89ce943c785e7dcc12b"
SRC_URI[sha256sum] = "2ce4112033d1788d88b85777073e319b9da804f30db28e0da1c8e3ae432391c9"
