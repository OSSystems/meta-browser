# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7b2329d9d4ef4ab842e8ae004e950079"
SRC_URI[sha256sum] = "eb701a98a358cb2498e0b403a1835d5422b7a7a005047b590d03ba63bf0667db"
