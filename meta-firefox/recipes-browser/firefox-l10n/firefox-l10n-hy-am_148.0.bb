# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7f4e9b70c5828efc011c1cad2cd938a5"
SRC_URI[sha256sum] = "addc970b47009a0a4f8dd7a463d106908284a3e0d35050dce18d6bee56ff6648"
