# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4b86dfc1ced9e6a1a3183df171be7abd"
SRC_URI[sha256sum] = "8b7a68eb4a8aa71dc1179f8c60dac920949c434c863acb85f5f7f5b8bfe6ded3"
