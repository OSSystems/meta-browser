# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6a09b7c6715c28fe784869018f864206"
SRC_URI[sha256sum] = "7e912f760e281e6802a32a4f1034f609b6df6fc9f4790a309cedfed409d74ac0"
