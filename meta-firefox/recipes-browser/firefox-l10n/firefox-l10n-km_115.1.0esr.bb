# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7f181161873ec225a557e22aa0f106a6"
SRC_URI[sha256sum] = "e5f2d1397a890ecff5544740b5e1b9c23466bda7884386c55eb1ea560488052f"
