# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a06945c34b53df29bc387a16ae163399"
SRC_URI[sha256sum] = "cb74aea39174be846a51349e5a6049dfac7f560f7c3c7c82e22de73a29fdb0c9"
