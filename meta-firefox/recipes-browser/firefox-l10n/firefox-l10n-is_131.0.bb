# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7abcc482ab90f488a40d2bfa52c426da"
SRC_URI[sha256sum] = "60590607201036a0f96bac0e8791c859d61535e4cdf7d814abc3977da3817e02"
