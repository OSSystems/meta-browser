# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c5a55363e40170f60e7783f5e7d4044b"
SRC_URI[sha256sum] = "2a8030fb6c53eb1d408d64ee68969727d26cb7005b9dff57a96ee3d22152ce38"
