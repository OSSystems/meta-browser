# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e05bdffb71ccebc20f683a192b21bf28"
SRC_URI[sha256sum] = "df803f744aeec59093b7ad653f7d745eccdc380751d7dd33287bbe53613c72df"
