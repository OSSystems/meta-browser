# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8a062fa051dac932217bb5affef6bfc0"
SRC_URI[sha256sum] = "99771cb43233c31f6a779b3a67d18fed8c7de9959420e2f9bd53563d26d5a1dc"
