# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d0ac4ec61b1b73e064d4cb6800ab4b5a"
SRC_URI[sha256sum] = "6e9476c1d92b8d442faccc8431b4f5fef365723fbaad045ed7c444066c35ce86"
