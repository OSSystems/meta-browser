# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0744a6918089dc421d5390dc6defb0a5"
SRC_URI[sha256sum] = "984ab52c053458060d7a05a31d9f6c924e2627c8791a54ca98fd3b55c3d5ed74"
