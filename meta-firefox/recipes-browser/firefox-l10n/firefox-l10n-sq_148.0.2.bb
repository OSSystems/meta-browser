# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "def7651c45a6d64cd37b55acf34739c3"
SRC_URI[sha256sum] = "7214148ae43c1883c0b4e9d1255662a15371fe1ee919063322f54d9fba5d9e8d"
