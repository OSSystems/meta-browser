# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e1ef30d41dc39beb63ac5dde5724bade79d44716e3b3eea8cf3c274ca7bda992"
