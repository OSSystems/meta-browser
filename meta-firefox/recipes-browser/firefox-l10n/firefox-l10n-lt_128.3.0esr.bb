# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "50075e86b665227b4a36d43ae8bdb68a"
SRC_URI[sha256sum] = "4746cdd053b4daf288bcf5188dcad1f6223d1901de469c1f5f82402a550bd261"
