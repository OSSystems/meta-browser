# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2a4d3a87c60c16f2040dc9a41821fba6"
SRC_URI[sha256sum] = "081f2f2d6fad64a0c616aa34fb56a9bd93169a218b82f62938fe42e7a6b95313"
