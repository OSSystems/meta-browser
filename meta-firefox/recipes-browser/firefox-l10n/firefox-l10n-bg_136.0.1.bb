# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7f9ab74cfb387d0069f987d71d9c9a66"
SRC_URI[sha256sum] = "cd8f4799e91463f244df18c19dbcb516c430b99572a1ccc655f0ba90be0b2849"
