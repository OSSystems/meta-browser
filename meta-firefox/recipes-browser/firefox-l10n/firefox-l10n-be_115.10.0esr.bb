# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4ba9bb73cdf675d53db746b788b66046"
SRC_URI[sha256sum] = "5bcc8cb84c55e959e3245a137dee5a04930a17602ccffa7143fc1f9d5827d81a"
