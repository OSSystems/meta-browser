# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c0bf4be93c99c88222e5080ece91057f"
SRC_URI[sha256sum] = "8b947397f182f84b148e5b147bb455ec177532567c8eee65e38152d1aa6293c1"
