# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3c7faaa6afe95cc14a023a1c67dbeaf0"
SRC_URI[sha256sum] = "d252723d2c111fa2c787ce18222c2dd4defe805f51a5bb6beaabd1ae8209704e"
