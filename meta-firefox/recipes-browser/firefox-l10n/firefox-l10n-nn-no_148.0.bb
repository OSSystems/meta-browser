# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "06c2030ac70a20c952aa204c60402630"
SRC_URI[sha256sum] = "2c70931f36256fe3f666a513264cf759f0baccd9b00bcb3591c52df7f830566f"
