# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3d652ef7d052a0624a77a99eb774dc57"
SRC_URI[sha256sum] = "5aa26603bab2e0e10fa16f5f4f592006d221953b4fd3c584bd393a75b171c7fc"
