# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "76f7ffb7fbd3976cbd57d3fd2d62c09b08fa28c49746590aa0d58fdbb585af12"
