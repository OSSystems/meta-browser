# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ba858252b0acb4b8d6142477af257c86"
SRC_URI[sha256sum] = "bcc418c3a742489b183137a634683e14b3a85ef11fc9ae3fd9d6759ee1b5fdc2"
