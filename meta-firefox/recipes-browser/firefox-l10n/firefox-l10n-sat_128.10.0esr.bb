# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5eed98242371d91e1ebb60586d33043a"
SRC_URI[sha256sum] = "21ee2606e0dae3db5d339deabcb795f66455a8db296253dd57bac8d493c3d2d0"
