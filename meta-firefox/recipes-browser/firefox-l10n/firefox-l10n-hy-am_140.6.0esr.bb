# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c815f462aa862f4ae0d6890520c94430"
SRC_URI[sha256sum] = "2f7e3495ebf6431d541dcc57937f60a14bd0ffea21f6a514bafa49b29cd80530"
