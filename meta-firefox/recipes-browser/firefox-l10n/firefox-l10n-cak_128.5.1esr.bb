# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "512554953f11486935b74d11ef579a88"
SRC_URI[sha256sum] = "c71c63fc479c5911dd5844efb7cd0f28e088beca46226481fa2758e6ff06e2eb"
