# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "340dd24be1f90d84d159a936e7bd290a"
SRC_URI[sha256sum] = "94d969af5db66ec7bac87c6586fafc45640ee43950f9f64ee3927094128579d5"
