# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6a68afd23b84b7e1953eff7fa6487d21"
SRC_URI[sha256sum] = "dfcd997e3917a1c0e8db3bdcd9207bc8e4c8ed84d716aadb26b6a2b9cf8cecc7"
