# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "da634b1b3e684aff8bbecc05bfef6991"
SRC_URI[sha256sum] = "101071daf7f2b4527d6e7b4c1e135ac3ce2fd7964ef3b911f11731ee70390c23"
