# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fbe0ff32679047de062b9f2f83ce8a99"
SRC_URI[sha256sum] = "45940033bbbfe53ce03c58a9fa60173a40fc1f43429c07c1f5e5ebc779a35b7c"
