# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0b4cb65e2c80b577061f3f2b9b635bf6"
SRC_URI[sha256sum] = "7fe4df52786ed49a0dbcbb1c2da1942ec2d6cf4ba1ebdf6364f790b63cc0f158"
