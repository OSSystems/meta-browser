# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "017c7dae64d6c05d8bcbda57a0e7473e"
SRC_URI[sha256sum] = "3f4e5d9999e698861637360637ed4de39abb0b81ab2771e500454f2c317b80ed"
