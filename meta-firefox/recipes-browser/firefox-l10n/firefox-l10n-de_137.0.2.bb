# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "59ada4d6f8503497db063472cbde2649"
SRC_URI[sha256sum] = "5af2928cf3e53002959268c87402c1bd92430eb50f363988502fce99d09ad880"
