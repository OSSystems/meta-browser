# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6bef123a1c7c6ac042ab7f0d0c397505"
SRC_URI[sha256sum] = "24296215bdd8275fbab2f2795cbfd56f275b6d7c65f81d1eb50083da231d0b7b"
