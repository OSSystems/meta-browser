# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f3f414d6835236493516f4d44f776de8"
SRC_URI[sha256sum] = "6703fa6cbf92435b653194418dbb30ba845377b621d06cc15214981f1aaa4c81"
