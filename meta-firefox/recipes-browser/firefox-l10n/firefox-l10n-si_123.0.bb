# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "38c6ccca7f8cf2ee0b1ae86d2c611773"
SRC_URI[sha256sum] = "9c45b11350873ac5b7e6c650844d661cd1663160c8978068b27a7af07820f4e9"
