# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "66e541c19cd9f7e481df80c8e6453b1e"
SRC_URI[sha256sum] = "0281c4b4f4fb130a49a7475dcc082a5f22ea7823a4818b6ebc5a2198955240c0"
