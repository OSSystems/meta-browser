# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d31324acde1545228a2f0c26cdece00ae5ceffdd63da6b3b941eb845e9771f6f"
