# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6973f4de8b363bc06603babb1e2d15bd"
SRC_URI[sha256sum] = "7abb596ff390e01ea68d14de5b5640715148b6d92b2d7df7433d1c47ec406885"
