# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "99af736b4da55f5a0d9380f8b730aab2"
SRC_URI[sha256sum] = "55a2e3201c846005c4d1be427737a17b8853aa0dff150ed27b746cd4ea03fef2"
