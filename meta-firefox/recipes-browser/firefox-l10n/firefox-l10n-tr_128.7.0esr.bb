# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e0c642207c7ba45a43b9df0a203bd7ad"
SRC_URI[sha256sum] = "a51f4ce04f654a0c03d99a1c6d35731ba6d652cb3bdda8cbf0314895a8d0a820"
