# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c786c52aaa20a86837d778025b99d13588c81b41de74fe1b8843995914817ac0"
