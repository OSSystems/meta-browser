# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7f01fe3b4f89425de078257424eb57c5"
SRC_URI[sha256sum] = "9c9cba4e7c0caa3b41be353251b866fabc0803443d5090afe62ca84660ab5e4e"
