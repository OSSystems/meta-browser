# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c04b877d90722104de7d40424a66bd95"
SRC_URI[sha256sum] = "90fcb771988c4e50fbbe7cf9f134fb3dc14197b59d4981f5e5690a7ef8a096e3"
