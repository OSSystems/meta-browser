# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c6f5b287a2fe6990856af7ca3983e839"
SRC_URI[sha256sum] = "35e6152d232ca1ade78c7d22304e269249e38c784cb3c18a5e89e46766749b71"
