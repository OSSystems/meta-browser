# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7f016b61454133e1e457e954aa140d52"
SRC_URI[sha256sum] = "8a24238f2758b54a9823c194fb17f193c207ba4e8683c548b7702dbd4a3a1883"
