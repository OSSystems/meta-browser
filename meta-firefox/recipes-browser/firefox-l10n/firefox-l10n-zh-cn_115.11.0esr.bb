# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fb08dc1abc663ae06caf81c72265cb1c"
SRC_URI[sha256sum] = "d95bdabff2e62eb434135f96904f774075a6a320fecada546a8709b98ca4c119"
