# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8b71698d6feb9391a9202eccf38583e4"
SRC_URI[sha256sum] = "74992d7ff7641deee3f8a9d5627db5523776a519a5b6df6af735f8cc8be19a39"
