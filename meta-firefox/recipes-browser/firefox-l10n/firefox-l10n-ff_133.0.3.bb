# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "523ca15c7ab9f8e31ba8e943d96fac01"
SRC_URI[sha256sum] = "e9583b892a8b3c73ef626d6b689ee7437bcb2620f62bf4b19b8139b55470e5f7"
