# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eed430fe4fb8d8c225342ec540c4a7e8"
SRC_URI[sha256sum] = "9caa6f577613385a4e1a3881d457f4262ed5d4ff8fbc3fd6210fed49922164e1"
