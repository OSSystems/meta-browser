# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "530346dd5d5ac5c18e0f98041078004c"
SRC_URI[sha256sum] = "b92b171c96d8c0b8c513a93a05af02238f035497b1726867cf3ae5792a9bd853"
