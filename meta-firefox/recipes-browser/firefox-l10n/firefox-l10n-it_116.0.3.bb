# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "825ca752665b1803ee61efea4e765797"
SRC_URI[sha256sum] = "62d6bffaa7d795f754f10ba48c27a6eb30905119cede9388380fbfb2ba09d637"
