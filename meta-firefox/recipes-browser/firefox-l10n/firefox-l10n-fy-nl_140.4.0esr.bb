# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4e877feaa82a4d3d634cf244e3cc8d6c"
SRC_URI[sha256sum] = "d1e5dcc00aa4d98233161725e2929ac3b98ae2a68271b499556365478ec2e81a"
