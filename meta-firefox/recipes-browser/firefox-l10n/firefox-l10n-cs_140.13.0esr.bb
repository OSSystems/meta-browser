# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c3352fb6275cef8468d1a6bacd92682d3ac1c45172240f435c59f4a73d38859b"
