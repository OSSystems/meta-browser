# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8b621da26e93b3bf7a61ef381923c737"
SRC_URI[sha256sum] = "785d5f278365893e192c07085b60ec5a9d14456465711e299fae8d95fa19d22e"
