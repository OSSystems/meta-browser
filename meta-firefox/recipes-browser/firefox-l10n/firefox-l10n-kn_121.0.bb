# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "879db08c4eef2655aec1c517cccf1398"
SRC_URI[sha256sum] = "e99a8908c25e744afd7b0546ef871a629f533aab64b398dee0ca3fdff31605e8"
