# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "628b1592dc3790704bd988d94ab74987"
SRC_URI[sha256sum] = "558981b552db69478e014166d13187efaf5c5f38489b042a9e41775f377bf8b3"
