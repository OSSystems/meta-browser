# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f7b875559ce012f6a7e24ee7d8192607"
SRC_URI[sha256sum] = "663f2261c635532ffaa9a70fc4e4b3eeb504246db80467f4a45b884fc1b14513"
