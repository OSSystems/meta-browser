# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b381fc89d9ec4e6e748246c1ee99df5d"
SRC_URI[sha256sum] = "900722bdacfc67fda2f0494aa62d1e26f6beb72ecad3e714eb1f3b075b1257ac"
