# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d1b8a54b4cc27d266bdc72108121da7b"
SRC_URI[sha256sum] = "14362c36ef6b943d6f0979b6ccf042c5e07cb7f477422fe94fbdc3e120e59607"
