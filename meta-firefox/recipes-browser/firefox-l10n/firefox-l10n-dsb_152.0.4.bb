# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3844ea6ab3411c28924bcbe3eb7a8fbf3cfc69494580ffd4991b220494992a26"
