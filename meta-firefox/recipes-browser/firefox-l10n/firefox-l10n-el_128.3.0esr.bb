# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e920770b1a0e6258a9377906f8c6621c"
SRC_URI[sha256sum] = "78643b83b802c6986f98a8e93027c1194b7f472c2745b78951eae9a5ea74750e"
