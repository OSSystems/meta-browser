# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1d4b39102822e3323154dce8eed4ed47"
SRC_URI[sha256sum] = "1fa4e330e31512dc17a295f340ddf78012b04be38d981f142bdf53dbad080238"
