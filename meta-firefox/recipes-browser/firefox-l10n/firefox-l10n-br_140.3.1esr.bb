# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "545923cf383a975866ae715ea2404687"
SRC_URI[sha256sum] = "bc29a61ad6aa21dfa22062cb60f81c0d8df5cafb07e53296e03fd13f6eb9d4d6"
