# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ac04451bdfef16c385a6befe6dbebe49"
SRC_URI[sha256sum] = "20daa19c5c06fd806e3b67e0001f2149eec10b98ed6c6eaa2b26d4084057101f"
