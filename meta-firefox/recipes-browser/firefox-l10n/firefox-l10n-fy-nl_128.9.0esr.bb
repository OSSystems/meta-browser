# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "19e5231bf67fb55ba35e5110e55fc28c"
SRC_URI[sha256sum] = "9946a455d394fd1bba5fc512ed9dc2721d301b94615d59bf21ef47277799ad28"
