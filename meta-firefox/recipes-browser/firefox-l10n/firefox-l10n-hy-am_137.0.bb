# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e128faeca2e7dbbc3f8378687f1aa3f4"
SRC_URI[sha256sum] = "a04b364c0a3d0bd9b756cabc6f3bc94b44dd6396ad9896fb6d7b3179e6d66bd6"
