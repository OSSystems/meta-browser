# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6316c0478641b5db14ec77315ab38ea3"
SRC_URI[sha256sum] = "fcf16d8df07aa8d13b4f97fd2c9be4b27bc59d973fa2bb9d5f4ceccab30505a1"
