# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7d05f2c30880bc2765fe4a13a7b8b60a"
SRC_URI[sha256sum] = "4982bb54a18344e163273b870de3d980186f2ff4cc28232418e7235a5ec88f6f"
