# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eb89cbd6c36421e6cdccecd8d6d20247"
SRC_URI[sha256sum] = "43615a8e7e5921171c0ca9a140bcf04dc79a1b7ddd03e784bdc4be29ea23a4a4"
