# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e6059533eb1a3ca06db897e80fb23eb8"
SRC_URI[sha256sum] = "d35a6664f091adbf6de87f6e148df6d3b58ffaf2803c69898fa0c28df1795e5f"
