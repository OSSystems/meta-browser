# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "4742192d782f89dc6d9e82c611d43f7f6888c7ba0e64c2ed430b45dc9d2c8a9c"
