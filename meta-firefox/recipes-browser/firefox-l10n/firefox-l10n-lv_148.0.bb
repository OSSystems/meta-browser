# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a9ceaef15a70a3a38b9c208a524498a0"
SRC_URI[sha256sum] = "f74691623cc251479a6f3cacff2b9774dc95286fe11c6bff0eb722dd135a21ef"
