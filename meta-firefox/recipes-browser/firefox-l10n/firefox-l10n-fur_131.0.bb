# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5eb8f084f4d9f046d7d54e8f3a2f54de"
SRC_URI[sha256sum] = "408af00bb46dc07df8abb0a4aea6f7b97d758893086a9704a5519c9299046ead"
