# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "285c7bfb25f7f88916fedb14c5fbc69a"
SRC_URI[sha256sum] = "c919f8a623cdf657b5425f5251a8db03ffa7ee46bac136a25f8d7a158b380b95"
