# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3c7a8af5d6bddc576eb56657e8ba42e9"
SRC_URI[sha256sum] = "7af93df75888efa49e236da43fe203c19dcabf26cd1189f89deaacb13a215247"
