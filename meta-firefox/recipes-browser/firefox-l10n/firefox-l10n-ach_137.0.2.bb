# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f4201a3985a3556dcc12cf02ddad902d"
SRC_URI[sha256sum] = "f3890778ec6a20f659a946f838b2228c526dd8a53ef4fb55855edba49f2a3687"
