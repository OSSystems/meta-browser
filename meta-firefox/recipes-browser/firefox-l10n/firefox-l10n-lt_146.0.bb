# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1961175a468964a4c6b438e172b3c2fe"
SRC_URI[sha256sum] = "ffd78fc8cd3095c30ec0c506cfb18eeb7ab4f64756734676d159a65aa1f2ee10"
