# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "200fe2dc0243ad27cb5d7e415bddec40"
SRC_URI[sha256sum] = "20fb131536505aac98d1897f66344e3ba6d6048ae8c8e9b81f8b949b4cffc8e6"
