# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "845f3fc0794bcde980ed66a1c3f51eb3"
SRC_URI[sha256sum] = "71fc24d5bcf407373c9a7e74c20f090fd1a09afc55cc235eaa08a8e2a817f7fa"
