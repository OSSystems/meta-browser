# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d637c63074b937072a6441f25d4b5699"
SRC_URI[sha256sum] = "a024fd60edb921a33dfd1616482f8597546277d6280e086281db8113e1fed61d"
