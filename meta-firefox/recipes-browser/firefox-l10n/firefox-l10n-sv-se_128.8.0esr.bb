# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1317de773f8925330ebf7f8ae1c5adca"
SRC_URI[sha256sum] = "25a41b036e1cc81b14011623b3a5344ced8f6a848ec9923e85fd433bd5fbd1fa"
