# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "6380441001c30025ae43020b9584e2a8c3ae8bb9686b910c71e98147057d6bc2"
