# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e2742d726aefe8695eac25cc323dfc85"
SRC_URI[sha256sum] = "39fe57aeabc67f68d4d8f9634fab84f1f750dc7406bbc9ecbc9520c91c41168c"
