# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4d6b4c6afc854bd0785a81bc3e6681c7"
SRC_URI[sha256sum] = "3e78b5fbffeb18ae96ed7a5a596eb6b8aa38a1e3286460f6e44167133fa78fb7"
