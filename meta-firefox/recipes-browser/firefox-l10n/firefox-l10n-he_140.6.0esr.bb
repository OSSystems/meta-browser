# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e6d4f1664d12ed24d9cfee4c98d9dba8"
SRC_URI[sha256sum] = "bafdda797a96e2316c4b4319d2d977d1112dc18e6fa27a8ee3d8d3acdd7aaa4b"
