# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "9b16163ed5f63fb67f1514dabb583b2fc31a2498485571b4339c3a728106114a"
