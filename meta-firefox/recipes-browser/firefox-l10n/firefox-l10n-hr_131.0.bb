# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ac68de9cb227081abbd95e912adc54f5"
SRC_URI[sha256sum] = "bfd66b12d0f61a91dab776171d60139e89187abf836fb668d7327ba0d7bc2d94"
