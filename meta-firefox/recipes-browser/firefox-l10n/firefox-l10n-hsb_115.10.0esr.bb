# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5d3e1ce84c0fa756390e8681d7123fb7"
SRC_URI[sha256sum] = "9d95e439c9acf13c4b870215e45fc78f3f3e893817a7ecf91593ecef2c41ec08"
