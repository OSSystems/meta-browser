# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9d35b548a5b6f35258904175e4497c7b"
SRC_URI[sha256sum] = "4c5be11c15806604c85b5f1b68aa7ff044b71c1e71589fd4c58a3a30b5f58e1d"
