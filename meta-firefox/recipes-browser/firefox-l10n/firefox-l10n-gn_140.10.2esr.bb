# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2a3823a7fac676660576740f88d15e77addfbc18049f7d60c8033d532aae2185"
