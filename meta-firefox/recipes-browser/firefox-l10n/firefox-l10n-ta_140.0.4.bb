# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "84fcca99049a06f5be7eaf9ce6c0465f"
SRC_URI[sha256sum] = "cbc2ff52c9cd3c4bd5b1744f1046ef8ca2b3eca2a2b8cd1f4f8737c529d89bd2"
