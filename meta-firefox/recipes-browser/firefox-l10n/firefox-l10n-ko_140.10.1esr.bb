# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "99cea41c1df0fcca69fa0cc5863f671bf44bf32a6de0eff9349a4793447adc2a"
