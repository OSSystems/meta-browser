# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "83b3b756ee5e09bdeb562b3157e1ee9a"
SRC_URI[sha256sum] = "89aaf9ba28abcee619c74f747a0c75d0ef463eb5c8c0a8cbd6e3c1eab0bf9ad2"
