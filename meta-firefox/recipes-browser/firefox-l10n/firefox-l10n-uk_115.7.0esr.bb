# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c6a89dbba7e3decac14ae96fe17f04fd"
SRC_URI[sha256sum] = "bec935f49615826411ba8201e4bbe7da981769ddbb5bd40240d855f5c3dd1251"
