# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a9a25a336b53545ce626234c16417a09"
SRC_URI[sha256sum] = "36570c30a3142e831d6e85bb7c92eefd3ecb05c583a364839185f30e50f61126"
