# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f14cb1a562ab5928db53785cc8d9e51c"
SRC_URI[sha256sum] = "efbc0381abebfb1289fb761cee6323585a90481b0f197bb5579db97d2b4d63f9"
