# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "807d2e8a491d1917c4eadd9d61ed9550"
SRC_URI[sha256sum] = "d2c508eaf9fe6f09600c29202e1e537566db3e7b012e3788d866d0e3b735e5ce"
