# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "81e92b03d9e6e27b1fccc8ace42e7c2a"
SRC_URI[sha256sum] = "f5b62e5a0ceb4de4252fe6ca1918fc6968679dda4f978e36400f88c79c1a6e20"
