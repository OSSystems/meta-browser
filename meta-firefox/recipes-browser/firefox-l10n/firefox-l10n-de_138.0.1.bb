# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "69bde139db3d42d7c0af56cb5f79eda6"
SRC_URI[sha256sum] = "4084445d5fd86d7f7675203ba1bd65324910d0a164ece25393af19853ea9cee3"
