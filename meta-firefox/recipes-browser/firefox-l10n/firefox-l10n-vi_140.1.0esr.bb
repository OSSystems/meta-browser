# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "531b6b43d1cd506cf1324fabaafde46c"
SRC_URI[sha256sum] = "3e206bb95b999cfe271fdc049b1912e7c2e3540669f5ffae4dad07e1edbb5448"
