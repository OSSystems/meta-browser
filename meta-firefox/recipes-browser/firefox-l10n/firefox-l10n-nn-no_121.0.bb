# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "53e4652446464f98cdf1ed56e5de5bb9"
SRC_URI[sha256sum] = "8529ebd64c1c7a5e1ab943a7f1739fdf9cbb4c17dfd2351b0aa3c99f9b007719"
