# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "498aefba67c07c95acb12a66007e69a5"
SRC_URI[sha256sum] = "16a9eed761e51bd2382d6cab203212e9b902a0720712b61df667bc76ba2f8f31"
