# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d5c24a4f923d8eb393070eb35d1674904faa871e809b541b32c7e16126e5d080"
