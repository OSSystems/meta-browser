# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "81cdbc86d81084ad83cb54bb71228e6e"
SRC_URI[sha256sum] = "f8f3bf14150a1a5722eaf2bdf2ce9ba8c79ef647d5a2d1e6e2e64fe8d71163a7"
