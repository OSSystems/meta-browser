# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2919b7d0b9e5aa295b799bc08f99ba19"
SRC_URI[sha256sum] = "7aeed65253a9b50cce6d82049e30ea977bd82ac126a73789b73ca61e6d73a5d3"
