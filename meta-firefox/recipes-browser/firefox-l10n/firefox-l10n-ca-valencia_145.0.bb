# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b3fbcbf5d734e7ebf4c8b447fb281662"
SRC_URI[sha256sum] = "9da51e37d1b8d8bac15308c43e98020b6bf1f00b99eb9d1fcf1f93aa6b607d9b"
