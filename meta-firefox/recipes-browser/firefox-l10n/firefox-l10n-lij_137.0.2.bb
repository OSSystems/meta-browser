# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8a32088e750060c26ab6c66fa149b26a"
SRC_URI[sha256sum] = "bf70ee5c2f37a82d97d58e1a7fc85e5435da2638be15674ca53384afb95d8f08"
