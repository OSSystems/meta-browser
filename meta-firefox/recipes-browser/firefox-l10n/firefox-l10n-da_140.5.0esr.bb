# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e5704313e9900d12d98785141e478634"
SRC_URI[sha256sum] = "d3d08cc21702228d95e10a40853fa9faa46653d3cfccde9520a1b82144d7a002"
