# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dbc6d5ae5a75e62993b82f567c1315f2"
SRC_URI[sha256sum] = "6018511ddc3113282a66b51f40d179713185bf5953c2750ce6a4b3ec2d2ea244"
