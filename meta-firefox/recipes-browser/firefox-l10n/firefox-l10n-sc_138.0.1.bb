# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5a868cb915405e4c80fbde934c5e9108"
SRC_URI[sha256sum] = "46ae4bced2c0e2260ccfcd6eec93bef8816190825a6e3563d8850292548a676d"
