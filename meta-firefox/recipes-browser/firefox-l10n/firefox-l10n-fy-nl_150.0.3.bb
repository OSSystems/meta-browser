# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "22cfa7ff640689f25bddab0e1f7d0781ef5ebde58d00737629ad20613c654088"
