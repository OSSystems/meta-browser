# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cd25a204cacad8f5f9d8b0a17b69874c"
SRC_URI[sha256sum] = "6ec8f0c9c255b08451e0ab9b38848ebc8128f6631e0a5333bc9d654d61bb9211"
