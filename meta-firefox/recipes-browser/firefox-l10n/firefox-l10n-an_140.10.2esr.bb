# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "44b0349da2baaeb2d6c9e73a4137901dc99c2fea39bea90831eddf427c13e7d7"
