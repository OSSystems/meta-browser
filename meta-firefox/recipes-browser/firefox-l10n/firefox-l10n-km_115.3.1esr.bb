# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bde35aec770c136357e79a2b7b79ffda"
SRC_URI[sha256sum] = "51597e179da1e8a8cf17de05f656f6993c6366e19d66669e2b7e319904bc5b9f"
