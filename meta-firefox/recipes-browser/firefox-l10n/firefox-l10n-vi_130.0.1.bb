# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4c126bbb42d9c425aec4f0f379d6b529"
SRC_URI[sha256sum] = "397835970765ad950b9140b46b3bcba79a39d550e2329b6c9241efec44656701"
