# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "720c9c1ea7b2437141e3a7296503a3be"
SRC_URI[sha256sum] = "d492e3cd02e4ad1756bb432dc8130c2051494148e60371a834179a0eddaa9ed3"
