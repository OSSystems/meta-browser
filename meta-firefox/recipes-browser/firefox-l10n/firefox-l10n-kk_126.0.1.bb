# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b4a639a0a99929d04db292df919292b4"
SRC_URI[sha256sum] = "3c37a7abff04be6906846442139be07c67c28325605b0282889a16c200a5abaa"
