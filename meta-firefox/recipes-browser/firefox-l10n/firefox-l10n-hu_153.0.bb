# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "20c9eac1cfc84fb55eb722d302c7557a09a95471195d6912b43a8f08b11fc837"
