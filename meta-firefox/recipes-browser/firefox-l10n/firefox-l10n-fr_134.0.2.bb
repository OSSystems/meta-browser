# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bc6607dcc4afc83ac4957b962de5d2ce"
SRC_URI[sha256sum] = "34fd11bbdfbe6d3c795078cdc9bd1ec48991c6680f7a7331d7d2f5b0bbcb511e"
