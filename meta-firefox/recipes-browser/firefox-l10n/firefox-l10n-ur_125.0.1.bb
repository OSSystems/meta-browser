# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a487104be09bd89a2f2cb5c6b181abc0"
SRC_URI[sha256sum] = "8c737c8d9d8adbf62a30e42cae6f3c8b5982a01761558faeb5135685257dd7a8"
