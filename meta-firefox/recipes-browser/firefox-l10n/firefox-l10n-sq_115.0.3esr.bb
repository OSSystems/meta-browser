# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d43ca5f23b8d0e2d8228822a6c25ad2e"
SRC_URI[sha256sum] = "09dd1058b65dbc1f5cf7c5fe2c788bcc8c984276863149f01c659087ef63ffd9"
