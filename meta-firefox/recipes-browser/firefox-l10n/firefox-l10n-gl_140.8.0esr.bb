# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "02aff4d97ec0560a987195266f423a53"
SRC_URI[sha256sum] = "1522eb19518130f3d4417333561c852b59381359f934335538d3ac6d57705c48"
