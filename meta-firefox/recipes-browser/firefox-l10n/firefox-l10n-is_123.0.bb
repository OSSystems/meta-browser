# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "744aecd2f26a1e8f9dbe3de073848336"
SRC_URI[sha256sum] = "86d47d4cb7772fba2a39eac8f32c4e108ecfb0fe63b91c900d68858cd8b92a25"
