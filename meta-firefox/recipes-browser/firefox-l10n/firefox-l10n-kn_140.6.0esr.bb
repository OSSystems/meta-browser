# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0e3d6b181ac02f8bf9dc9799c4b366f2"
SRC_URI[sha256sum] = "085a94d9449ade30a16c806f3618b0850467253dde01fa83dbb1b3b7541f99e8"
