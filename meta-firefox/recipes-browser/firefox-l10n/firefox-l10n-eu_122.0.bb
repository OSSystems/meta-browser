# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7fa31ee99a192b485d9f2a03252c2768"
SRC_URI[sha256sum] = "709a1f6d4ad462c538e181dfc5bb9dd6f68fdf657140d2f7e53d56a7d1eabed3"
