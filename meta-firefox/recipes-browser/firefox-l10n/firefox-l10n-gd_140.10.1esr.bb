# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7c622e85eb2a98316d8357d7919db38a4ae5a184092522b69ce89830b761efa2"
