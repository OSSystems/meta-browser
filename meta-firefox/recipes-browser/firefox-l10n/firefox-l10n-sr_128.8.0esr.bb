# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "366c949c17ab926e4546bca2e0859ea4"
SRC_URI[sha256sum] = "4d617a1e8db262d6bf525717d2d8825d25c1238dbb2db175aeba88f99c7681b3"
