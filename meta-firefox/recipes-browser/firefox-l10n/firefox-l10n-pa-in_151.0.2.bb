# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "abc8487715c794f869ab9c871156013230ca6c3e9cec3fb4e0d4baa8d37fde05"
