# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "949730df19a47098e44abe3d950670e1"
SRC_URI[sha256sum] = "3845f442311965f3832c7810ecd84ee3b663359d79bd2b5be11d203ffdc260ff"
