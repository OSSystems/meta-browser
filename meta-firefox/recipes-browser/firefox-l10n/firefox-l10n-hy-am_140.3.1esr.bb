# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8019ab15387eb847f8487b65d53b6acd"
SRC_URI[sha256sum] = "1ca4f73729940ceb41ddb92d449890d75ef338b74f5abca4b5ef85ca74ddbdcb"
