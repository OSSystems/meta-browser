# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fe2690e396a5244c7f4c27130e4810a9"
SRC_URI[sha256sum] = "2155aee7f8bb8404163775943bfe77011b82227e2afc1289ed3bb5b27ffd548e"
