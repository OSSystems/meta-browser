# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5444bcc7873b46a2cf4038d11c468c08"
SRC_URI[sha256sum] = "a58fa4d84252d1ce695c7c7cbbe9d9c555a1d1ab06e32eebe89689f49cabc264"
