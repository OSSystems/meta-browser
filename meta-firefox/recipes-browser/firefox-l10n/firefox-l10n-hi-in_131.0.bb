# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6439d82bb59f53a81b3cfce3f7ad8ea9"
SRC_URI[sha256sum] = "5e69825ec9affe3423b376ee1f1c590bfc7b3549679b0f311abc08a88782681d"
