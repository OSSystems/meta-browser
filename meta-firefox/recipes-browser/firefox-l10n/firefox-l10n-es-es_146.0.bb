# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "12c6da108a3b48530c4d4fa9871d232d"
SRC_URI[sha256sum] = "a0cb350b88da9d950eaa976dc89c999d68a839abe9162db5d6db85c427a2957b"
