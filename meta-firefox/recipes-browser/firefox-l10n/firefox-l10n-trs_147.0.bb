# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f4ae2bd0f23e352ee951a36b4bdab5a7"
SRC_URI[sha256sum] = "5c73b91909ab2f1b96063892fc01fc0a131ef7c638d542be892274ee99daadd7"
