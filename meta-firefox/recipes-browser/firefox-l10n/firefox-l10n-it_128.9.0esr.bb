# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "59d75395982cf249eccea67aa7b6bdb2"
SRC_URI[sha256sum] = "5e6d779bab6e193b5cfc8ad17ef2b867381b75dffe83f0eed38376193ca3286f"
