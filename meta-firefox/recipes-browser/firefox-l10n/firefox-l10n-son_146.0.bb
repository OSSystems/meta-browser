# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eba0b49ed8eaf7c17131be91725b5c9b"
SRC_URI[sha256sum] = "8c598d45bcb19fdde15871a33b6cf2c5dadea4301e68f522e931ff24160a9dc4"
