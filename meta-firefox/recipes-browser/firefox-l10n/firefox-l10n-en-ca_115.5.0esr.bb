# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5e8a1d857c957f6134de1280956bc808"
SRC_URI[sha256sum] = "0743754ba8b36a54648f26e599a3bf3fcae3fd33a062e3b089095736cf8eea44"
