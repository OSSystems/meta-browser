# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "781db9d96c81d448a12c337597da9529"
SRC_URI[sha256sum] = "9ec52288105951b7df9a13fc54b3b03d4b705d1dc4c0d5ff196af08676671e10"
