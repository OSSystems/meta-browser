# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "444a3973ab583f11d231c889510822bd"
SRC_URI[sha256sum] = "3e9f30b758d33fa34fe1ba9f6d894fc27fa3658a89583b27c9d52884a935b22f"
