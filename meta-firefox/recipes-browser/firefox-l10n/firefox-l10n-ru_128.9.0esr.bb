# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aa4996af9956f56b05307009708be271"
SRC_URI[sha256sum] = "481401acada0e27c92a9a17a32af042891ba1e188893f9338181537afb5447f8"
