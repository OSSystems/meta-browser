# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "31ba131cf130fee0abb8beb16fad561f"
SRC_URI[sha256sum] = "fee2aafa92a25d6505f2255896de876bf3c0c7384472ec2d4c1e939d00a07eee"
