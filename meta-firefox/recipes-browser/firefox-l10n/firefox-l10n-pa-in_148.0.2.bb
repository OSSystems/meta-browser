# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a18a6d87f600e59b5f98460ee47b048f"
SRC_URI[sha256sum] = "632a400a49eee85b9cd09f360993ad06d4e1191cccedad30b90cc56d6afd534a"
