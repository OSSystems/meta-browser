# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7919d74428a5b1d3adba24404c0e7a17"
SRC_URI[sha256sum] = "52a7c22fcf4d57b8dfbe7f35423acb4cf8f128d328aaaf6bac4d85be8af6f1e1"
