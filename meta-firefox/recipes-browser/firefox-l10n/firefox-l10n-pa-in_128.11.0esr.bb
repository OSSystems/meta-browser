# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "57c60321e80c2ab66dbd5027cb0978cf"
SRC_URI[sha256sum] = "752ab663373a66343a34c8b96e09413827ce5a61f07bbe426de4fbc8f473c554"
