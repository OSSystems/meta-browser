# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4176c053cceee1a47b83c467485fcfa8"
SRC_URI[sha256sum] = "99a9dc5d90fec187cd68e2a8286fc1ae6a5516eac14dcc6c740d77ca20d6c7d8"
