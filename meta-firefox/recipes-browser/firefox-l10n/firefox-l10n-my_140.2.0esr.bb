# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d1f2997de4e97a4376dc7d06d0f8f58c"
SRC_URI[sha256sum] = "0e5fa2d2cf9f52d23057d5192c310e6161b6ba1cdc1e6335a7ef5299d1aa1f07"
