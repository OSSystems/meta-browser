# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1f64cb17ce8ea03fd0d9a78432c51e0e"
SRC_URI[sha256sum] = "4425fbacb3efb0ae7ff39110b03161e26cd3b344a67a14800b6fb81b6d1c7d26"
