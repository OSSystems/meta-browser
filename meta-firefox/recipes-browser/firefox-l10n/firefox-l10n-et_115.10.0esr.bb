# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5ba5d85a99476d2d8c5b81a96d0ee931"
SRC_URI[sha256sum] = "ae9b5cfd421e5a449112daf6ce24dfcf692e062d847ba85002467763756a9fb0"
