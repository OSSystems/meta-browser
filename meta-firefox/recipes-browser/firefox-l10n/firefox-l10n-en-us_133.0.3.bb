# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b74144300e34ab203497d7bae9749ce9"
SRC_URI[sha256sum] = "b2fcbc96f792a71655a07db92b97b30146fbcaa5c922f7b71b2d8374b115a292"
