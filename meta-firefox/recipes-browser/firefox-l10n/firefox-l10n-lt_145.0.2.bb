# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b6e247e437fe86c7c665fe3243939c21"
SRC_URI[sha256sum] = "555437e5c859cd040b1668e9411fca828cb82c8f2625d4e847a34b5ba2397bb3"
