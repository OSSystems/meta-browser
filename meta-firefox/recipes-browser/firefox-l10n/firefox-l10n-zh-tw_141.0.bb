# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f93a6ec8468ba151eb20ef26cabd73a5"
SRC_URI[sha256sum] = "b85a4b9af01d15552ac5124a124f84f39136495535e93e94de027cf6814feed9"
