# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7c49fd3162b3c433a17e279e3327e111"
SRC_URI[sha256sum] = "0b1e1b37b3ff6c23987e1a507cdb5b57fa35de91135ae4b637f4975bbdfcca49"
