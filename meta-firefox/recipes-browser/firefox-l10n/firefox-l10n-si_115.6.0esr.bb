# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4d3ca46b9892b3387666e8dc72685efb"
SRC_URI[sha256sum] = "f13446c8aa84be0447e4cd03e177d038a8e41c1eec0e61b7d1ded1d8e3fd9cf8"
