# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aa4a20b7986bb7b163f7862d5cb3cc70"
SRC_URI[sha256sum] = "4d8bef0a3becf9909b40f16f8b671872df55ce5adcd74ab692d7878b9bf4fafb"
