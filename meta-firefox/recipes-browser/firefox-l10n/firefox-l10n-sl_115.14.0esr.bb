# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d0edcf0683401986d552b0ae9e035ecc"
SRC_URI[sha256sum] = "4448bf8e241006e8278511dc4f9bb32bbcbcab6d6c6aab77cd28b6dba471cfa9"
