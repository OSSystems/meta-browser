# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fb04a349dbf8261b2ffdf702861362e0"
SRC_URI[sha256sum] = "1e2ee4a3638e3b4d43befb7fdb912fee64d1068c2728d5a2fedbc8fcdac4cc10"
