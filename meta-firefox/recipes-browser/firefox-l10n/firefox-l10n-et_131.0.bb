# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "de1c79a2ee5ea7eca906cd55c328126a"
SRC_URI[sha256sum] = "26b7946cad5d69040b668afc9b49a9d0024b573f79e5b35d11d496fe96cb4d2f"
