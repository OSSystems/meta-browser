# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3227bbefc053033e06d8dddbdb7e61c2"
SRC_URI[sha256sum] = "97f878aca00f9eabfd28b0f6a59148080a004d25b18b53585e045d7cdb6ee048"
