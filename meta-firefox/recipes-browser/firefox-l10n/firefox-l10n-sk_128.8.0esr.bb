# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cc257168d7fa7565aaf9fa0bb48596ef"
SRC_URI[sha256sum] = "45d76776b4ad16468263590b6123b5fbd08e3d1ffd9bb0ee3a60b71842471846"
