# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9a5287d9b5c4336f07365cdbc63bd549"
SRC_URI[sha256sum] = "3b0f61c8c898d5164042c2aec0e978a89e7c1abaf1fca55fde3167eb0e447529"
