# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "f55092a2472ac130d7c7015bbf13fde3dfffcd630bdefadc2f66ea1fa7ac6aa4"
