# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "efdbc8aa40c11d5dffb5ebc87039771c"
SRC_URI[sha256sum] = "37ef519ce07e433a913f709e13621cf1bbe624315ce4cbe5b5f752c254425180"
