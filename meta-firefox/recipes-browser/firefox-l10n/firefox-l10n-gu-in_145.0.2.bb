# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6a331494c947a84be2d158aaa6fe9572"
SRC_URI[sha256sum] = "ee7ef70218e96ad5141dae79e012e0b3e51b15e5682d39887e976f61e18cb464"
