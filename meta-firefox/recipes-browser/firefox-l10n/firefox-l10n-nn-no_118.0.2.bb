# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4e204b33bbe4a846ca3778dda6b8908a"
SRC_URI[sha256sum] = "0ea25053cfad3cb0979360c71e40644fd713c351853d9f5f07fe79acc9445c08"
