# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2eaf0bcea6004800b44bcff3fe1f5fee47ec426f58ed5c34342f9c5ea20903ad"
