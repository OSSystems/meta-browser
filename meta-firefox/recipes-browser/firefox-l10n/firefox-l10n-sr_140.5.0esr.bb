# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2e9505f0e5b102f8d147a84b21a9ebea"
SRC_URI[sha256sum] = "9bb5b1abd1f4314f47c297b810f01662f29f53d9f499c4bc9d356aa643401341"
