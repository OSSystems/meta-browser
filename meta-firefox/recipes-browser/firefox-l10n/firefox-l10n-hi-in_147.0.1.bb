# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c8dda88b222785db856fcf36c71d903"
SRC_URI[sha256sum] = "52ddeb42c73f1d4f9dac68c5e184e243b6ba01680437b94a8591048e0219df21"
