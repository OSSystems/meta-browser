# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1c3a3799e15e171052ff02965451f71b"
SRC_URI[sha256sum] = "4639640dafbfac40e794fe67a83c3156c5cebd88050eb0b15c2ae01039948efd"
