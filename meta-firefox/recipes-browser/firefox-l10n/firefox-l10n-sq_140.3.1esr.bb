# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2bf9323002d2ad04b1eab29b4a9415d7"
SRC_URI[sha256sum] = "0332892d1ebd6315601c8df31999e65be6c8817e405b20708ef899264a7d42b6"
