# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "91980b263d76dae496105affca4e522a"
SRC_URI[sha256sum] = "1eb2e1034ebaa14f4cdffd7a99b14da8b08f95516ba7cd18415aae5c7ee2b7d2"
