# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "531522ebf123015df275f4ab9d4cf83b"
SRC_URI[sha256sum] = "3f958b71a26f2f688e972ee40ef180535efd405d5e7345d2ea6b115136a0c8eb"
