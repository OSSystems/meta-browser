# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a9572da67da6bd87c6fd93d1d86a261a"
SRC_URI[sha256sum] = "9a79d3be6b07c631b21e7d461df7a7bd5f5a65b369ae6aae5e2e7e0b9d41caba"
