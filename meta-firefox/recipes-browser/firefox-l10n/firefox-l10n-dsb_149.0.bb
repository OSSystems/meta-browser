# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "148b38fcc6e925e13f62407249e44b3d"
SRC_URI[sha256sum] = "eacdc144d421f4f160981f181f837b1cbc1dbe991ed4f5d907904dec8ec737f2"
