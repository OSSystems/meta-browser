# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "500d4888673e7763c0ad16212ae199aa"
SRC_URI[sha256sum] = "c3966983d62b641ec5b1ad06256ccb527a5bcf4ea7e3a25819472b9b920c7675"
