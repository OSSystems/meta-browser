# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "93db77c3bc43e98c22acb5e2d2cb7bcade8b5171a8f4e348d2c0e1b92b7bebcb"
