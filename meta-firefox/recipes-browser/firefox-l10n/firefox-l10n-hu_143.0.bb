# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "23b9cb7cb1817af3fa579e3d65992f9f"
SRC_URI[sha256sum] = "78f7322a461198ed1965915c71dd82793d3ee691b7b8803394437b5bd7033d6f"
