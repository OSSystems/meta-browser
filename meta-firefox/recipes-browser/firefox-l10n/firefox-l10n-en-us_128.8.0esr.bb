# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e84d46fc1a5636cdbf175cf96687c7ef"
SRC_URI[sha256sum] = "7a3caaa2baf3930624ce4bfcd34a52af7895484104668d7acc139d1e25fd306e"
