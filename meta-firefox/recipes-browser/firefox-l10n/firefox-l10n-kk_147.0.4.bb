# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b66cc8cb777099cc17b0bc2624912a3c"
SRC_URI[sha256sum] = "171b7a1b80351d5372c7cac244d4949200a6c7ba8d00302a81a41883c4907a2d"
