# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d62368f5bbdab3940342a71950318c49"
SRC_URI[sha256sum] = "3f8ff228be01cbaa7144c992e2123d333a2e3d7156e8fc89b7c3389701d6ad47"
