# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5f557059ffa279aa185ecf81672b28f4"
SRC_URI[sha256sum] = "21755701e45aad961a308e784f6e1ed3018f3b012a01006182c951193823db3c"
