# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "93812a93b0569375b1b0f4b897b07563"
SRC_URI[sha256sum] = "86e67ebdc73e0482ba8ba32341f6a30c82ebf9858cee4f29a5e0a29841edf130"
