# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d5083b4a4b9c3105b953d0a1c452006a9c0f724f9e30ef9e7da6f0d8a7a46c13"
