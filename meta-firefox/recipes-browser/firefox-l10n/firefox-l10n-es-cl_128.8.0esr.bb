# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3c64e5f2c68effdbee2d4ab4d9fff3d9"
SRC_URI[sha256sum] = "2316e089f7412b5509b7c971c8295661801980c267d959115ffb14ec324b9973"
