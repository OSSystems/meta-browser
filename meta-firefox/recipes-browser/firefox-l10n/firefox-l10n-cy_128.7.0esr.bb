# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db97776863b4c12d258f291472e8eac0"
SRC_URI[sha256sum] = "fb105c37003cd40cc8254726160ec78e368ebb63b0d7dd130581243d63fd01f8"
