# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "84c272752f6e785c120816781d73d19b"
SRC_URI[sha256sum] = "c69b397add9bfbbf7c2b9da0301e85c9cf029ccfc8d852497b6e5a7663ff0a80"
