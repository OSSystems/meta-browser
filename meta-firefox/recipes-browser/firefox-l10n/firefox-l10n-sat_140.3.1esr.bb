# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "df2b74e60378e6c5f7e076dc050cb469"
SRC_URI[sha256sum] = "4e8c55cdc2c18f84b5b729532760f1b8416adddc49795917ece933fbac034540"
