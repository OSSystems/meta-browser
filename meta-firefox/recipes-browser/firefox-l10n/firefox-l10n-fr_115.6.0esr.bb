# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "41714d4bc483bde2b8b6cce26220feef"
SRC_URI[sha256sum] = "4c8bf66c8b3e1200befb0a11668341cd006481c9d08861b0018bf2c205b90dda"
