# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3f87571ceee2478ad6e35986631a1283"
SRC_URI[sha256sum] = "3985358a57d46370818fd19535c21e1565894c81d08f009447ae5f4cea42fdcc"
