# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9975e4791658119639a80e8a22a98a13"
SRC_URI[sha256sum] = "9bde894ec5b10df520b808fcdce19d75748da3ad174bd29f923f15dba4be4d63"
