# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4d4e4170f9457d41e7bcc402ac4c51b0"
SRC_URI[sha256sum] = "1985813604e89672133ebcbce4ef6625d8617fd9ccd73a7dfe78104bd434f35f"
