# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "283170b6754c3ddf96d5afd9b8a30920"
SRC_URI[sha256sum] = "ac035157b9a72cbf35dbbf98066173749dab231527dcbe0015546dfbad9fdc72"
