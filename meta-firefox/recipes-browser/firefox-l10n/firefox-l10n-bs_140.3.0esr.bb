# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "486a6ae76f0c9c75208be227261717eb"
SRC_URI[sha256sum] = "fcded217ae7ce9ac41ebfcf6f88eda933fd8f256b78636d4d045f82af010ffe2"
