# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "18b25b5623133a2da3c1235e8e72ee402752d77534f516cfef50484b3b821e69"
