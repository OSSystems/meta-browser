# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "344ff0b9480294ca3286cf3da8e25a3c"
SRC_URI[sha256sum] = "5937a538e03974255937cf18c785c4424ac6bddec6de3b3a52f6cfadd15d685e"
