# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "741d33b526713f5b8429eff677e16f04"
SRC_URI[sha256sum] = "96da164a502d05c049afa2ca21fb999ee4313a13ee57f3850e62bb800a154350"
