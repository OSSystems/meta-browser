# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1272e1a4c026864a3fbd40e381d38e2c"
SRC_URI[sha256sum] = "a59e597ccaa2c1757112f69880df601527ea458f287506c5e9cdbbede14c4454"
