# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "376eb1eec2642be0495e7bc4312fd707"
SRC_URI[sha256sum] = "241185d22d886a40f4c1e9df7668763ca7a0a36a76b3783a084d1df36d953274"
