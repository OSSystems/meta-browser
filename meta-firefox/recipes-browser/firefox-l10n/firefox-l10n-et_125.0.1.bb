# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7caf2c6d9db6bbc1c9f6748d2a8c2963"
SRC_URI[sha256sum] = "cbb437ffdeb9b0ccec7799be594f8fd6fc7cffa58731c3b8c8405a8440a5c214"
