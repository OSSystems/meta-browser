# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5c23c561fad6f37f045742ffb92bfc15"
SRC_URI[sha256sum] = "47ddde73e48644b355eb8bbfbcbae187d4dc3ca8edc27930bbe558a8f555674a"
