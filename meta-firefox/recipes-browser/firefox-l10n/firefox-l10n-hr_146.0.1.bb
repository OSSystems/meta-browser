# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7b1bd16c6451122fd6c7978e09318290"
SRC_URI[sha256sum] = "b74c7dd46d75196293f1fda88aa1fb6e2e93d07d1191a4e4c14f1353b623e656"
