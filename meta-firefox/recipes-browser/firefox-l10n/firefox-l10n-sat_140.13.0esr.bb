# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "0bcd4254c52688ef4fea1ceb20827a5d184f961518f1cdc1ab1b64933b9d0089"
