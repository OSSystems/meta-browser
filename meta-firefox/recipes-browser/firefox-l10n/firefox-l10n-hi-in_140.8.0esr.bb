# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3899b9461f527ab2397e6baf01e07c4a"
SRC_URI[sha256sum] = "8e9a35dd82cbf0870985d719d574e3c1290af5fad0290d8227773c9a8fd51986"
