# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ae9a76134709db525ba725f5ad80e89a"
SRC_URI[sha256sum] = "8db5a1ed7e9f4c1bae09f4f9df2a0e46734e45c2278c7159e1f720c7737abd94"
