# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4f37f3ed5f6c718fad9513a081ced0d8"
SRC_URI[sha256sum] = "25aa504a6a262b30fe86b246d6be4ff6791de7de812c91fa4c456456c1b11b71"
