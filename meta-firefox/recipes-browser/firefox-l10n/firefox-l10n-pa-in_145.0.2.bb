# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ddd1e193b2c84c091265991eecb7a6b0"
SRC_URI[sha256sum] = "662aeb090d97e8ee80b898c6a76945cc47e53bf73820ef19ccac5dc611fc34cb"
