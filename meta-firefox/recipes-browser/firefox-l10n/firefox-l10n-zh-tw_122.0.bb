# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "60e529107f18307891eb85b15f91d9a6"
SRC_URI[sha256sum] = "aaf02f453474a4055b5be10f53463007fc392499af131539efddefce39255d81"
