# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9b13d39a225ffb3172c8eb7acf254a80"
SRC_URI[sha256sum] = "5d0613508a106d0364e4881024bd3de2a29e1ddb8b1f03998d37d6ef004d2a39"
