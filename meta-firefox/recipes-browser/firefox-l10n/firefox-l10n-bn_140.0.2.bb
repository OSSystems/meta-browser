# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "532c01934762766ef617f2685614c05f"
SRC_URI[sha256sum] = "00ea6d77b86bdac798efc21a028785c6e7a975b2d007243b1840259687b8394f"
