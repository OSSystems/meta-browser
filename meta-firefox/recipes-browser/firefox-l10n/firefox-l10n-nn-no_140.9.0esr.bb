# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "180c642fe6da17970afe8c2e69cc3b43"
SRC_URI[sha256sum] = "b79577c08d50bfe643ae7131e0cbea9ce4fafc4ee9d3f4512bcef415ffcdf900"
