# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "61e1917c357c40e8361a1519b790230c"
SRC_URI[sha256sum] = "8547b5b98d9ff16bc03d375bc0943a371190ada4c64f237a1186eb869c706fda"
