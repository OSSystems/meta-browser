# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a9276a4635bb4456be05763e549116b7"
SRC_URI[sha256sum] = "d0087f62137c4b12b079aa32ba489d4323877520274d408a048f68e1c3bad321"
