# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bcc30f6e85cf8d8a05ce9a25fdce7b28"
SRC_URI[sha256sum] = "f24d296f439fd2cee35d8641dc34360a0991fae0fcf7615fce83219e4a9f851a"
