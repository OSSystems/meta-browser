# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ddbc7205febbd9904231742b8af8503f"
SRC_URI[sha256sum] = "9938986c190307b84c34588d7fc30297634bf233599f38466d22530ddc639c2e"
