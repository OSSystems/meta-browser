# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2e48e140acf8b13f3bdc321f19d078224e3f0a868cdf20989c793e6df1118ae2"
