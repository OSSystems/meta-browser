# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bca97e32ee116c3d0d179c25bbc96c2c"
SRC_URI[sha256sum] = "e5cf55f090abe2d8a31373b1c1d4cfd946ea43419d1293573f679697d31dee3e"
