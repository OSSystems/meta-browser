# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c2ad74f4f47fdd02dc2586dc8b72eb0"
SRC_URI[sha256sum] = "4a5ac71c628013d085944f709bc85724be3451d0ed635cbffe2645d2fe546e4c"
