# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0fc09f96e9b0aafa77fbd32c6fc82943"
SRC_URI[sha256sum] = "4313226d4197d605e06cadeed7712b7ef1ae19aaa9fd52d18bf8dd995cf9781f"
