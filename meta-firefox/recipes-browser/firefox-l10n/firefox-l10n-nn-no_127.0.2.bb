# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f0d7e96c6752f5ba5c5ca54f50f74900"
SRC_URI[sha256sum] = "1e1b3e5a92a1e622df2c922c6802bd9ffb3d26802b49efc1edde0c56797c8ae2"
