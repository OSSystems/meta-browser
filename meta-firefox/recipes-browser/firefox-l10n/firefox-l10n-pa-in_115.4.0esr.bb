# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9f4d172afa8fbba0539a341bec998f2b"
SRC_URI[sha256sum] = "434e1eff46b0d734c2d18931219157af133532d4d08652da8b4da7c74db69928"
