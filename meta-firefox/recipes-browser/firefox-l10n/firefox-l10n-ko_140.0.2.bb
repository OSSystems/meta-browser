# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "913beb3cb870f6dd161a54509f2674aa"
SRC_URI[sha256sum] = "1850cce0cac2b418d6fd293ad3399c4e960b62603b2567171bd1dff25f68df47"
