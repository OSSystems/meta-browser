# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2c592c7067c7efa56f38018d90c823ee"
SRC_URI[sha256sum] = "75253d79d8346636c8141baa12272ca6e37329bb06765e703040ba0f8c86287d"
