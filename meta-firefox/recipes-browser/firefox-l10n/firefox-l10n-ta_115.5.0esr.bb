# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8ae883dd83f58054f15c554d70adbab0"
SRC_URI[sha256sum] = "08f28e26f68ab476fe318648736d5f51d69f35e9c0cfa65e224fa3865d80212e"
