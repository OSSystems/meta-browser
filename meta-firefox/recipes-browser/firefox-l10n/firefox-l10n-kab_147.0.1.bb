# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "06e7a932f6ff68b8f70f45dc3f713cbe"
SRC_URI[sha256sum] = "906eac70e9e924daa8036ca44e2f81a8651e7f3aabc51468154abe8a85aca9b3"
