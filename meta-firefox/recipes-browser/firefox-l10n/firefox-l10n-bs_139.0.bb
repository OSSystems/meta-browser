# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "053df36978e3dcb39f21971f189f8a89"
SRC_URI[sha256sum] = "d33a711c1d1b4c85cac07cc1dab6e626d6421c97a848683eb8ba4f5943b4cbca"
