# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "602fa18e24ab3903bcc7b4313e671ef2"
SRC_URI[sha256sum] = "a8606e76e310a0f2eee350a2fd2dadc22a468eae78a1a22da2821eb8b17c8b30"
