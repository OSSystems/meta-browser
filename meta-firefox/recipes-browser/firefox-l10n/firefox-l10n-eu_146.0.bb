# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b650773a4dca226f11e0b303abdcc224"
SRC_URI[sha256sum] = "254eb89c8333b8971d0c7efe6dd04b59cd68cb3d55ba90c586f3297b73400c9c"
