# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7c1bfce4c02e8901756ede407986bb6ddea200d6d48961a36033fe449f1eb145"
