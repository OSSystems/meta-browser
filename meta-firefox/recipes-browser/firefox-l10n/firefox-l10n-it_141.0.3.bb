# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "77c230768a66638873da292b21f286fd"
SRC_URI[sha256sum] = "9f545dce338a56aee45ba6237381d6b1f417a8b5bb7935e14d635dd2baf561d1"
