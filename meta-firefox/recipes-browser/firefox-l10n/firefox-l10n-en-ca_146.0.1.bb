# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3d95a5632e30c021f8849ca93c371dd7"
SRC_URI[sha256sum] = "9a4dbc73a3faf47d4c3c0400f0709123fb5962a47705cafdfcee7286e571a803"
