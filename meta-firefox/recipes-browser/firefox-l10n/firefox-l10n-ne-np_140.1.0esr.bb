# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5fc826e60c29816e4786e64e4870d9e8"
SRC_URI[sha256sum] = "e7fb1f57e6fd8b2d8d0a431634c2e7f0ef2a21539bd7c8f99a38c75ca2fae6fe"
