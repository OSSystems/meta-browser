# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "78a1b10068d48f8196bb9658dcc78988"
SRC_URI[sha256sum] = "871fcf11ad950270342655d9f0191f09dff2431d570b4dec3c3b066d70be05cc"
