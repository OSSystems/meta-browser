# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "174a0fd74060781e24dc8311a7b78e9c"
SRC_URI[sha256sum] = "3a8a77fbce7a7f8ede21f18e6918e66f2da5841d198594acd1380c72e7cb4d0e"
