# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "972c897eea5af8105017645a972e7b25b2b8313b278e20a96620847b1972e036"
