# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5f93b67875f9b7f386c4eb9c2099e04f"
SRC_URI[sha256sum] = "9dad264b06ff5dedf1af04104bd19f69edd5509d2e7837a326e1c9c8923ff6ce"
