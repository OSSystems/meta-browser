# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "808bf10de347842505d69e5c0e9eb035"
SRC_URI[sha256sum] = "7c68b4a3f0a93de00a370df89cd7271a26800d9650c0e68a024cdf6a2f2eaddc"
