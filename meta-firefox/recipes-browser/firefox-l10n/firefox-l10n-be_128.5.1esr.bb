# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "13ba698fa715ba52a0a2f21db2423aec"
SRC_URI[sha256sum] = "0aa7e3723e818443627cc7a55ee3c5cc684d9c97efde5eebaf23c54c4729af31"
