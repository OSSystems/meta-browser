# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "168a5af36cce600c279950876df30aa1"
SRC_URI[sha256sum] = "2a8b5f716891d827f4adac051e0ac31a1c21a4c4e6385a60ca236ef5f34e0f2c"
