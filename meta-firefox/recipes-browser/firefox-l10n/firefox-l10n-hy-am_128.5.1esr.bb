# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "407c20176f75ad3c57e8d901049a7563"
SRC_URI[sha256sum] = "9e6b6914f0b61d4e427e81a741879a1918b650fac7510df9260930eb572c6f3a"
