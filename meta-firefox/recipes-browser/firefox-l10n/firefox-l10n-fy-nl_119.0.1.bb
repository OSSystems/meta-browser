# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "468cefdb3a839e9e783d20eb0e932eb9"
SRC_URI[sha256sum] = "5af930317364f647647755d5adbe2df03e034b3f1c99e1642d26093643059d7e"
