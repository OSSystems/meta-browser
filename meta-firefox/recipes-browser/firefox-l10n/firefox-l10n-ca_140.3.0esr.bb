# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8c073bc74f2c8db1e8d6a94f8555655e"
SRC_URI[sha256sum] = "9678344a53873d3451f32d48617823d2f483d4f8c8f77a652aacee87eb906fce"
