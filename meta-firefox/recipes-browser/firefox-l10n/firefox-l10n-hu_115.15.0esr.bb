# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bd44b4fcf0f2d5e7d09985dd6a42b36c"
SRC_URI[sha256sum] = "2eb1d2ce2181e6cd677e4723b6b0e62639b07b23852113f3d64f910dd7b659b2"
