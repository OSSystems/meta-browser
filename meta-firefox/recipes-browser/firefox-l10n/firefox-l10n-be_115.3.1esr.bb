# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b16bd2baf2877a30c33e6befeb3d1c8c"
SRC_URI[sha256sum] = "21445d3c4afa38c7adf6a9cbb22630536bb9d45475702a12397544b48841fd70"
