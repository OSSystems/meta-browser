# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bc93c64e1d01e85213ae3e897017f261"
SRC_URI[sha256sum] = "0b835f0344f66111355fa22f546c5ff8f67382c0a0f453bf21949cee8ede2fa4"
