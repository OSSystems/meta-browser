# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5d0da9b58dc76f47e92283d8a168561d"
SRC_URI[sha256sum] = "ff2734f1eed6affa5346c50b350ccf5ab5d0e825b007c93efd99369b94317875"
