# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "617f54b1d624f2debc0074016da0cf3f"
SRC_URI[sha256sum] = "a7ee3448ede0753272e33e750a4b9667b91e83d9d33c80fb201565ad1c67cd10"
