# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5b031f1e5c5b76fb1702ed0c73cafc42"
SRC_URI[sha256sum] = "aecdd3e1a080ff1d6ea88aca0a9f489d6155933894706dfc1d1055aa0a5694b2"
