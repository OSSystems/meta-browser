# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0f2e233ea4e2e4a870ba65ca2eabf2da"
SRC_URI[sha256sum] = "40ab2db17856c3bc819b2b7ae8d607cac4fd07eef513961e33a6454c4e76cd1d"
