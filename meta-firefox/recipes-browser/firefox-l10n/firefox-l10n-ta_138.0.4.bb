# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "81e3d5c76a0fec7a6ba0e83f6e6a272a"
SRC_URI[sha256sum] = "6c3d7b9c993926eb05f35237d45c3d15872ae499cf820354017e1979d21d8c34"
