# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b82fa1160576077a580e87b847ce9185"
SRC_URI[sha256sum] = "85e0825854486dd00825f80a641bc6ba6c8169751cbb7d7086b550b92ab83838"
