# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "455611c206e985b5dc986ac6c7c514c1"
SRC_URI[sha256sum] = "53e5a7e9e29573b9c36433a4cba250179cab3cabf176f4f26044fe955a461f3a"
