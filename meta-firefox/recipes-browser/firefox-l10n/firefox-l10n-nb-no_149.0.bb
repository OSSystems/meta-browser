# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ecc7b1153982fcbceab8fec7f2c761b2"
SRC_URI[sha256sum] = "2c46a51dd46290f77cb445699a296534008ef309402ad1812bb15c9f148c9f44"
