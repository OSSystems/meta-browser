# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1c9c0dde4a6e5dbf2d80d6666094d976"
SRC_URI[sha256sum] = "ec47d11163250c07bd904577b844a7cc0f0e0d067e79716a023365d69366981c"
