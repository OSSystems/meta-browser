# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a8d90d4fd274da1b7342ca6904f370c9"
SRC_URI[sha256sum] = "3932e48b0e0bc8fa7ef18d713a0e84db35607e2af2f5082652dd16d4f1fb2891"
