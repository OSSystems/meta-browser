# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "49efaa6233c8e72d180a9beca219c132"
SRC_URI[sha256sum] = "9faaf63fff48d8a5a68b1e0f7ea0e061ab7e6ef849244085954372d7fd70e99a"
