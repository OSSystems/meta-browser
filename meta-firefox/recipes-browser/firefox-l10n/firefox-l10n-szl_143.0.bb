# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d6b5d23cd6875443f3f2d6273f222635"
SRC_URI[sha256sum] = "18253e438f4e7712f6f7fdef4e1aa6e6709ed79591806fd088c77fc02613f108"
