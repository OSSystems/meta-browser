# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "22c743e02dabf8a672d3908125f67d1b"
SRC_URI[sha256sum] = "33c9fe1cdff608583fc57600a536375b82971c937a7a508189334c6bd748cd96"
