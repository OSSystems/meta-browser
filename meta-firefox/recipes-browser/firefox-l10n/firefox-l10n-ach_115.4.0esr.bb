# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "26b01990f9cdde130b98301c681590e3"
SRC_URI[sha256sum] = "f1eb4280ab82788f2ef84a249a99a63bc69cda134245fcf48fc3ca987c87311e"
