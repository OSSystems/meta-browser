# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b829d21d3fe8001f9685a2aa01b2fa78"
SRC_URI[sha256sum] = "0fb36387d1d67f756f45e669c7d800b950490d539f6b9c3867b7ca6391d9f498"
