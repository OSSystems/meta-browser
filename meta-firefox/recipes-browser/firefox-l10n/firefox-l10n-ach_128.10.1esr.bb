# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1825d6d2afa1e246b82b32dc2061c06d"
SRC_URI[sha256sum] = "fdbb60575b5e5513b7c5a63169c14dc6824d61268ea8fd64bb903033f9bf9d13"
