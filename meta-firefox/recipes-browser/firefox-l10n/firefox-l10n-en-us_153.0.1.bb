# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "494455247a967aa62944360481633e0bbfa1c733d4196f61c0fe6c8815bcf635"
