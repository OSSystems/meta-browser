# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "adab56d0e8a65f725e8a4091280b5654"
SRC_URI[sha256sum] = "1eae8fe1d4b7407a83955ee0fabc40d52050f56b0a1e054ba118099dc58422c9"
