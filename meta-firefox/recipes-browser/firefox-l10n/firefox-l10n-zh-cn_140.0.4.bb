# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0dde59c25ceaa70bc0f9481d063fa4fa"
SRC_URI[sha256sum] = "e529f9f025667e0158cabb42fc10017f96fd735b9feb8167237bb938176ed9b8"
