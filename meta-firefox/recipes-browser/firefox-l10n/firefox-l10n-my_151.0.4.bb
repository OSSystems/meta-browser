# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "279d728011f0fbcd4bb65f2bc6731174a7738b306bb36f6b6859c4e7a89c5a2a"
