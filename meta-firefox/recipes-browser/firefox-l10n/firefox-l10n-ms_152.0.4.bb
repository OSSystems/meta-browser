# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "1b7040aea42fbb1874e45ba9e44e006d941e552f7e264c3b4e7bfdaea2212a5d"
