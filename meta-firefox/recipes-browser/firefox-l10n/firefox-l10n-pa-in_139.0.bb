# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "882144d59dddcde938b93f5412671961"
SRC_URI[sha256sum] = "265ee66fd89fbc05fa04434ba4ee261a11ff1164f6fa9954188526e580a4db8b"
