# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "57f7dca0eff45e88b87c6152dbde48e9"
SRC_URI[sha256sum] = "eedb9e624c604cdf4640ea044bd2bfc10f80fa1f182c555e260a9f17a0467859"
