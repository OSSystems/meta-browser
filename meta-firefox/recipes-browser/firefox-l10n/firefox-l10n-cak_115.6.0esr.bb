# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "31e24fb5c14f80c92fcb218d08847872"
SRC_URI[sha256sum] = "cd69802c28d351a0d04ef70f7f8af942afb09a84a092420a27ce7ccc5275ff6c"
