# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0903a6369b38b2c674d090a2e6218eae"
SRC_URI[sha256sum] = "c3ca4c75c01e5018d97a98a5bda5099628573eb88daedad66d605a11d78b23bf"
