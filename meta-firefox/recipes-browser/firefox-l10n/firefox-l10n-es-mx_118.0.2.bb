# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "414172cf09a6e47ba6bd2fe973514ff0"
SRC_URI[sha256sum] = "a95a286b8be59fbd5b0dc2ad02c540568a95953a28f66a8993812fe6dd20490c"
