# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7bb3e01c54991f2b7d70e25fdf3af5d6"
SRC_URI[sha256sum] = "d7bf24fcf40a3ad027adb92248bdaca8041093bc91e5c631ce07ffc8312d1ee4"
