# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "845c6a523b154d91e8ac0c18fa95f4ed"
SRC_URI[sha256sum] = "7d6b913da8ca9930e50feeff87e66afcfeadc3c5ae6979ab0ddd3c7f41cf5e0c"
