# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a745ba4af072a8b3b11d45ee1b9e3812"
SRC_URI[sha256sum] = "8048a7a6fd60e71a85c88032e1abb5e32eeb79a6d70927773997641afe1e8ef8"
