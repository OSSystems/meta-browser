# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f6c19c25310f29de4efd79ab9c8c6ca0"
SRC_URI[sha256sum] = "87fc61e1b6d2f3fc56c48a82e2c6fa0d3497fa6c788ed9c4a59b6d7d96325479"
