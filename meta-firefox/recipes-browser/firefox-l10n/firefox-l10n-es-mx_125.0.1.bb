# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e00a5056628ff9c14f1d0be0e517d7b6"
SRC_URI[sha256sum] = "aa89dd896f739dcbeb66f0ac0ebf4f9e1b695588df34755423a2eb90d192edbf"
