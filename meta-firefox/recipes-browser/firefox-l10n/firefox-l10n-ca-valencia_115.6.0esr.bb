# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "75bd0e2999425a6720e0620d508e7f71"
SRC_URI[sha256sum] = "6349b7b45aaede0146c66d34e749926c4be2fba9ee7313ddcec5deec5ce0cef2"
