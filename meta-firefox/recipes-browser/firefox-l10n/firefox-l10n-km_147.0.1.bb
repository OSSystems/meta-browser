# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "567ea92185467582591b63751c8bd39d"
SRC_URI[sha256sum] = "dca1740f23f1b208ce545583ef2f9c094f69ae96336f7a789fc30d894d01c667"
