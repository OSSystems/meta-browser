# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3fc879a5589cef7b19befa07e35ddbea"
SRC_URI[sha256sum] = "f80425b588e953bc4a867f84e18583aca6c613416087fc7453e72fabb4ee1634"
