# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "cd37e8414a71f39c483c74b17eae3650d24821d79b0f74929067f7f351a6b921"
