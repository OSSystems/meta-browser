# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3e5192c722e7d44c5db43c34c466cc3b"
SRC_URI[sha256sum] = "5996a3a281642f6bc3ebddefb03371d6c61b1b9e2495fb124b7430e00bc55ce3"
