# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4f485380f3ea9da11b11660f8ee650c9"
SRC_URI[sha256sum] = "362e76f323170da7b956cc6fc23f9f74a0e4ae10290990c8e8c1023c7e4cf72f"
