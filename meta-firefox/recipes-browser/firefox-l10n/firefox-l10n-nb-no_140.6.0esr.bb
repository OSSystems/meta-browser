# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3f986d410b2ae164e030c3950cfab72b"
SRC_URI[sha256sum] = "505c73dea7a286e11aa852a00feb2da0e5a3872b8b9c5baa959ecd661588082e"
