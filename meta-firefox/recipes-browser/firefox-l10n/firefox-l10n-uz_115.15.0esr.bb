# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2f24c6765e8116c891f4f243aed31e5c"
SRC_URI[sha256sum] = "4a24c1163d48ea02835935d465a56943a22ec3ce719800914355e16612549349"
