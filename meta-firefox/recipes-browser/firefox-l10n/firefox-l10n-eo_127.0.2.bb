# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3d6e0517d1792cfe23748073a9aa86cb"
SRC_URI[sha256sum] = "02a161480691a54836fa6cef4848758516e95b28ca6e980b7bd3eec92aa4b203"
