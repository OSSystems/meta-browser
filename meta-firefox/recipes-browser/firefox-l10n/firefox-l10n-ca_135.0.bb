# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "23973178379b47b06be54ccf0c084d23"
SRC_URI[sha256sum] = "5f37e32f917c4d368255ace22b2b92fb1c4ef5680bc29007f7200d5ecb00227c"
