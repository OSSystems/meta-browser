# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "848a77872ae371361c75ce496f0cffa5"
SRC_URI[sha256sum] = "a23ef9cf8f1de8691d6e80079ed7f07c8cd3585e0884032ce267081ea2b808f8"
