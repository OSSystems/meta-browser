# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1256e0c97ad565b6ef50b106398e061a"
SRC_URI[sha256sum] = "5785013c46d8d6d3d12059d8b8683602987633bcce66ddd0f69eb27095d6fe38"
