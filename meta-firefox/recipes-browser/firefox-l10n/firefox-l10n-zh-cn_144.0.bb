# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6c9594e1fd7de4643abc334251b1e4a1"
SRC_URI[sha256sum] = "2af03f809d3e15e2e91cdcd8a4ef574875c188c624579c8364968f31ab21c39f"
