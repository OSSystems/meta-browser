# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "8ef0b7788734d911849bec2930f12bfb7bc9e68a90dec1e7845ce4a5377e99d9"
