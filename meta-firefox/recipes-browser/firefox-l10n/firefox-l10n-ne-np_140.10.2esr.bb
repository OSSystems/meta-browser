# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "1b18c898f781535d6e8f256d99af9a2b25c1961b46e1b34c6ab4a7840ef4aa51"
