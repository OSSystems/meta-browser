# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "4c6d64e2cd2f6ce44a9b6900b78a278682e1e0b87eab7facd9812c2db84bf49d"
