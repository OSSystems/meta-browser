# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c2a9c0909d5b699b26bdfd3228aa4af7"
SRC_URI[sha256sum] = "8b0d0c12ee47868857b92b17e87df1deba8ea8015cabe83dcb2525a11dc8eff7"
