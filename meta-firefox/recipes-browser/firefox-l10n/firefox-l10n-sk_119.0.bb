# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3e3400f4ba0d1ce2809a7af17338f32c"
SRC_URI[sha256sum] = "5a24c4e93d2c402c91a032801656c0a027a0f95f92373c6e1c0357b0862e059b"
