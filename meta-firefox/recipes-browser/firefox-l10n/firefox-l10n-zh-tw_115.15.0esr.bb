# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e3f6a6a6ab34090dcfe530d8b23decd9"
SRC_URI[sha256sum] = "7b69f8ef5e4431ed9130d6fb8918e4a0511447a0f2629d0a3269fe14e82b7486"
