# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ee68cd548935755606b9c366a84a267f"
SRC_URI[sha256sum] = "b4128a0ba2b05d63e9680f417b3fe6e37e3d31c508d8ed9fa2d7a240d2b924cf"
