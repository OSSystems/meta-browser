# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f7b105716e66233f92ac29086ce95d23"
SRC_URI[sha256sum] = "c56d230acda8c89fec99e419513f442d87344f07a851857c6d1ff4304776c355"
