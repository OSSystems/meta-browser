# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "62233600a00f64e4a7d708b2dd6b8609"
SRC_URI[sha256sum] = "781e5f6cdfaf08de24b166c8b4ee30c8ca85a30221b4f96bc8160b92aaa116d2"
