# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d726b8015d567259099464781b114010"
SRC_URI[sha256sum] = "ea1ef2e3ead1077ed6663aa09514712739bce64b2552644d15a27b0b492cccf4"
