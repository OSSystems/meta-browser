# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8e33ef141a1ad2d984af6821cc3c602e"
SRC_URI[sha256sum] = "4784618b375fdd1d88d4ddd8be428adfdabec4b41094e3ca28fc7ac1ff9a0528"
