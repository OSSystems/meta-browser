# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "0ea17b307613dea7c4b623a5fdcd69c0777285a1249f66efaad132d324bb97b5"
