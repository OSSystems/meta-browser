# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "56f1a194c548898934739e53bda3b4b0"
SRC_URI[sha256sum] = "b6f8cf5e98c2339486626ff19cd54bcd6c92bc92411d467046584acd848ca69b"
