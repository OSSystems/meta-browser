# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f8d99c478acfc46b7f9df77ada808023"
SRC_URI[sha256sum] = "8608f999d327cce0e03709731fcb304373ad3b0d9b123e2f3f0099a12e42a3c9"
