# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7833b7af1a6b007118ddb3471634194d"
SRC_URI[sha256sum] = "be8885a5b2c88fd27aec8380ff161f8a0ff3327d01dc30e06ac4eac1615cffce"
