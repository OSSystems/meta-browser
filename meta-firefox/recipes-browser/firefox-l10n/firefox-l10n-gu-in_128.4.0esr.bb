# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c1d368583ae59873eb18f4471c90f711"
SRC_URI[sha256sum] = "7b608585910334d29d875e98498484e8d58df78da9e4b9cdc11ff9751052044c"
