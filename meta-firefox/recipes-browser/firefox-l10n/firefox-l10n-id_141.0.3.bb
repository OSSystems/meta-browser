# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8b8842cd5f3a53d010a6114a39abec12"
SRC_URI[sha256sum] = "1a43a4a63f9c2f66b5f6f083d7ccb15f5fe032e1b419f5f67182a634f4cd49b9"
