# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ab738e6dee64c839f2a8dcd466ccfe58"
SRC_URI[sha256sum] = "25fae4190f48bc3ef47b635290fcbc3b4e4b4bd31e9ef044b29382fa64d0fa71"
