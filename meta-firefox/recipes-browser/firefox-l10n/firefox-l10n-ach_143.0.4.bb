# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a1714faab0223c08b143c1df2b4a35f5"
SRC_URI[sha256sum] = "c822a449367e3abda0ed703c86baf1f9095dc7e11948ceb6c163e635d55f596d"
