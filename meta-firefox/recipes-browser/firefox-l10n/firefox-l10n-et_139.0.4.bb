# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9e26e189a115828671927a0dff010d56"
SRC_URI[sha256sum] = "afbeae9978cebd1fd75e6f4a6ff2e9e7e328bddff4bd8cd07f9819f46bee2991"
