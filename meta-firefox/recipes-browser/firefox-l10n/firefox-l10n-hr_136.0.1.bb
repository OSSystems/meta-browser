# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7acb614d976b9f6074e324c8545ce686"
SRC_URI[sha256sum] = "5d4cf16772d52c888ca315641fb92c72ab360acba7245ab49594936b8d0eea65"
