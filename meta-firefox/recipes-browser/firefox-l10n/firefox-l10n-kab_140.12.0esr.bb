# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2cb43091643c327ba758c84f397ebafa4473099f6876d1bdb6a03dc800870254"
