# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8bd30c5d46281a44416e94ae511b5bcb"
SRC_URI[sha256sum] = "0be321a285f2638df31d7ea91d60941841e89e492613bbaf5c890d3b623055b1"
