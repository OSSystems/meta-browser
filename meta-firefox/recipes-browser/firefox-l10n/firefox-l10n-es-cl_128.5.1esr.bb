# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d8638ed48a35b5297e1dfa155710ed68"
SRC_URI[sha256sum] = "b286d4287ee4f2e9f893324235a4b64be94a91fc12c485aecb1b087c979f8b0c"
