# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6aba86fcfdcedcd7aea5bcf992424d1b"
SRC_URI[sha256sum] = "eb4fac41902417bf6d16f2b66d43f0ca49072df2687333cd3d7ab1740f445c29"
