# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ce872310cc22b364decff0a2cc9ecbc2"
SRC_URI[sha256sum] = "14adf2443765a762c1b6c9b881c5da465b2125944e3ecc5e949945d784e1e16f"
