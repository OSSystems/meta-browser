# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8b9e39caa1f26bd762adda642d2ae72b"
SRC_URI[sha256sum] = "663fa0c0b47a071dbfcbdc9b05f7d9ef149266b2e8f2820919a73594cf3853b9"
