# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "58c55751729ce9de062788d804564663"
SRC_URI[sha256sum] = "f63e659cedc23df028ef3445e5674a0cf727ce823529b29929a10005c0153fa0"
