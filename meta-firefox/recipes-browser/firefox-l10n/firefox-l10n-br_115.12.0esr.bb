# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fbb9691e42a45c2560d2e51e027f78ee"
SRC_URI[sha256sum] = "392870e0e9ba1d2de22366d04c30b89b3d92a78df3c07f83a499c53f13f80bd1"
