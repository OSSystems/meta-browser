# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "229e4cd8f3624cf184569460fe203320"
SRC_URI[sha256sum] = "6f0603815fa096afe5704f4eb41c65fcbd50744434b36a4f63d2561263639242"
