# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7d23e62b6a98d8ee67af56eca9ae2456"
SRC_URI[sha256sum] = "22bac57f4cf682c5d59571c27063692b9dd26264b99921568be72851ab17d570"
