# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "729e50ab736a1224f7725bb7fdec93bfec947ffe165ac9778e77b4dbcfaca87e"
