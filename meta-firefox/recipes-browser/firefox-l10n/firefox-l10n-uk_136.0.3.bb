# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "986243dd147d7457230519f1c5c6d4a9"
SRC_URI[sha256sum] = "f46a135d4a6d86525a0fbd96fbccd5d74caf166756aa2ecebab1aa3b5f730203"
