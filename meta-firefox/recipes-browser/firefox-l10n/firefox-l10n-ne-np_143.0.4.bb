# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fd842050294aefffcde36c5d951d9cfb"
SRC_URI[sha256sum] = "d2ed9b3c925a7a1579c07b9aee44c28051874eb94986f3b45cc901a520220981"
