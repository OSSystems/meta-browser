# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ebee8dcfaac2e55824c7102731c9df10"
SRC_URI[sha256sum] = "f73d62d32f054b182f42c69b7a1d2e8f732cdb3ece00e7c831b3cca5e65683db"
