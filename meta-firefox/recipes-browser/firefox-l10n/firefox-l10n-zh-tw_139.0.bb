# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c9a818d6b2fdb65c906d5db4baabb0a4"
SRC_URI[sha256sum] = "c86963a8dbc73dee6cc73e5c34788a08bff121c238b9dd5508b944e1fb0876bf"
