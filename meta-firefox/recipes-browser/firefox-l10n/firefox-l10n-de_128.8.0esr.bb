# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4b52b2c140aa3992c84a803e28c7b57d"
SRC_URI[sha256sum] = "60b21be58f8f8bbda87f7de2da9ab617bb0a29849f01c4b921b29450a73c56bc"
