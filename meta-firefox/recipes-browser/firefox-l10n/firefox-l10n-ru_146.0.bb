# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9e98ce83f2e38356b0daae1b29d4a530"
SRC_URI[sha256sum] = "6c26ea0afedce05d029b442c7bbb2e3d9398da000540fe1ad2796c6e9b6f213d"
