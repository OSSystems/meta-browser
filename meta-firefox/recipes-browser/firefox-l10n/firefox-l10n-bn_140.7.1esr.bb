# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "903b3fdbe843088699ae61022c4a19ea"
SRC_URI[sha256sum] = "5bfef9a0252084186d6d298352749ac917e9a39209edfeefd499338ff27ef506"
