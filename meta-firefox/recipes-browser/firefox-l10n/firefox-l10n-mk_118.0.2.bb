# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e2835ac6a496fbf0f87052e85c220756"
SRC_URI[sha256sum] = "a56ea9274f7dda14493dbd1d8570419d2c7bc5c9eea5de2edde64d962b5a2b04"
