# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "27e528762054ae4d78ddc5c5abd00855"
SRC_URI[sha256sum] = "5748d3e4bf0287380040c0eb9f5a4eaaa4e920edff6875ba296a96d155dc13fb"
