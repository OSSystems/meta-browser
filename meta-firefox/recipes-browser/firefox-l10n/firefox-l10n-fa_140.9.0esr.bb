# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d59924941023ec4a3e5b0bde09221df4"
SRC_URI[sha256sum] = "9c639ba9b5570e59495497e7f1322e5e6cef83f6d47248770f5ec5a73487a1a7"
