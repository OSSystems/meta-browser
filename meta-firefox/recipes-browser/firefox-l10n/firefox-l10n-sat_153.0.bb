# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2a290e5c6bd4b7f284259737cafbe719489838e9e3a21644fd29e56a95e9e5a3"
