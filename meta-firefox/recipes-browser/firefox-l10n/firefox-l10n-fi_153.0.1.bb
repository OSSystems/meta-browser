# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d4623bb1f33e91fca17714793012a73539e872feaf3fa13ed7eb36af0ed4c178"
