# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "97f30a84101316954fb37d0308376c6e"
SRC_URI[sha256sum] = "c103fc3ed833830fc78fa68f87611594a86653f9b73815b16b8979c8dded24ba"
