# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5206d3634427360527d829f46d028b58"
SRC_URI[sha256sum] = "22df3367c9ae8682dae439daf817d413074fd9357b3de252134b1d2173f5c2ab"
