# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4ca19c8a5324439697f1cd4a15fcc717"
SRC_URI[sha256sum] = "ff25e0900ea50eb2ef72bc7e9077ec545152f5b6c01f298a8b3e0bbde6f5fd61"
