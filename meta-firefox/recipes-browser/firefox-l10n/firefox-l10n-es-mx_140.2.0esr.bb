# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "101ff0991ed3686f4198ab5e11d0b044"
SRC_URI[sha256sum] = "b3fc0d3e495baa5be9111ef988cd7793b3e9c5a158361ba34d146a8ad5eaf0bc"
