# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4022182837bdfe8b00f461aaa57b9b85"
SRC_URI[sha256sum] = "89dcc46f8c542e52e125d94e9a1e2690c9da5c008541f43875e3c4dbf89615b1"
