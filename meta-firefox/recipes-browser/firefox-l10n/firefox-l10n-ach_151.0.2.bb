# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "21b627a09763661ae8009ea3a5444804fd835657053f53f6f705ec80dafee503"
