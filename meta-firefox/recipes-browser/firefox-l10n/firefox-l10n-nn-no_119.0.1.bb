# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "82d74d1d9dd52365d32d1c553e3a3114"
SRC_URI[sha256sum] = "4c63adc54e58f3b130f94e16d82b0539a18a898665545ce3f76f9b0fc6da019c"
