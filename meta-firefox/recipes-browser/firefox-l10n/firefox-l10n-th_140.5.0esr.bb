# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b063870dd12c1687fcb043960d69867d"
SRC_URI[sha256sum] = "75f1e883a6497528f73c68007aab70ac8c73ea1c2c266197a48f31588b64cbd0"
