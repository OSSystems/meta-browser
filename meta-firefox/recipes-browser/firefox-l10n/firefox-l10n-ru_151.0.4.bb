# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "9f75a77fedd450a1cd386865f9cc626bb47c1c22862ac675e23b1762fd36ba4f"
