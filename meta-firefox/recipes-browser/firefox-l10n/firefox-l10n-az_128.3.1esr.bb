# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "00b346140fe97a4f959277fd4641c9a1"
SRC_URI[sha256sum] = "56960bfdd90c2be9d2633a47d3b4f502ce79bef2a75b3944eff91882a87e8663"
