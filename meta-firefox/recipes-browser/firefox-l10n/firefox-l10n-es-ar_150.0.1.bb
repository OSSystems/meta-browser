# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ec136e00828a7b7bec6c4c9c70224ecf7f4dfb925ad4050494ff11f03517811d"
