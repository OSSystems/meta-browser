# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6a6596283dda9c9116a7379a60d78499"
SRC_URI[sha256sum] = "100c9e5e2e81a5c7b5662de5c5e8fd7104120c48fdacbfa905852aa921fbb51c"
