# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cb7f22b3df7215ab57fcf15afe258780"
SRC_URI[sha256sum] = "ed10aa5db853930d775e5b652e10e9cbf90c772b3a58708f3268e2fa8d5d5667"
