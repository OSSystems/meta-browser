# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e6ec97c491d5e692d60d305e06b51ad9"
SRC_URI[sha256sum] = "511571cf2a5a97f83c41329ddea1cec10261c2f10667694b2a3c90f71d7640fd"
