# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6e5084511b519c358ad14df4de7624f6"
SRC_URI[sha256sum] = "8452c81207dc6d16be8e70f7202c55615b4284d6f9770dd990cbd09312fb196c"
