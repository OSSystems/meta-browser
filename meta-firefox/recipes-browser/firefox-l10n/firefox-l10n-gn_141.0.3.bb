# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5b938a4ad34570c75de178bc11daeb75"
SRC_URI[sha256sum] = "064e8c864f461efeccfa2d080f6112b747f6b554fce0bc5aa0b5d4c8dde90884"
