# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "263f06061c80a08a6cc48ff378d4de7d"
SRC_URI[sha256sum] = "6d8e42f29fdf143d64b7c18c547b398f8ce523a992ee55e37000bdc82a4fc502"
