# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8b8b17032fd2f7cf1b0cc9deb19a3860"
SRC_URI[sha256sum] = "ffae4317f067131e88354eeaf82f265790e7d83ddae24d467512d88bcfc19e1b"
