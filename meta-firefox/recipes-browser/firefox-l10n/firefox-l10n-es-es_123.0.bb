# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0104d0bb70e070d8e85a93b9667b2873"
SRC_URI[sha256sum] = "c99f760aebcf5aa1dbddb0a04e302893d4676261d508b4c0010652616208a4c7"
