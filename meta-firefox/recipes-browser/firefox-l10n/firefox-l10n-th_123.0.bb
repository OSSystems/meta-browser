# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e6cb571dd4a08347ed4d32822a99aacf"
SRC_URI[sha256sum] = "5892983c5fdc5a26388b7c3896706f4e710c6422b6a6ed4ca50c9545e9ef463e"
