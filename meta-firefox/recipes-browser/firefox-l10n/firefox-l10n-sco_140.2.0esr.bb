# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "16e42d08054d3c0ed328d2e0e95963e5"
SRC_URI[sha256sum] = "0fc6408ddf249a3507754cb1cf2b30c9cfe141674a9ff08d07d05c46e867ad3d"
