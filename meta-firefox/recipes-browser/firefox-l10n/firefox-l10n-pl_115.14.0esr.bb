# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fc62f192b2fb2cc5005cbe468068f1b7"
SRC_URI[sha256sum] = "75d58430ea0b2ba980be5b623d2128ee8ec495cc0c2f22d68aa99741f34075f3"
