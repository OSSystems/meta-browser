# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "699883a17c5b93073ad6defd5c6976a6"
SRC_URI[sha256sum] = "60fed51397e8222b328a3eed4326086262977c8c31e9b42d8e243df58ecf671e"
