# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "02d26a01bd521cee839c82aa7ac46e35"
SRC_URI[sha256sum] = "8b2a87716ecaf7ec6c1c1d8be44cafc005cd21f3a6c166d2ee13f7efad4c83be"
