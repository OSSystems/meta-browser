# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "f3bffe03a5a7c818e4f20464c136cba3b46d50afe9f811ec010af03bb80fe613"
