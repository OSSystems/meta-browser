# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b7daaa8eb8a7efab793ba0b916432dff"
SRC_URI[sha256sum] = "657de800918695f46704e8146c3b6b8345b11afeb1755800543026d6a77719a1"
