# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "83e4ee515eac48c4c6b9cf986e965e2e"
SRC_URI[sha256sum] = "7209682fa7483479fd9b2abe4b5e62f7ba0f28f9498ae96d429512d160ac80d3"
