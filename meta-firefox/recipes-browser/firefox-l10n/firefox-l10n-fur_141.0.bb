# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b8ec75d5a266e354bffc585b8b21360e"
SRC_URI[sha256sum] = "4192a58e5c43ec9fce7ddefdade81047cca9321d9f3044a32e53865ff04a99c5"
