# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cb68d6cd6419c12c265310f43f6e82a2"
SRC_URI[sha256sum] = "38c519cde4e091bd25b76e5e2cd120dc7eb65e2fba860513d302c79c41ddaa47"
