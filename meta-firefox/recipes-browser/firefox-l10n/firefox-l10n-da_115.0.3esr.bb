# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0903e1a51f6dc515614081ceadecef35"
SRC_URI[sha256sum] = "66ffe7f9d3b4a920c66b4dc696804099da2d9ba102cfc60f7bc7de4c04516c57"
