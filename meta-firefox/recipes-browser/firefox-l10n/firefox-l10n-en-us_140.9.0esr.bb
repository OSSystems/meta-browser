# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6c245ac9ad8753867b1aab5523e8a67c"
SRC_URI[sha256sum] = "4200c0f9ba715bffc3e2a1022d9e35784a71e62d515f19de2d150addaf61ef02"
