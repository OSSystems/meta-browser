# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "47730e720837f207d53e454f16d2994d"
SRC_URI[sha256sum] = "3eaf7ae83fb12a5bdd18b7286be3eac64dd39be870ad56c090401ae22818eb18"
