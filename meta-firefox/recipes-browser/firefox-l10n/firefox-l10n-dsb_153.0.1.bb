# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "dd8dd30a2493edf37b1ec9609b928398d4a82fc3033d4f54311f21c591611440"
