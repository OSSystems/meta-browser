# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5d459a63c5fcb150b629ba0a39f65184"
SRC_URI[sha256sum] = "135298ac6ed93670e14823b9856419c13b35053a0e7e038007a9bcef97c9a9a9"
