# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b0e2a433400868293c300eac0105c528"
SRC_URI[sha256sum] = "2de987274792513962974a2446a729fe94d6f15998849d420d5afb60cf63bc73"
