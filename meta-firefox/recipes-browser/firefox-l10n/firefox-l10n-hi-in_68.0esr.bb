# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ef33244acf3a26586f4b0ef4b030415f"
SRC_URI[sha256sum] = "cc00551850d737180c5b729b839a43ffda216fc5451e58f7013b96b77ded799b"
