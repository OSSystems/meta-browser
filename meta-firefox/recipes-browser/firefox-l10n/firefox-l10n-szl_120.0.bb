# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7fe3c5e5b2f9f70e0bb0fa69e0d0a5be"
SRC_URI[sha256sum] = "f454586122bcdc9319df62fb29baa573267665cc509b3dd0460b8fbcb5aa637e"
