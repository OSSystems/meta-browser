# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8b209550175136996fff603b0359a329"
SRC_URI[sha256sum] = "63430179b39987da288c7f0fbf4fcc193bc02f0adaba32b334a12a3b2a38a371"
