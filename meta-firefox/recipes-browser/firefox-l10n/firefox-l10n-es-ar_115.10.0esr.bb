# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6c41047676aa138cc350da7600316fff"
SRC_URI[sha256sum] = "8aadcc4c00be7aa080303fd456dc9ba35479d5e8701da49638c4a63bb9246737"
