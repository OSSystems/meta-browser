# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "018d8cdccf49655feb83765aeaece28c"
SRC_URI[sha256sum] = "0c16f9ac13524fa5382f9d2278b366cecffb10a514de401718a4bb89261dbf12"
