# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "27715942a5d386acf3a45233df03caee"
SRC_URI[sha256sum] = "3d95ace598217a6ace3d60cd4ed622efc02a298145b112f92159813629d86e30"
