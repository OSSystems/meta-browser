# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c2433f9d75d71f8f33b63eb78f20848e"
SRC_URI[sha256sum] = "d7a989c42880ec0bb54a16d6ab9e1f08df320c0b92129047b179e263cb4fbddc"
