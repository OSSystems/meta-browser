# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "63880e6abd46489363547033be93fff58549b3dd627f25aa6b598012a8a68a4f"
