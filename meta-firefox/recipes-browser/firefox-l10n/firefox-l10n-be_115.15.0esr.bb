# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ac7822b820ee3ff80360bd3f7f835cab"
SRC_URI[sha256sum] = "408a04d45cf6be265fb4f8bd1661dede1d31fc2cbf3cc5c9ff52cf3664d4b03e"
