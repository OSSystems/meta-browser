# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "31440039e4975cc7841d6d3c587d6379"
SRC_URI[sha256sum] = "7fbcfb544e08ccf72af689be33d6503d9674b50c6534b0b2dfc24edfbfcc2ab0"
