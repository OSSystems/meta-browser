# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "57b8d3a600d65c48ce628816b3ffce9b"
SRC_URI[sha256sum] = "4d6f1cfa910ba1c606da8f2aa230c579133ee2e83243e67c09d0179d6ce4c4dc"
