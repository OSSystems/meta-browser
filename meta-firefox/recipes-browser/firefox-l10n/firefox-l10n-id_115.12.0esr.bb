# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e4aa5427ac6d0a956d99a823e881680d"
SRC_URI[sha256sum] = "17a98e138ee96157f5e84bdcade76a8b99364fe671d0b047a40acc7b671fe70e"
