# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "a61057aa140b96bf2db5668695b46ad2622d98043da06572429a5b3033f61271"
