# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "093cb1e0166ccd4ba13bb0f9191643ce"
SRC_URI[sha256sum] = "a52a072227fbaa0cf9f6908681f93221957a61303bb292981d7c22b1a0c17f44"
