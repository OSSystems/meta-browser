# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "55ac64bf783c065dc164a4f62879008c"
SRC_URI[sha256sum] = "a32376af12b61e335a6e541f1eb97d81424bc726cceaa051778502baca5969b5"
