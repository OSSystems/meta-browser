# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6655736e4b6c1d4b4f4329d3c4b19cc6"
SRC_URI[sha256sum] = "77f388383c2ade6c3b8617533c91adc9b8fd3ee43fc0ce550cc2eb477625e091"
