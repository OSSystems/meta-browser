# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "97a2ec8c35a4960387e5153510a5a83c"
SRC_URI[sha256sum] = "82d0b356e19bf35fff7fcace405755dad129a0b11cc8223e515767c6f7c50801"
