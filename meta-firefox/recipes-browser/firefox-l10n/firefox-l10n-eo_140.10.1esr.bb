# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "44cdbdcb4d0a248ec353b4c2b151b5c738839583bf10e3aa4366f7e06857cf54"
