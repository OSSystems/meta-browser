# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0b4b2a63cf7125c08548810c81024334"
SRC_URI[sha256sum] = "d16b939e20a03d8a92e3b014561d5b501385b06e17f337ae4cc3f38198931094"
