# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dd45b70eeeeee0f6ddaf03ac7fddaf64"
SRC_URI[sha256sum] = "bac0dba3dec18988e065d0c6a126032b80e6b0841b47293be4e85edda5b51c9f"
