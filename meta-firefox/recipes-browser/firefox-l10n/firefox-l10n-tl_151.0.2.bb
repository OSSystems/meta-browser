# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ce3d674351ce69dca5b9ceadeb5994225bb83cfc82b6c162859f83a028dc3eae"
