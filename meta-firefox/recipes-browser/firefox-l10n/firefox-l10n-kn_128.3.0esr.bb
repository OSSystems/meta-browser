# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f2034b2929216210d770a59b2c16f522"
SRC_URI[sha256sum] = "58dc9190310e0ab811a6d8e1a52ee053fc11db839fea39bda2ac4938c88b317b"
