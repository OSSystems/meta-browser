# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d22f66591fa381a9d2c505dd3eee93d8"
SRC_URI[sha256sum] = "62ee14cc8c108f8464be94a9a8db451a85b37ab3968312ffb1ae97d6c11eba0c"
