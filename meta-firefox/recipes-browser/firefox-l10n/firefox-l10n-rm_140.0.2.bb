# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5de6942cef55d7e670f221b452036714"
SRC_URI[sha256sum] = "ebe46ab42a4254172313fb965da087c3717a8666485cfc60fdea251c07673273"
