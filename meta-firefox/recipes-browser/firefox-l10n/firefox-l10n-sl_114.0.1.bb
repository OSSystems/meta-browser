# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8e8663aac93d16f01d016f5cbd00565a"
SRC_URI[sha256sum] = "172c682ae5a19f9bf519a963ed8ab0178b3c2a2c6872134914a0bad47abaa95c"
