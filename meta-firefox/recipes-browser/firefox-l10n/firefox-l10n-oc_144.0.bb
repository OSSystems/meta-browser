# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a4b495dc65761c83bb2d71e5a6c7faec"
SRC_URI[sha256sum] = "de4a16f07935f3a33d133f8c38079ad394946dfcccf8cb1eb352e080b376145d"
