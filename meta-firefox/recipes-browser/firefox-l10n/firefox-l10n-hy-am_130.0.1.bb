# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6a9e511a66f83639b6dc069531a53a50"
SRC_URI[sha256sum] = "3b0bbe1b7d715ed22f87014b24e72c62d0834bc190990193916bd09f74f3378a"
