# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a0c6e64860f4c77bc81478305471d40f"
SRC_URI[sha256sum] = "fd7bf7ca258f33f11d835202ca0713c60744a757483deaa028ebd380cb1cafdd"
