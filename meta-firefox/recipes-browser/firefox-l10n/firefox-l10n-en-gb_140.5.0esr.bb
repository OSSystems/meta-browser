# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "040c6945a30b64169922e54f97292d4a"
SRC_URI[sha256sum] = "b185a5196026fae9bf8d3d33212c2927d9747cafcb850ff64bdad2dd183c6c01"
