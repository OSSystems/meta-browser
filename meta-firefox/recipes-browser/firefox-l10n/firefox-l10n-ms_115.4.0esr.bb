# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0f2b99e39b1bce3359ec099a8adc3b1d"
SRC_URI[sha256sum] = "d138b66c363026bdc71a33a665137c7e49e3c0a3bfde8c953ba2ea48309e3325"
