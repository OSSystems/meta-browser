# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b579f93c6d25cbc84df70d08b504d15b"
SRC_URI[sha256sum] = "7781b5ebbcf887cffd6b9767804e58d7fcdb1623898470502a414fdf74810c20"
