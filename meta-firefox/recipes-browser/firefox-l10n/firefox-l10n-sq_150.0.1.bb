# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "8998af628ca222437197a487359eb6834ed5127a4adcedc2564b5595bb0c3cf0"
