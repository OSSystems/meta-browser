# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f9445fb7306682c6d4e2ce82fd237d2e"
SRC_URI[sha256sum] = "da784cc8e72634877caa644d2d331afcf548ac21335820088125a76ca34d3b2b"
