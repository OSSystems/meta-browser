# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "685d5e85ff75d23862ba35ae3911a3a7"
SRC_URI[sha256sum] = "7f3299649643dffb76cc9f63cdbe2dd63695d2086941645aa66eb455b52dd966"
