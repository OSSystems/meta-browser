# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "469f0a88fb40543c79d93c46bcdef710"
SRC_URI[sha256sum] = "a92e1aa17dee5e2d9bfdd0daa10a999e324716f2bc6dfaa0ca70e86d1b620542"
