# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7c87d43b9656501a5c58b3d6dd23e66b"
SRC_URI[sha256sum] = "1572919a34905bb676744ff2ffda15c6df2b44b3ef27338c3f71ccafe4d5f913"
