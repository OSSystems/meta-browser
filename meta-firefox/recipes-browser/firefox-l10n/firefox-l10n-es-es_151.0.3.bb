# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ee9b796010b6586223141c1e0e23ed09f539b86f250f4c6721aaf9aae61d31ac"
