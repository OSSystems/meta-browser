# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "409d0d6bab719610b524fbd869b9067a"
SRC_URI[sha256sum] = "8f6e216bdb9ed7b3c7a1b5dd161f2f84e95526a180b776736423f854a1fa8606"
