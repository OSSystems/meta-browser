# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e8dd11b14edfe7be342b66150a0a5235"
SRC_URI[sha256sum] = "96bf061eeef3fd14bf0abbe3e597a75917cc51d9f2a976bd33a6367bdec55c07"
