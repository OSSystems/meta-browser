# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eedf5e589a9c466146ac016ce7dbe0b7"
SRC_URI[sha256sum] = "c68fc4b1220908c1e7687f9bc30f2e673ed1e84c3776812349e0fcee7c8afd29"
