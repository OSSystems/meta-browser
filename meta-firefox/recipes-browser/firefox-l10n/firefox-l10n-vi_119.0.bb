# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "830a5ec803ade8d80e86f067d0c18e4e"
SRC_URI[sha256sum] = "411358a2cdec1817bf8f573e4e1491a1a8d75ad475a42590ef64a3faf83c0fb8"
