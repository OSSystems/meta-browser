# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "827e4fd88a1ef0b9cef41aae277b424c53edd12e2f167b6f286dd51910666641"
