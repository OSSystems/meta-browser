# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4c313bfda644f79831bec2a0a71b7709"
SRC_URI[sha256sum] = "9c5a66c1208640b3296eaa5719cf0aa3644a50c3185103ac27a5059f3428744b"
