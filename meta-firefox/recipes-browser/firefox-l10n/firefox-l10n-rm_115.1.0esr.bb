# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "17dac94dfa4ce3f0df391b3acc55ff0c"
SRC_URI[sha256sum] = "5edf1e30f64daf2b982a0cf1999a30b2a98b1578565d25822c51255010cbe4ca"
