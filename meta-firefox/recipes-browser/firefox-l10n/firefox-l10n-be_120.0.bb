# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5ad66da5ce592755db367c2f1f8cdbec"
SRC_URI[sha256sum] = "be381219224bbbf97966605741a7f97dd8b8ac5d1ba7d5aabaefb1081b3a1c58"
