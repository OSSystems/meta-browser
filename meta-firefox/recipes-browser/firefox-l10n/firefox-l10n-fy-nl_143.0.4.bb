# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "94ae57e56aa321b3a4e417481396d765"
SRC_URI[sha256sum] = "181c1d4bd7b28e7b204e40fe013ddbbe516c4771bd05a4b7de0437494d140e64"
