# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b0d926c143b3898e698efe69fe8d46e3"
SRC_URI[sha256sum] = "28f03c414f7c31bfab7297ac1b804b1caa068732598a9f58bf3bc1c5756cc3c5"
