# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ce4cc9b5a95ef7deac3939ebde1b7402ae33f3fee0724ce1873887cbab0a9675"
