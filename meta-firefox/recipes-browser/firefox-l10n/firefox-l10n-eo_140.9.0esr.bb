# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f9cf8003a0dd924d97afda34f884c4ab"
SRC_URI[sha256sum] = "191e495bb401d2cce3e3e358b2e57534b22d3bfab5d0fd52ef0540e208842115"
