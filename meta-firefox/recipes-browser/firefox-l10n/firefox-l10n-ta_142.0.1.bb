# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "248e5c4b067796642d3deed03ed114b4"
SRC_URI[sha256sum] = "b6236f5cbc84ae98edb4a228976561951c1b39b6465f62a373bbd6a742327225"
