# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e73879b68d4c31104ebb700bea211e8b"
SRC_URI[sha256sum] = "a6cac0d96384dfdc89e9f3d99bbc4501daf9314a86bd9ba67a0e1d2d5d5ef3ab"
