# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "21b100a93806587d7d34b82354be01a7"
SRC_URI[sha256sum] = "83c360e47e5c61d8270b392405435a62b77149d8f86b8e92f900979bcfc88de4"
