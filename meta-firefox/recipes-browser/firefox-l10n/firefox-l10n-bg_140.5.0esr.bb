# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c1e4d292c9739dde59b8a3238e450d5b"
SRC_URI[sha256sum] = "ee6336d76d66a1afe041795912697dd9b1a92a13bd3d4c813d036ed03e24adec"
