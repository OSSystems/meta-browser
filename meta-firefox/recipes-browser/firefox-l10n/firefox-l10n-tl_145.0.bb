# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1f62003f2bad433e1cc5ffbd5edc459b"
SRC_URI[sha256sum] = "4e5673d772f8ee6d73ce6e2ed548dd43486157f6d5e9a3424899c139a23cd67b"
