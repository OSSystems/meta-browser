# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c727e2e461ca0d644bcc1bed0d5cdcb9ff36a40cef5836d4d38acfbb7e70bfd3"
