# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2e617bc7c48a348c80d0873f334b3328"
SRC_URI[sha256sum] = "0efb11217eb9bf1cd6ce98130a08ada0351123a51f9528e4a8444b73c5bad3a9"
