# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c92eb4b586ad62b60103946ca9350fb7"
SRC_URI[sha256sum] = "8821035a71f2f3f2025d90b870874af7c0f88cea8f88643f5e58ac92e62aeafb"
