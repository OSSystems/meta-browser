# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1fd7f53f9dde5894bc781025934d62bb"
SRC_URI[sha256sum] = "626af05dcfbb483f80e2d9855cb56c618641d646a9dd8fdce2977acb5244bc09"
