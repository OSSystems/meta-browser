# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2cf68fe766b69800af38fa61dce16537"
SRC_URI[sha256sum] = "e5cff8447b25a97163070d9c1a6a589e67ede52249c9dc26aae3757ef9553795"
