# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5e133d475f2b3d5f669114dc3ef38c02"
SRC_URI[sha256sum] = "517659ae00f9d696469892bd840955eb95751adad6a00bc6b4dd9e0ab9773671"
