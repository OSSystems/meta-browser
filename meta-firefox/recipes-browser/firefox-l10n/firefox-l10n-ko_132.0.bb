# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "72341e4c13f76f55d0386da728f0688d"
SRC_URI[sha256sum] = "7cffb14f70c12da80e348ffc76ec191d4b2e67854b24f5742a8ab1f827171a85"
