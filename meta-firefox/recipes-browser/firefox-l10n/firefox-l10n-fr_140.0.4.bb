# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "66f326595604471a4b8c6c1a1130383c"
SRC_URI[sha256sum] = "5b0cf5c875418330c828a51e75b300670daf6c514550d8597a3e8de6ff479300"
