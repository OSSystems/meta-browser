# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "001a9b9d106f3512ca5ce0e8033bafa9"
SRC_URI[sha256sum] = "6581724fe94ed3f1e2b4a2bdf3cf0dc931e905639884b8200a4118e753bddecd"
