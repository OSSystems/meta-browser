# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "07bf974e53c38deb2c868fe573587348"
SRC_URI[sha256sum] = "9beda22e7f4c02f4006f97f44e3954d4c024725e1783ce35efa0866456bb2c59"
