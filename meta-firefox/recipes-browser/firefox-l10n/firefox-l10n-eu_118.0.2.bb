# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d70b4cd87498b9f3d453f01fa137c132"
SRC_URI[sha256sum] = "5209d095a429b331c27bcfa93d49c14e448f43778931ca1a2d959164c8ff9e61"
