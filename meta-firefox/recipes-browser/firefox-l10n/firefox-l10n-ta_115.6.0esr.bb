# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cb681c6ce23bbad38016c1c205d591f6"
SRC_URI[sha256sum] = "c7673b8dfc18b204d3d09917b2869351984e6b0cf8c86ca9c9971f009034b190"
