# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "535b5d441bfa6f937dfceffceb1404f4"
SRC_URI[sha256sum] = "01e0a3c7836b4a8ecde33155ea46b307fe0f388347391ce679d72d8be1e68b4d"
