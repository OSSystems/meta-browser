# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b1f56ce66dbf3805d003dd99ecdf6258"
SRC_URI[sha256sum] = "a51bcc98e16b6246f472e6dab69cdd179bdc2ea96a1f7e61fcbaa423fed8a75f"
