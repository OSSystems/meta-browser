# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "f090ca880176ca6424b16ce5e4340e0aa6b8113724ee5e0d1b22edb826f1be37"
