# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "a1c6b0cdcae5b76eefffa59893ae4a77f3eab1b17e2c5cf6d528b8ccb10dd4a1"
