# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0be0cd45922d4e82c4bf11f64c792146"
SRC_URI[sha256sum] = "17537e1cd0f9270ae54c6d3b9e63a464cb9ccaa8eecaf07bd3ed481b3fa2a2dd"
