# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9d8c28347f89e6160f3cb9e34f45a7de"
SRC_URI[sha256sum] = "55b6ea60bafda73e85fd1153f830f339cf0769abcca6d57378cbd3df6900ba99"
