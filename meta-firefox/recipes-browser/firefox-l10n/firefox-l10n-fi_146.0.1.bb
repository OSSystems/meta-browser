# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "44da97006a95b9b20177e8c3ab682208"
SRC_URI[sha256sum] = "7c283cd01968e527bb6e559237a5fa7080c8a9e8befa5be3c3acc4eb872131a0"
