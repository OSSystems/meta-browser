# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ff207e81325f00c692160e590e3e1501"
SRC_URI[sha256sum] = "cbd7c60ada3c058135455aea346d5629b1df9827d640045cd76f40c58cf1d7bd"
