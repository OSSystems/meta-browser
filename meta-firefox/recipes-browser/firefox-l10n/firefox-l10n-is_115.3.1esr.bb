# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "67439511087eacd0d77ef8f8838d5cab"
SRC_URI[sha256sum] = "5be237010c22d145c14c875ae7b2a423230bef56495f985e81a7452740985d6c"
