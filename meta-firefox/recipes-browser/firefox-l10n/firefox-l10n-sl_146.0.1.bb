# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "07d5d42dcd61c3025a4668aa27031c01"
SRC_URI[sha256sum] = "662afb65dce8f04a542b368f3095fed19fa3eab167cd968767aa7ea8249af61b"
