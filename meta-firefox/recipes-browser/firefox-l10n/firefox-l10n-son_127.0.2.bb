# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "00169fb415158e20f505d918c52220a2"
SRC_URI[sha256sum] = "38553c34a1b0deb74a766b76aca4fd4e0b90be00149a5e8542e08ef6038fcae3"
