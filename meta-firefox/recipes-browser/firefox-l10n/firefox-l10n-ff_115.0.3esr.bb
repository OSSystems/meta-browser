# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "82710fc73a2f19b37765797b4b1470d6"
SRC_URI[sha256sum] = "1a74aff53587412248a3a01f361ed28583bc76099654c10d3ae12df943999e61"
