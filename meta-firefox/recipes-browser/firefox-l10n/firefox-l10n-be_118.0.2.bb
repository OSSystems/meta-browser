# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "13ac7ce11e5f77a6fbaa45d2284ecd5d"
SRC_URI[sha256sum] = "a889145cfe14bec524358c69b8e2ed83ab4c53938ebb7b05e4b548456b93373f"
