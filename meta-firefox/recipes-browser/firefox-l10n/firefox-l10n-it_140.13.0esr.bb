# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7574f5c863d03d8fc0d7ba41b87ef3c334403b11c405c8213c951c8eed3b7267"
