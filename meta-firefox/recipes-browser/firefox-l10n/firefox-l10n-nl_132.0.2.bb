# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6d556b8a2fa612d8c61f27387160dfd8"
SRC_URI[sha256sum] = "a4ab77e8b6a8038fa0e64955b79f6e15ae8228e205e84d38efa23b67e844047f"
