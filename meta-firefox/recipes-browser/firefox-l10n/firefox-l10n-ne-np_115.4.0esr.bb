# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "653fc3c9ee26b4bda52385c3145d8ee7"
SRC_URI[sha256sum] = "6a40bf1519a54494a6a1c36079b7407c22a2657d27187070a78253b0db775ff9"
