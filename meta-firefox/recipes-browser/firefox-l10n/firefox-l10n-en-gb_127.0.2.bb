# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cc47089b469735f314d0ac8118cee885"
SRC_URI[sha256sum] = "5fa802d91b1e3970e0247a99638b6f7f026903dec4482626ed242d3d9022382d"
