# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "38c329eed2eec2b1a39aa91605ff76a4"
SRC_URI[sha256sum] = "db294d1de11b950252ace1943eeed22c4152f9c98b94fe49b3996d13427d153d"
