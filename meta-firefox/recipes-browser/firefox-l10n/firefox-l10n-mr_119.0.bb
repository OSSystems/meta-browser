# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4b61eccbe7a9772d1a80a4a3a10f0cec"
SRC_URI[sha256sum] = "1b4e32e1b152ce936ee6bf9e1bf3ce30b99c6ba58a7a7d131a64eb1aeb55d814"
