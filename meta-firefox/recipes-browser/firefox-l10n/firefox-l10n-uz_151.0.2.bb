# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "522ee2a97e45a36fde3720a55e3fe951859a41d1cda47fc8a4a4a8f150a49f4b"
