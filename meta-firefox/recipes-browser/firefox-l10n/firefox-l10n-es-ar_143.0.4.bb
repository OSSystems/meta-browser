# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a1039421132fbd4ccdd18a21b32f700d"
SRC_URI[sha256sum] = "97889951168119058d084dee750583c59e7e0e5d40e4f83ce1054b67ae4c90f3"
