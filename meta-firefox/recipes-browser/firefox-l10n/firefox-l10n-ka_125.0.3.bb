# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8a33117abc8d03ad0fffa351f86f597e"
SRC_URI[sha256sum] = "8e6bbf9873b9bcbd63dfd850b979ca6b2836fa83b1f80bda1122bb43d7394ca9"
