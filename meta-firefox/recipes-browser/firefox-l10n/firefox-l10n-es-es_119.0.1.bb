# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b89d4829ad5d159551a5c6f518f653b5"
SRC_URI[sha256sum] = "442baf2ad932b88bb252d4a9781481ecd8e25e9926340adfd73df3d463077154"
