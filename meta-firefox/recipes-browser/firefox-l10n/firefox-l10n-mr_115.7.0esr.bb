# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a43862d2e46213fe5fe8e105ba0fa080"
SRC_URI[sha256sum] = "e85d2ac2e51b43ed8bfb2257ace217303e7ed2b192344cff9787e2c90ab31090"
