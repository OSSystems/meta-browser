# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4ae28e873794660a5177a2a4cf61108f"
SRC_URI[sha256sum] = "5c5fdbee48e43149101a444d1a6f562b5e577471e6e21c97c871703e80e34b5b"
