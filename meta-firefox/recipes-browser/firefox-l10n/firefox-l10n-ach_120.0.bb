# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "37f813d2c0b72deb42787d4b16027dbf"
SRC_URI[sha256sum] = "9cc5ef614027132353b96ddee5ce06803018103d3c44cdd3bca3684a66a052b4"
