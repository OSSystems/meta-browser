# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "55f5147b1845f8cf03721c4b8a7a851b"
SRC_URI[sha256sum] = "bd358c6e45b590b060c8f0a02f56609ae98031f3455c8f6bb07cac000ca0f37f"
