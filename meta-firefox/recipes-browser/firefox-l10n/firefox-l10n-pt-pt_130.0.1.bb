# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fb025c499419e54a08961ae81263d70e"
SRC_URI[sha256sum] = "efd08b88209c033340c07d5e881a5ecdb34c74d4d4d431eec0f0922ccb62f973"
