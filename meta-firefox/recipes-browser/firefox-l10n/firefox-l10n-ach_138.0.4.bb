# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b53f63c5ae3f93332ef9bc8758748849"
SRC_URI[sha256sum] = "bea2a75b95a5ea7ed4c2fe3df7cb027003bfa13d25ee88db0b06552910df60bb"
