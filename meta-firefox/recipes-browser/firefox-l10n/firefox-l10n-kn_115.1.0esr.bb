# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a2b1d43073a454ea131c257fafc1dee2"
SRC_URI[sha256sum] = "79905e60d322c9468739da7f659c5180c9c42ba4bec78b4330589a8b94ff140b"
