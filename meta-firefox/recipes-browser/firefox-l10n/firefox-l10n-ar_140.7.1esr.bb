# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ebddedf59b8f8f8000c3648eaccd6b1"
SRC_URI[sha256sum] = "9780f5bfb7187a9e6020418bb46fa0e27ee99db995d4b55b54bf803ed32f1729"
