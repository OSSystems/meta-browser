# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b9317e0b238429554967ef6d64b51157"
SRC_URI[sha256sum] = "7c1c787bf4c450659a3043d61628aef0b9186f453a2011fed8ce55cedd02837b"
