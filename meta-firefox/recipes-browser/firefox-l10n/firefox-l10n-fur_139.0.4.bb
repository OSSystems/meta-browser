# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8cfa27dbbbe9341038eee14fc9b762cb"
SRC_URI[sha256sum] = "d803ea7b0dfe7a7f5a90c591930ef2eef221662ac3b1e916b4e1182a7bea87bb"
