# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "fad827a44e2c8a6c6b52d1c18f59f84cced1f1909cee0dcf17407efdaca075fc"
