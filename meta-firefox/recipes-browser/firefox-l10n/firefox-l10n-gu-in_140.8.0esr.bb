# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "143c252d538c06ce6879f544fa914f6d"
SRC_URI[sha256sum] = "5747d4bec767005deb45d56bd7b3f52cb4afbaddabd3c090b0d3eaffa28fb72a"
