# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fd721b24b44a82279a1134e5e6a021d2"
SRC_URI[sha256sum] = "f028cbcbf52deed2704c19115d5cd6f8e0690ebb191dfe2e37a78726377c0fd5"
