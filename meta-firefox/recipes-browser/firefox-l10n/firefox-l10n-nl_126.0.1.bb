# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4031e44382d77623b6bf9029bdf2aa56"
SRC_URI[sha256sum] = "27f1434f3c9b542c25009a490ba57fd43bff211bf9048e5df2965221f0ec36aa"
