# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "56b9e4ba65fdbb6dde5a93d57f69fd5f"
SRC_URI[sha256sum] = "891ad29c6f82953eee92f72a47131d3eee658c7efdaaf4c91804797688effc78"
