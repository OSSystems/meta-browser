# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "434bf779791c8f3548119683ca921d9c"
SRC_URI[sha256sum] = "60f2a5c628f3e833bcf7c1b347d67dc27f74f2fbbe86dff1a1054225b2af3113"
