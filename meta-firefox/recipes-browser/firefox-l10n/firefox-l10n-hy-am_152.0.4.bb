# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "66618ae40972180e70b3e05d71f05551253332a0ad4a353f9d7e30ffba8d3ae5"
