# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fef08b60abc8648327aba5d551845bb1"
SRC_URI[sha256sum] = "88a56e57a856ded4566bee5d0e92707df573e754fedd72e35d054ffd5f9bb6a4"
