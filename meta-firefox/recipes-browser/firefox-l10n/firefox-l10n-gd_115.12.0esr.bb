# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "452c7249e14163931141e667450d22c0"
SRC_URI[sha256sum] = "8ceeaf1a1dbf20a96e6f7a79d96febbc02428cec62816bdc17f6bd0a33ee934d"
