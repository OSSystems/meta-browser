# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "00a03fe1f9e7da4624ec038bdc0cb6e98c3d579dec5ccf18a7d383527ba634f5"
