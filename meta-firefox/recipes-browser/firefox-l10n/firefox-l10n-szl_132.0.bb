# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e43f8896f886c6549b1737acd182f162"
SRC_URI[sha256sum] = "25c90afdd82e147ac57cbeacac5940cb19536506382ee08f72d884a438afd34e"
