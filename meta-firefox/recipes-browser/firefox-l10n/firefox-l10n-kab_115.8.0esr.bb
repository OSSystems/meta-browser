# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c01ee2a5370cc579a897321f9148787e"
SRC_URI[sha256sum] = "c796d894a8118adc4602dbaa57727500980397ca697c722bc571435aa2755999"
