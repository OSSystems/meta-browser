# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aa587751673d3496b1751dc4377069a3"
SRC_URI[sha256sum] = "667d91917d1a0f6a98787f6d3685e1c9802e3bfd14d50f33944919e82f7c03b1"
