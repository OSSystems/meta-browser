# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c9f19e21581e058060833346e4ae361f"
SRC_URI[sha256sum] = "bd80c39d13a77390957bfad51991ea9d8e9a8f4266f816e4575a4f51a4ea5198"
