# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "99cd81e240559218bd0469746c44d70da9450be6b1cf41bd3360bf803bb084cb"
