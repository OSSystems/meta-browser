# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "15c26f9f59231bb9f4bff7a5d0826a218f0b0cd7f6cf97c9700f2cdf0018191f"
