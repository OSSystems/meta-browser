# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1e6891d72c23d11f04c8e61005f092d6"
SRC_URI[sha256sum] = "e124dced20dedc224cb705f1cfeb2830fec33427f35f497bb5187e165c9fc93a"
