# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7ba4979f570a98c50d8ed20b47590d9d"
SRC_URI[sha256sum] = "bf31b04e3b5de1bcb2a7b6a7cf58a6949d4f86c3acbd3b6ff19d6ad83da5f023"
