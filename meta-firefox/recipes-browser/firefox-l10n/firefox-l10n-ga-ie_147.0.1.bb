# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aff225c0a33c68a516d5657aa29faa06"
SRC_URI[sha256sum] = "bcd47726165dd70188ca203b7d8c3c87f7bd74a9180b1d6f72dea358befbd483"
