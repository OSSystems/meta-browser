# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2c4d9fcb53a65c2ddcb8ffeb0056f717"
SRC_URI[sha256sum] = "216b30bdaac980f04d0d17dcadf92f219e141fc897b024756e8d0f736a4c0e91"
