# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "acf38f3d3c5da988d5ce97104e213fd3"
SRC_URI[sha256sum] = "c3d43a4d082146dbbdb418320813c1562edbc3269183ceeca23a01903e04f83f"
