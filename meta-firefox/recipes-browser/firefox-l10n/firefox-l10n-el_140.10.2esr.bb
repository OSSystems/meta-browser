# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "84c20f020b8fa0e99d22139043af790c3ebee00501bfab835fddd44903c432cd"
