# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3baa604128a173861c58e404962b3c24"
SRC_URI[sha256sum] = "775b9645e9cd41f4f04f5854d5913917679edffc90aae586f23ca7b4e0d3120e"
