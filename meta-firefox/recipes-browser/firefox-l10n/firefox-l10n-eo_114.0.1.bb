# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3adda65f4eda4e9677a138f2edeaf429"
SRC_URI[sha256sum] = "211c4320d2fccf060f377dd0fe027f36609934f17e815b91aa9ee8737de801c7"
