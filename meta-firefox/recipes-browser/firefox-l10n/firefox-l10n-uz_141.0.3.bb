# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "599f5af62cb68a56d160a40047572e26"
SRC_URI[sha256sum] = "7d3e8d53d40a2c25acfedbac302402a5d26cc57410a67be9ee6fd85b318ade01"
