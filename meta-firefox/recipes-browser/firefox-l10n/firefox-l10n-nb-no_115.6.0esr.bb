# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bc1cfefab79c026588dd3a91b1e68222"
SRC_URI[sha256sum] = "b17d02012680a1abc1ecd612ce5a85eb1d812b22bea9a8297775d00ee974064e"
