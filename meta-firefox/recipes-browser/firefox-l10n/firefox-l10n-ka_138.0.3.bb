# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "670a1c1b995588422beb14a6aadb4463"
SRC_URI[sha256sum] = "0963f161115e72b7c18391165c98bd1f88940b43730a125cc9410a1e584d0e52"
