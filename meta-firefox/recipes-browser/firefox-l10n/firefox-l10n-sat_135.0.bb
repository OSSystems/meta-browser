# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a8de14d0979decef3aadae7fbc1d1a84"
SRC_URI[sha256sum] = "4c822fefc055c93203fde542f500e02987714c86269d101a9d5845a06e3229f2"
