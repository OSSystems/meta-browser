# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "48e97822cc13ae2af91776d02f5c534c66bbe408be5fe05f9a12752c9d68ba97"
