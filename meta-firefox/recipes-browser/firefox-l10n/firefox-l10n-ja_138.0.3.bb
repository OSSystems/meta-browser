# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9beb31ff5bbd7658c3bcbfa4750c07de"
SRC_URI[sha256sum] = "6f689638abfba772279b61ba2d9a0708524e708facdf495729c547dc57208284"
