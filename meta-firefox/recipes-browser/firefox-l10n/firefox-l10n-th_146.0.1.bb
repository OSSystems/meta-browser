# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bde403a8564e1a907da8d59edc25eea0"
SRC_URI[sha256sum] = "003928d51420add984d9e14bd7a2f5b0d0b8cfefabf22a0d44fd4f64aa2ca6aa"
