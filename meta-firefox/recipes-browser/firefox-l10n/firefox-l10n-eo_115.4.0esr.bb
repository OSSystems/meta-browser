# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "80a8b49f586cae5787812cf1c67e037d"
SRC_URI[sha256sum] = "b3c5370c500bde2bd1a9f8af0f5ce02d0f54700abc5ee0a92475f2bd08bc8c37"
