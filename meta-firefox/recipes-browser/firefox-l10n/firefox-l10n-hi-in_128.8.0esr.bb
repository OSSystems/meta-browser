# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8049418824558b869e500c4ce5e5981e"
SRC_URI[sha256sum] = "0ef7e49991b0dc4d815120fcac82f87494fa4d9243569a52a1830419122935db"
