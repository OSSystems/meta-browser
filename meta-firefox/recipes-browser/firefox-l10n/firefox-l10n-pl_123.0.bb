# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "42d82c69bb6900db5f9590009570be33"
SRC_URI[sha256sum] = "934ecf2cb14d3a06c8d27507a8190ace78161d48861629e94a6c82d3d306b916"
