# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6b64e4028da22c60fb1d0dcd4c39b770"
SRC_URI[sha256sum] = "678571fabb39251adc73ae86e6d03632adeebc55fbea5ec1b4ea2d1cb1685c1d"
