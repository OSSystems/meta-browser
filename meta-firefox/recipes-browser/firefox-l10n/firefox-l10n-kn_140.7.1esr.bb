# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6cbe74d8227d90f8987e3f8e448ad62c"
SRC_URI[sha256sum] = "063c19af4d0956a08cc491b16996298b5eb0cd0604ad8063a5115cd6f8035887"
