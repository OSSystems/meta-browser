# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e2c70cb9489c939838843480acd28476"
SRC_URI[sha256sum] = "e7b43df6f552f64b239fb0f0195d9d24ec129a4b2037a26ef0c8e3f85e176950"
