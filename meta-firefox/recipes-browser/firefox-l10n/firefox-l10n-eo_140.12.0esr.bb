# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "799d21d2227b74c367dbc5b600a5abbafc279d2d138107260454c0a2812422d4"
