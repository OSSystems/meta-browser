# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c09d57c37542b5194f42057119525678"
SRC_URI[sha256sum] = "547b87393162bf3b11935a3cc7f9a8ac050716bf560a6ec257dd0694a3bef203"
