# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5064c73a52e7ea2c0dd76a7498731a87"
SRC_URI[sha256sum] = "ff1cacc352645a5de3c70bc5ac8d6a23b9239fb0585e9edb10b4194bad6028e2"
