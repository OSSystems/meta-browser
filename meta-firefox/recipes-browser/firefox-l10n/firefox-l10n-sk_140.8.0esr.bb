# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "68d8e72b70e001a99722928c5bbc8318"
SRC_URI[sha256sum] = "196563db260677b3ea2f7dae8b9cb5448bb29f70ac1d33841ae9d116f5e5810f"
