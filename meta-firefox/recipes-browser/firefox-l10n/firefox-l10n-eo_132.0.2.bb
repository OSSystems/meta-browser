# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c469de4e76d0a0886e18c52b8e252089"
SRC_URI[sha256sum] = "21fe36b9a25f4c2144c254eed7eb8b28459ab173f01643bca1ed6ce4684619a7"
