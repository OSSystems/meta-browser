# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "27624857aa93527b387cb35f8440ba60"
SRC_URI[sha256sum] = "509d1cc4e099b36ffb20b80ed1db6ee18761db631429e594af5b83033bfbb917"
