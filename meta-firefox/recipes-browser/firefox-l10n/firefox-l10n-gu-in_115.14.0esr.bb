# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6e42c6bc3367cc00c73984276370e3e0"
SRC_URI[sha256sum] = "74b34d19900e2bb5a85232699e733baa03bec4e3e84e27ba7129c740a1ec53c7"
