# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c9e4d680168d3ee54c9f514796287201"
SRC_URI[sha256sum] = "dd7656a5598edc1ef858c6be7cdd9e87b391e33299d118f5804d5cd4b65ff391"
