# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bd28845942d9bb8067ed96be19d0cb53"
SRC_URI[sha256sum] = "98abc976a5958753a8154a632c849639e9a71d2c2e7c92603e4d2d111efe87d1"
