# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fce1602e77e99c4c386be1ecd50f9ec2"
SRC_URI[sha256sum] = "cb374596d48c8365d627f0a351d62177815af8d053fe08eb5830eb650b2d4458"
