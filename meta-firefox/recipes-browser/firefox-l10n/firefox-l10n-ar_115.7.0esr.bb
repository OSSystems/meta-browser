# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9c9c3da9c64a3671b7a657861ce0dfea"
SRC_URI[sha256sum] = "bda26a835ad60ab094344e5f7ab4d48a2b810b1f7adabc01212d84ec146e436a"
