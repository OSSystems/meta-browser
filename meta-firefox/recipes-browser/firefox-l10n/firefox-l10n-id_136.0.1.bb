# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "808134e1426f90241a31bc675afc38bf"
SRC_URI[sha256sum] = "dbc6db710446c2d7a951653c83ecd4c1dfb798f5501bb8cba30fbf395d31d22d"
