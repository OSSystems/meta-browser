# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5b5cc2a9f7998b959038d6c6a900e569"
SRC_URI[sha256sum] = "8696153e61a03ba028cded6943644c3626b0b92417bbb1b8e93d1e060f556037"
