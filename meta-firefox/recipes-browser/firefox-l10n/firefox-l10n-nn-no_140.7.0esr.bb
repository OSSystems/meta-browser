# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2c286a0537b826b16b0857cabf93a8bd"
SRC_URI[sha256sum] = "59bc0220953bc6905838644e34c680a6ac2ebb621df806388ed445a693873a55"
