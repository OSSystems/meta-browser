# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "181c221cd41ab53fe2f73049e783f9f2"
SRC_URI[sha256sum] = "eacfa37272b319dea05291eb60f67f30d5ca9106f41054d3c573d163b2ae52d6"
