# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "406cf47a11fda1556aa1283957026c82"
SRC_URI[sha256sum] = "32bc3622f0bdad905d5ca512e42e70e772d9267d971fb0c7cd5934d73f457f66"
