# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0e45a98ff0f7275304787104452f05d7"
SRC_URI[sha256sum] = "a66319579c5eaee3ab3ed943df1434bc68635ada3c2fb7d11179a7e594ca4a25"
