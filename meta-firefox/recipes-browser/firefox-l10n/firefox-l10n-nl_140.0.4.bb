# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d1931a339bd75d91281e05775f8e4bb4"
SRC_URI[sha256sum] = "0e1e89c0880836821a5b4a796236f76785df98bba51b9f8f9554d96ac593c04b"
