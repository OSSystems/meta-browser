# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3ed3bb1e8c758dfbe33ee334e86e7390"
SRC_URI[sha256sum] = "0beb63a999988531e789785243baa1cfbb003610e26187e06de37fa19c424a5b"
