# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4102ee60b0c50d96f04c1a55c687b929"
SRC_URI[sha256sum] = "392923081b85652d4bb1c12e82e50a8371af855c8bfdb329b1e3de3ef8fa8744"
