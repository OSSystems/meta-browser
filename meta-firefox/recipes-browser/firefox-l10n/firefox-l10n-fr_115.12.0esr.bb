# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b5545d9ed5e2692ed5a56a37f6fb9ced"
SRC_URI[sha256sum] = "a96407cf38782f8e1f0e6445cfc3b98c436ed28a7366ca0c3291b87e52f0230a"
