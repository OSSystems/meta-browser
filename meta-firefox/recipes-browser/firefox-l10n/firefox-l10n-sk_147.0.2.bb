# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bc5f9312c75947a7d7a69aeb25fe9be8"
SRC_URI[sha256sum] = "d651dae5db3dfd71930463fd67c893148e8f30ef51cc6656bfb0e0156159b425"
