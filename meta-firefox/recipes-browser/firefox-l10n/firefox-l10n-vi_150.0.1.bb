# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "991b22a1f41be046c0d2c3d4ff88c99eb525e933ea4758ada8f1e7eb87aef0a8"
