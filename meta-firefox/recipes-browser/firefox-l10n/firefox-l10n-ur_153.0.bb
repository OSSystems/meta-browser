# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d4162a4797b02e885a9099bb95699136ec6ae628af0a79c44a8f7fe295fa6c61"
