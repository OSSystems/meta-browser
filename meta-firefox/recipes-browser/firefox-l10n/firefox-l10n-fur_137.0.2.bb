# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8fd8d4cb50ac2a1e0b025f7ff0c5cfcb"
SRC_URI[sha256sum] = "600814544f2233fad947ad7649dfa33bac800c06de7488334961b23c772f5b1c"
