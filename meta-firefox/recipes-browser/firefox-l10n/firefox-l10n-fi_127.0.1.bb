# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "343c2445b4a96d3acc420863bfe2331d"
SRC_URI[sha256sum] = "99666eb29ecfb121f392fdc6fc112921910674c84d9fc28dab9b27c489302332"
