# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "578c2f83ab9e3381d75ba36445950702"
SRC_URI[sha256sum] = "1c389ca9b4ca6740ce89bc72ef60fda5d87543fd427e077da8bb04fefda40b7d"
