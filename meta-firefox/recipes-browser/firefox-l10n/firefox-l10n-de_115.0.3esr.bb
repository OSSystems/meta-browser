# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f3f6e3734e432cd81c86abd6bbbf3756"
SRC_URI[sha256sum] = "754ab1e7f15e141dcc500eb4351beafec0e61857d5491d6a47897bc23d246880"
