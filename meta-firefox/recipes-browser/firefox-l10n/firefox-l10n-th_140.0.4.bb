# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1fa6e1b40b5c88a25769af93e1840abe"
SRC_URI[sha256sum] = "e77b11cce27f82cb8ff9432a5ab46b75e3f8959a00b9d1379c00523b0669d574"
