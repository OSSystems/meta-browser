# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "f4ab57dd1d8332aa6aae52a5614f68dc6acca11d918a5efc31f4b47a1b8945d9"
