# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "552b15d1ed3e97e25a4ba9aa1234e86d"
SRC_URI[sha256sum] = "46815495027552176dd147c79b058e43bd46618609a60d41e0f56b37690c9f98"
