# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "32c413c1e8a9f3a0c66175c679800ecb"
SRC_URI[sha256sum] = "e29103aa5da6eaedde8ecabbb84d5675fbf5c0b9de4a2fb1a6ec71ff69cd9298"
