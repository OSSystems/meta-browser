# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3adb1f1acd71d5af603a0f1fbf8f2510"
SRC_URI[sha256sum] = "b8c49f6e8f1ebeeafd900b9e6e13cfe70f61f171bd52134dd77ac00e2204dfc2"
