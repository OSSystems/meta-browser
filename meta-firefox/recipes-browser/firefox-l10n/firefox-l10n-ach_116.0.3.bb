# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c3a0cab3dfe4282e298ee2bed54328a1"
SRC_URI[sha256sum] = "26a852b7e0b9463e7d13ffe618e0ff37044f6bdd4a7c5ea324044add42904585"
