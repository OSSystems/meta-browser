# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9987384262ec385668360ab9a1492eac"
SRC_URI[sha256sum] = "c66320cbf9afabeb855f50462ad6a3b120781702810162e3f3b3dc735757e6d2"
