# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "74ac2454f515eb360df0032330347fad"
SRC_URI[sha256sum] = "02690cbc908606d151e8868adaaceb5cf26ca8d2cf0d30a33bb8f40ee2b079c0"
