# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "f0bbc5ab4abd6e0bd101db178ad11b48b40faccb752e0c300989beddad3109bc"
