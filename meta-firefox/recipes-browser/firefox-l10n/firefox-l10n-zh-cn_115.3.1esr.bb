# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f3e27c4168c1a618fc6dd03b0267cc40"
SRC_URI[sha256sum] = "cc3fa42ee4366ef0270a61422283b09287f56ac01f59179c44f54bd257137762"
