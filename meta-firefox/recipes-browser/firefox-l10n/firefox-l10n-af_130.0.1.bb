# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0591a0af81b0cd2fcb7c6f5aaf82d611"
SRC_URI[sha256sum] = "095926c33b13a5f46b4672dcf410d8008a4688fec4c0cba369c25bf03b9d8d34"
