# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2622c47207c0421ef5e8418c8d565e49"
SRC_URI[sha256sum] = "e6dae60eb22847d1cb37d7255113db873b17cf415698039341b6a22bd1af8770"
