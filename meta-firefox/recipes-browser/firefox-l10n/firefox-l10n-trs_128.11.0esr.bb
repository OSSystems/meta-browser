# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "84b80f87f3e328b6e27f493ff2cdf6f0"
SRC_URI[sha256sum] = "31d66bf9f4624413303987eab8414cba32855487130e92b00527bec212569788"
