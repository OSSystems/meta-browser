# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b0657ed99ab95aff0d0f6811751a7776"
SRC_URI[sha256sum] = "43903499b3ff9757b3cbeb02af0b941ad66c5a2b6dce7ed5c740d4b048327abd"
