# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "abc1753414afb24b5a3533bf694b6353"
SRC_URI[sha256sum] = "44d1313f797d5d3fee27fc9437abed931d856a3b93e214157216ef9cd3d4d564"
