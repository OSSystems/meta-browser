# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "13cd97bd06eea855560c30e95297407a"
SRC_URI[sha256sum] = "5214795e651988f96fc90b80c3f38b88a591bb6bef877702a87a6cecd1f08f06"
