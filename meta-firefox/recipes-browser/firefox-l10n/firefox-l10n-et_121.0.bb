# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "90116dfbf6c4d4d4acc932fcd9c60410"
SRC_URI[sha256sum] = "41455241816bd26b6608dac8e897cb7cb8af8c2aab38f966a9144efb7b192706"
