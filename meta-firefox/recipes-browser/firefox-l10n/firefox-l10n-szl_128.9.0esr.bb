# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b9c4a998f171c254123887a75e210af9"
SRC_URI[sha256sum] = "3fb1618cc7a9ea5b5edfa903af7b39ec95ce6de4bc8ab53418c0103e884e3ddb"
