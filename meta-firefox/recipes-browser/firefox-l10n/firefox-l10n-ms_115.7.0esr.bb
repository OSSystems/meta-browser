# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c339eb7e2391b2419357f4edee70ab36"
SRC_URI[sha256sum] = "2c17bf61d5b378aef10bde5b5d824f82c2cd06ecb60b8760a611dc0116156f9f"
