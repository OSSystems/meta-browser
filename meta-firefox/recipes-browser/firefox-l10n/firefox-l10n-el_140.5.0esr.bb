# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "12a537050ef1ba5ac4ede263a10cc735"
SRC_URI[sha256sum] = "64d194287fb77897916c708472c81800ccbaa9b8a0441764a0d18407e0af1634"
