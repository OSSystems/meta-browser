# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3721e9fb2ea9279e56bba22357836d07"
SRC_URI[sha256sum] = "911ea6dac2fda2dc2bf72291c9bd3f0d46d6d064acd3e1b5dc86157a91377b5c"
