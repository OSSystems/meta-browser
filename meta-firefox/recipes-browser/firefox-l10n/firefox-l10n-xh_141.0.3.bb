# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6f7e5b41f0aeaba66889de211625fd50"
SRC_URI[sha256sum] = "d55bbb39446f0caf42c6bfe46c8e8c05a95fc7f067a831074e15b8dbe85d54b7"
