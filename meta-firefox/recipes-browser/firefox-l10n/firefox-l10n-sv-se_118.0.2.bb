# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "441eae5168b52efcc91e287c9799045b"
SRC_URI[sha256sum] = "d9a67295efacd0e4a75e0bc5d2210ada859b5d56eb53d04e3419d75da2dd219a"
