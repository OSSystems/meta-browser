# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b5a013178764e401c8f5e0c5b39b3af2"
SRC_URI[sha256sum] = "bc58da3ce0522866a95ba45085d9e0285cdb1110e229deee002a1dc57eb3f01b"
