# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eac7f15f3582d2c9de8e923766a0fea4"
SRC_URI[sha256sum] = "6a5b3beb3b66727173e3eb6c0ca1b39add83fc78e8fee594632949d17e1956e4"
