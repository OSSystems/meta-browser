# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2838ce0028e36684c0e2460f8a5fa629"
SRC_URI[sha256sum] = "28670c3b7caf201803d081a9104c208e235846cab9665b606972741d8c7c0807"
