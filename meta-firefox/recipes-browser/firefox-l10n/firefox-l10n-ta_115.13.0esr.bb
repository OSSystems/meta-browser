# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "71dfdb4c2bffb2749481040387e70600"
SRC_URI[sha256sum] = "d9f48ee5e14bebf5e4aeae0f20595e1fcc6c7dfaf7eda1a70fd52d6bf113381f"
