# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7d039a02ba587501dbefe45caf9f36e4"
SRC_URI[sha256sum] = "e3460aa1514f561c95277f218b6e518fe12bba5fad7fcde11ecace8d3b9bb088"
