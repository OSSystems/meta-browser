# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "90084f342a6a91c13ae5af07ccc69a74"
SRC_URI[sha256sum] = "5fec48edc7b308f6a9857acf2743f486d747fcc8fc2552c3f9e37278b90a9ecf"
