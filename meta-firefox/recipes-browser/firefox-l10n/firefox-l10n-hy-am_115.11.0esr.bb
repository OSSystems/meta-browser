# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5d3fd0598a45606399e3d334d4ce0445"
SRC_URI[sha256sum] = "2773cc2e9905cf0a88e3b952b7b43148c85c5d23bfdbbc463e1719db6390909a"
