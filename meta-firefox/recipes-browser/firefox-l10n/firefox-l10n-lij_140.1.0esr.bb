# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2d0a3acc2b08a360dd11417d08da84c9"
SRC_URI[sha256sum] = "9debf35c9ad4e97891e8f7fd83c4229c9da3ac3d691bb6709d277fea21f5046b"
