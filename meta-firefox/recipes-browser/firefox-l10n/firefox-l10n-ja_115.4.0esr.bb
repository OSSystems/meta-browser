# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "296d0b4e053d3acd5e10c588cba7df70"
SRC_URI[sha256sum] = "8be6fa50293310fe79410d9897abc20cd7fd5fe7d781a9219ef63d361af1a196"
