# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "79d9c14fa68be7112a7c35de239e615c"
SRC_URI[sha256sum] = "b5f3d2d446f3329029f5048505f33d91d0753d8b82d0470d160b71b2a98ba974"
