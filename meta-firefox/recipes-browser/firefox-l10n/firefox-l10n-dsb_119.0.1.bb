# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e397dcea86603bb3ad4a618d3242d012"
SRC_URI[sha256sum] = "66b0c9016dd3b8ea50243b9e7ce5ce429f7527d5efdc86d5e95bff70538bf1c5"
