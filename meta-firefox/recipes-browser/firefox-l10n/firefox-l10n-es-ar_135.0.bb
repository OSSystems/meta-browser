# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2a64e6356316c044e6761bf23be7dcb6"
SRC_URI[sha256sum] = "52ea5e16428e6886d014a1a05d152d0a8a17e37f7647dee695bccb912ca17033"
