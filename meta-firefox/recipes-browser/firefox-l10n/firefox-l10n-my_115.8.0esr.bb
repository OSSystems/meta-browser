# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7a7a5c0bd3ae7953f4b8c562aa5154e0"
SRC_URI[sha256sum] = "8729fb8f050eb4e9e21764468bc5b1d10e5e74756114845114da01a14e4aa068"
