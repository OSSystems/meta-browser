# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b5adebb011904a345b0197587783b4b8"
SRC_URI[sha256sum] = "153558e46ffbdc0aabb4ec9019fd6d883c564afebfca34968c293435b12c678c"
