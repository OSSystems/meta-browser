# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3d3cea98bfa50167e4c294315025536a1fccff199d8d8e47629ba718fe568c7b"
