# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8cf0324af04f5182af7afa7ff6674744"
SRC_URI[sha256sum] = "c8d8588c01b4cf6558cada340befc382b59e8277c07740986a59374a0371b0b7"
