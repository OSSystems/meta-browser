# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "016669163d07109981dc78fde081097b"
SRC_URI[sha256sum] = "f9d87760fb8be736a1969a59501d8f9a84b4eb73d29e22fe8988ef516bd65b82"
