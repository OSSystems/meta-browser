# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f506a97cf12bfdd996342783e8ab41b6"
SRC_URI[sha256sum] = "89f6c1f97548302c5478521113d09dd9fca9fe34edabd7085f4c6b8c259935d5"
