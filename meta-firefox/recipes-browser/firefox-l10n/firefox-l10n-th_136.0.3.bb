# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "99bced62f71ec651177970afb8ab17fb"
SRC_URI[sha256sum] = "ac60a9f8a6de10302920f8949fb0bdd0aad42eedcf595e70dfd72fae2206ef8f"
