# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e814251d9faf4ab029788caca52339e3"
SRC_URI[sha256sum] = "e7224ebaab24fe301214934623d5b4906f60f6ee6ce15e3acab56b07f5388bf3"
