# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fc54578bb62dc22d8164733df63aff19"
SRC_URI[sha256sum] = "adf21bd23d57f738ab98c44e15fba5f2d1e0503f86bbfec072adce5881a2b234"
