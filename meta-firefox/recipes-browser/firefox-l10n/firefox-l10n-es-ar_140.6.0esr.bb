# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f13647560306a39823d5d00096c750d2"
SRC_URI[sha256sum] = "8094cc5fb445690dbf84832daffd59b776236d6524a163a5fd10f3f191ae51ed"
