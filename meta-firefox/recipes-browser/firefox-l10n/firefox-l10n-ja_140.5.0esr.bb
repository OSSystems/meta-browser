# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b3910a08ac853c8d39b1657a79538b7d"
SRC_URI[sha256sum] = "9f7bd7dd0a5629e029a9735052f9512441b804bae0bffbb1bf78009928acaa35"
