# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e5ee50bc36fea602a02c756e94c31b06"
SRC_URI[sha256sum] = "443130adc414f5216cec7d61f255850f7824d43a77f560092f195fcf7299dabd"
