# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b9a1f9265270403e0623b327b5f40fac"
SRC_URI[sha256sum] = "5e5a2c3c04eb2ee38c48a115378ec3c7e13f9f9ef096b03f50759522638136bd"
