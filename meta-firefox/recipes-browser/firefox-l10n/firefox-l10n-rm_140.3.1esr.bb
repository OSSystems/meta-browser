# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "37f6cc7a6f6773cf0df94823816b85bc"
SRC_URI[sha256sum] = "620b8610fcd24b6a0f89e3c4079189ca7f6f568d694fc3143d19ecece5db20e0"
