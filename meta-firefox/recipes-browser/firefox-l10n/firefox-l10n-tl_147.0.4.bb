# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cc71a079356c891032a35215dc12aa4b"
SRC_URI[sha256sum] = "89b2fb780821247b18cddf3aaf30a7b38b15b1f03135801a67f52e85c5f9a7b3"
