# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ac0e5c5404aa9725ae445e5eae659b7f"
SRC_URI[sha256sum] = "b6c6ace4540a4934ea02382b574401200151defb00134019987a20859782ab19"
