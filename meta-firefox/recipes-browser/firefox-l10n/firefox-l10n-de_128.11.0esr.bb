# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7f64654c7028aaa9229d31ecb1106c8c"
SRC_URI[sha256sum] = "bc185e8c847605990fff0f7419d8c41acb8efaa5d520b27bb8b21b02db7535af"
