# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8598e37a04e85afe3ad8d593e7f355e6"
SRC_URI[sha256sum] = "9aea345c1477564f2034d2e0186b0d3238958f33efbf0e5456c3ae4ce3286bd2"
