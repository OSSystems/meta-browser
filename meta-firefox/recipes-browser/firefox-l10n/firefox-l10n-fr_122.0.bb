# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dfc9c98c8d2911b142d7d456fe63f36e"
SRC_URI[sha256sum] = "a168b9de05d45c7191e1b0bbe1a8d5f2fc66eafe46b0a36062a0f3b5ff6e2351"
