# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d5d0e8c8403ae694933bf842d7bcd766"
SRC_URI[sha256sum] = "54aba98a48ecec250f4b36cf8ec1a4f60f74f6b214bf1729398510e268b96b38"
