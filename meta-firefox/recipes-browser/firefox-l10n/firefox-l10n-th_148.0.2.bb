# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "98f2a60b3c79aaa6e9c48ca23f9562d7"
SRC_URI[sha256sum] = "c514389dd868d1afe50a74a9766a8eb2dd01b0ec5b75086251d3f93e5a0473b7"
