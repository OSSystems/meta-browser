# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0251a736de94ee59986e560a5211c7b0"
SRC_URI[sha256sum] = "a449d64320164a4cde967c795b954d0efdb9d548b56f9f061c30d7912f032bd4"
