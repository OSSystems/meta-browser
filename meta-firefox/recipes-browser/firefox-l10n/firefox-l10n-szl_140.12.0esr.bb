# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "078ca9fdba101e729f51d56bfe0aee82030daf115d66ffc9baedc04119ca0809"
