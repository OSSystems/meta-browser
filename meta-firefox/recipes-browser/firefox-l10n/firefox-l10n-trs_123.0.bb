# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "13b268b20213a54310e9fc3a63b4e581"
SRC_URI[sha256sum] = "38a25c990aa345c43a3c87131646c00f31787e47b96cd8a48c2a300dfc2a57dc"
