# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fde6c7618aaa05f84f47f477887cc668"
SRC_URI[sha256sum] = "4ad3d82a31ac8da8574c664ade4530f5aaac15a9ffdfbbe7d24043fe6967520d"
