# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1cd3461afd49a54d6d620ee234639245"
SRC_URI[sha256sum] = "d4f6d055730c57ab152745b7569892425d2d3aeaf605c8261e7acd6f83ab48d0"
