# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "62647ff40edd4fadb7eebfdaacc98125"
SRC_URI[sha256sum] = "84059eb868874fdea1bd99dfe7ce1e72b1c3452ee63a76a06d5f7071c4282c2c"
