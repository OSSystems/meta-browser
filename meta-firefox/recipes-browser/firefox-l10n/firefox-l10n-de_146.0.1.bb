# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dd11764bbea8f770ef29be88790b81e0"
SRC_URI[sha256sum] = "6494c9fa7ddcd3479c7cc5eef13bea1c3fa8a4f173fa7267b70d9313cb87cd82"
