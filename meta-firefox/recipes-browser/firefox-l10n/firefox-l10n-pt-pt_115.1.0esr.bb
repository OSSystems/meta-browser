# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d86e7fc783fef70cf8cd131dfd2c6b11"
SRC_URI[sha256sum] = "a5f2d30acd0fcee194a77032a7f602d5fb881f1df415d701c2d0777f6ec1b124"
