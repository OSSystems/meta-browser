# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "47528f834293ec108299eec8a9a31df2"
SRC_URI[sha256sum] = "0acc73bcd9f87fd33ff9a57cdbe1828f836cd73717761741038db005647f3156"
