# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f53b4ee371c16e99d3e6c64b34da0c17"
SRC_URI[sha256sum] = "1dec1118502efbe79130b0857006bff45ebb852556909cb5a468a5739282b55b"
