# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b9b04bd285653568c41aa7eb0b8290c7"
SRC_URI[sha256sum] = "a842a68adb06efc774da3b84a3936ad1b79e49c995a060c816478cfb78ac278f"
