# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e5b9cb10aff1862a1938886b014bb705bfe3cd2e802b31d9b5d5b36b6db819ad"
