# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e9c64da3239d7b8c502fb1d2cacafb43"
SRC_URI[sha256sum] = "b3d38f31e17f7383bfe3249c1c1dd46ed0ffe611d0a72e46c0c896bb4d1d3a78"
