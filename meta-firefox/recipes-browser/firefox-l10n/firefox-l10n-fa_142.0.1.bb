# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b1cb0e5b6e965c67ab7773856a50d7f7"
SRC_URI[sha256sum] = "1e786a4411d4086257124482c43fc84da6b07a9f3d3cd5fd2795c541f5efe92e"
