# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9fede8db1da84693b472f870c4c3fad6"
SRC_URI[sha256sum] = "78d1f9ee461869e8fb6f97c64728f242062f4ab93154e1fe4bed2af83d7679a1"
