# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "17d1010dfd4b7fcd3647feaed860ee1a"
SRC_URI[sha256sum] = "fdd77ce5b4e0848058f54f1b365a55657617be7c011dbd6b12fbc1f7896bfbea"
