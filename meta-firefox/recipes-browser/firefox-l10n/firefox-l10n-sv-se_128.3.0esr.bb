# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "62851f78e46e807ad247d14807fc7e80"
SRC_URI[sha256sum] = "9dc2c38366c50488e77703cdd7d6d9170f3e1b522e0c832e410e6508db753148"
