# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "67d99ca7b0ab3773cfc3a961d3079858"
SRC_URI[sha256sum] = "b9d976dce4997e3cf618a3c02a36f73f4ccc17c8d332b5272506864d886a28b5"
