# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "782f3ad3a0ca42200e806de58e26eba5"
SRC_URI[sha256sum] = "b8659c5a7d81da27f0a43416d207719e8de36d8fad46d1c58f700d18aa86787a"
