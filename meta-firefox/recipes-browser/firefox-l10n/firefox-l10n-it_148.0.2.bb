# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bf87d14b5150dbcca78ed4e426088353"
SRC_URI[sha256sum] = "656ae08135d0d9954109413d49cd296238e5069a1b661503ebfe9a8f2237b1e9"
