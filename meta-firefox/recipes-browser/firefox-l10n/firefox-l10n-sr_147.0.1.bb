# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "40ec854077535188e5e5e0a09a404b93"
SRC_URI[sha256sum] = "4b201d914f629ad311b4a52e3ce372e7dcac381a01fd9bfeeedde041f63ece33"
