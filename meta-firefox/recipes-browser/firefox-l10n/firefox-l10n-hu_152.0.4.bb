# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "78b63d6855e8c3c2af3eae8472fdb4edda0a380d2b3af895c2692befd2214ae4"
