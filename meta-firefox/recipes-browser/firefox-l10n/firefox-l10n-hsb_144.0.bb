# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "790d2ac90d998eb716864e8cc5cc6f5d"
SRC_URI[sha256sum] = "3d142d6d8f65f631c28140431288b30e1a97935c001877a2ea4ceeb124f0c747"
