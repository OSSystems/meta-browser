# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "606b8e9707e01cba09fa50782c114784"
SRC_URI[sha256sum] = "dcf5ee01aefa27b4405afd77848b32ea3fa3d5b3422bfd15972be64f00318c3e"
