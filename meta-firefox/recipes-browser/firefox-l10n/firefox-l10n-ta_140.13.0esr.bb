# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "b70edbe2a8460566689de79dbf784e7d97ecac7e499a893777658c497e3afa32"
