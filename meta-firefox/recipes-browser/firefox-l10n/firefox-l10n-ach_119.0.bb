# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d6b74e3a1db8df4f4f896e75699fa100"
SRC_URI[sha256sum] = "bbce6d47ef0ee761641fa7716cc6fcbf9b20c71afd24a17f4a75db8df417164a"
