# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "63977b4e0affa476190a3d66593ed57498eb8435581e075b95800364251bbc84"
