# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d8d7ef2e3467f6fd867d800bd3079655"
SRC_URI[sha256sum] = "6d865f345424f0ce73273cb7b71ae12d222fe6ab224d74a2a6d9ef5e40dfa0d7"
