# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aedd3b4b3f12964c13f9c19b5843e553"
SRC_URI[sha256sum] = "38060a12da7605e38733362740b30a3718f0049cdbc1d1864782e56ac5192f51"
