# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3b4ece6e2bc209309da7476d086aff0f"
SRC_URI[sha256sum] = "692badace4327be5bba4b0592f8c38d11854617a67471af9b47f63e85b0df14f"
