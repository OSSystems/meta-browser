# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "784e033e0d4e5d7e86d9101867f346ad"
SRC_URI[sha256sum] = "7d2b70f2c17caf43955b1573e6fe53d7aa047c351791270220a6f0aed4a4c00a"
