# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "89e65e26b3ecd0da2659cd15bf11d28d"
SRC_URI[sha256sum] = "7d94e45840274a30473c47092704a08594102f8a83774c6f456e49af6000bc69"
