# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a6edd383e52b74a95115fe08b76960da"
SRC_URI[sha256sum] = "3a2800f50b5720c4e0c80efd926e9ffe32a4d182bf3a6fe3ab3fe04882d1a780"
