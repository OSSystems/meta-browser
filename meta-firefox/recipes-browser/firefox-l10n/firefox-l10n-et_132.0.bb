# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1eb880897c654abd7af3b86980dd5670"
SRC_URI[sha256sum] = "1acdccda6a81094dbb87a9f10e7a8a38c391db52749b8e95a625f5dc1d93fef9"
