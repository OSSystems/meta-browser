# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "84dc4a5690507729a1a0cf53ee8b18a5"
SRC_URI[sha256sum] = "1e19800457945b2fc71fa037a8dbe0a79235e850826ad18116a146dc6a1da51f"
