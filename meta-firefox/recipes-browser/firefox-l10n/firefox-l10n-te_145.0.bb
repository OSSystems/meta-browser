# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bded17cf0a412a7af585a855f4590908"
SRC_URI[sha256sum] = "1c7401a145e1e0e0769cc151419043dc96eb7452de681265bc92e66013466550"
