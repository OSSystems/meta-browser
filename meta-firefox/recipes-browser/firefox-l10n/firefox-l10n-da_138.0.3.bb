# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "82798d6d60a6c4e201e8fc6471ca99fb"
SRC_URI[sha256sum] = "2c0debd17cf608ec6a4554f6f4ef7091fa06c2680ceb9123882a7b3528d89a17"
