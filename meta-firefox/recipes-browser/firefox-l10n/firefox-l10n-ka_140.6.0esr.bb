# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b3df1f875b2bf688504e575c116282b9"
SRC_URI[sha256sum] = "76cf59bd5ed59af5f9c45a5788ef7d3c2923177463443cc797b69ebe0efa19b7"
