# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dcea0cbb51d8f1cfbcef380424a798bc"
SRC_URI[sha256sum] = "7d869262a2beaf39d503b654a0016251c0fbbb1476b1dee1b611d59dffee845d"
