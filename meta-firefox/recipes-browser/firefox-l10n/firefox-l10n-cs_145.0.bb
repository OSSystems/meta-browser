# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "862f26d79eccddf33f284aff2dbb24a5"
SRC_URI[sha256sum] = "73ff18142107652cd0de253c7106d7e4a26368d92cf81e6c7700156b95025d7c"
