# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5fcba653aa5c4f41d907ed2699850661"
SRC_URI[sha256sum] = "4bea3bc605514e0f07dc62fb92b8b772336c9f42c8c22d1da450e19048bc6c1d"
