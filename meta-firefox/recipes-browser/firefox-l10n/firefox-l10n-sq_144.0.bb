# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "03a0767c76fb03595487767ab36196e8"
SRC_URI[sha256sum] = "dbb4bd5a143882de0a85550b0db4be88713c174badcc3fc26ef54ce783475d5b"
