# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "897a23cb55d9977ac4996a0f65f540bc"
SRC_URI[sha256sum] = "06b0f4a4fcb88074635e97034f3f671eb8e20f444c22b8ccff8f42b250777b20"
