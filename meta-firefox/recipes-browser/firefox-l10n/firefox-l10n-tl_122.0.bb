# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7db823c8d570d0d468e1fe2676369d5a"
SRC_URI[sha256sum] = "c462278e7b9dd328eaa842a2f31d836a95100165cb8ab83fbdf1d2c1d962d48f"
