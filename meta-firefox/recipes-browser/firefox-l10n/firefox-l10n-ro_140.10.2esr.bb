# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c3ece8f743f560599e7c3d9da4e6184fd9f69b92e81ca74b15491bfb0e0e33d2"
