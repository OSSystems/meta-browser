# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8d87da129c3c26206e498117e9073d2f"
SRC_URI[sha256sum] = "cf71dd6fdf7396a465a32e573a8c10a603bdbe7a43a5dccffa6318a4e89ad7e9"
