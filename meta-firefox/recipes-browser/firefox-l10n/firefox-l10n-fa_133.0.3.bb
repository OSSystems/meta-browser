# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6648543d23b9c0fd8e18a6af7e939984"
SRC_URI[sha256sum] = "b76b1a641b9830bf08f9a1f09a3cddd31c2f5b41fa3a87e079368e7616314e43"
