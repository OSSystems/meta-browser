# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3b12754acc4102bdcccb302a4a8a156d"
SRC_URI[sha256sum] = "b01d21876e95616cf2226932c850e027c0ac536cc9db3e6642611ccc862c201b"
