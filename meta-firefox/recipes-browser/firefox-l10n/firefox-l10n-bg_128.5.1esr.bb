# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c71f09c9b82576c1fc91ab65b76797ea"
SRC_URI[sha256sum] = "998b79d2b0cb6a9b3a25a77a22771954f8626eb31aeefc22a5073e98103d6ed6"
