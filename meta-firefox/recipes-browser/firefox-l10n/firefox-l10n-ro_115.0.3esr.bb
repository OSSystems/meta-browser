# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c26edebdd38c08fc2b3767482cf226d3"
SRC_URI[sha256sum] = "ee87032ae1e7e75867f87bc946961d6c884de19ece67f46d85f29f34f5ab571c"
