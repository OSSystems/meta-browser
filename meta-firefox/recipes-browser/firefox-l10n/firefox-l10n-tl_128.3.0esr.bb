# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "19b35a9f99a0a44f21ce389e8c54ef76"
SRC_URI[sha256sum] = "98056eefdc54c39a9fae2d21cbf370549867438bd848ada41342f1502db646a9"
