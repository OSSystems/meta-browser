# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "b47d7610069d853e519aba1645c55089c82ab6ff3de8b0e18a0cf091931ade6e"
