# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "4183172d285a8085d345d3d777432fd7c2fb2e30edd1ebea2e34d514f73c4588"
