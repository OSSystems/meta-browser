# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ff503b359d2f316f0bdb7d51b97e3803"
SRC_URI[sha256sum] = "e05bb65df5ceab0293bf827fddbfa42be42d01bb4dacc6b4ae4a307da3f88464"
