# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ff444b3499dcdaf4cb55351f723da019c1fa8e7804605b7b5535e8f912ef5d41"
