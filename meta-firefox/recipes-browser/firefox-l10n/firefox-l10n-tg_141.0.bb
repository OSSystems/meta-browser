# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "80765e7bc71f7a647f89e818943ed553"
SRC_URI[sha256sum] = "578cd365fa7bf88ef55c1f61685d902c0620d878f1e8876024fb740d6c340ee9"
