# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2352b165c90c576d9a3976593388591d"
SRC_URI[sha256sum] = "edb743155366dd4b47cd28f0a6fe05fbb9e57cc67ca014788a64418248855af8"
