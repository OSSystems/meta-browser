# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9321e1bfcd6ea61e8658a1f00f001daf"
SRC_URI[sha256sum] = "aec8bbf92d6761046612b447e5e33d6199e21a674aae30874f0a17541de806ca"
