# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f3920ac139f10ecfa7e6f5e1f7813c1c"
SRC_URI[sha256sum] = "c4bb451781863313fe35597f6329239d8330f1f6cd1372bec3e1dbeed1cc8ac5"
