# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6d8c3155ba12b0cafdd26910e64d3a04"
SRC_URI[sha256sum] = "b971f7945a128e47a3257a3f17e198b6f3002ffd5b711ad613d008b2ca0bde73"
