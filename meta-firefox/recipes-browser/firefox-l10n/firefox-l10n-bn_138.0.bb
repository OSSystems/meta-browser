# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dc37c83e63a28d2a602d46c5f9df413c"
SRC_URI[sha256sum] = "785f2d7c33b42e0a0e846da08279a5ea0573586ec68fb6b6bf3207c2ec20df5c"
