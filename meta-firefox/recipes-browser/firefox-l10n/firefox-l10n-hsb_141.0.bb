# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a4c5c51b9e2af7d7c6e4e78b1dce0ba0"
SRC_URI[sha256sum] = "2423add5a436236b54230d1321cadb8b43088517a4910c7b76b0fded4b6b8f48"
