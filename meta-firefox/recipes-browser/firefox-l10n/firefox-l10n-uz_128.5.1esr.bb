# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "589888ea60d2f3d8fb4f3ea2e51d2a97"
SRC_URI[sha256sum] = "fbddfd3ef5c230906bba911a497202696c7de88040cb0272ae497e81c45289a2"
