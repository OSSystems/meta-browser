# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fe6676e300956fa29cbeb3ed090c5548"
SRC_URI[sha256sum] = "f97d62a9a151db09daab46196a0eebcf94845b964785c2fc41ea5f58101c49ab"
