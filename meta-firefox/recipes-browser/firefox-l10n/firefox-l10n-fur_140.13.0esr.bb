# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "991cf5c79700c1ab72203fb75d975f9c024e8474f84945e8f6d7fa722d13b4d8"
