# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "20663ed9f944035043cd4ee8a77248f8"
SRC_URI[sha256sum] = "9b0a4b61184123441d75fbdc5992a3bc0e7a2c445800415a7ac50accfc9a490e"
