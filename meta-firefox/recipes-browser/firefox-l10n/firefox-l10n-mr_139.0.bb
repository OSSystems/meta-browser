# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "93d4fe536e04026110348eab83dc9395"
SRC_URI[sha256sum] = "acce5174bffcfbf85eb34aa61c8d5b5b1eaa0b6cba100b66f0a0715da5b8a2a7"
