# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3a9fe7ee923a101c8000b43707fb0a77"
SRC_URI[sha256sum] = "80d1dc3b8fd7ef83f7661388e97ffb025e6036f3502502b61720d3c942d6c706"
