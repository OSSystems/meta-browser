# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d8b38e5b8565e05b837d8a4dd2baa3f5"
SRC_URI[sha256sum] = "67c8e3e8a865870d5fb1e26ff20b4f7ec5d159171c96554db8fdaebb5fdd4906"
