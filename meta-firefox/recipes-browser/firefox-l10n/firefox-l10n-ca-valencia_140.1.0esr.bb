# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f6729554c4c92e1921edf9c8154b3d68"
SRC_URI[sha256sum] = "a72c1ff6797abb629fa73cd12749f87a61c8de20f73b303444155d36bb210e0b"
