# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0deb3134374605ea79c2b726009db7ca"
SRC_URI[sha256sum] = "68d93f4633d6cd4064dfcb680433f424f29bfb711bf2bf696f12793fd90a4a38"
