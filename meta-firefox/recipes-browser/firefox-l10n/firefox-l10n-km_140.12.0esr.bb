# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "6b6547ab051245801b8b6a3c5bb220f5be927b6f730fbbf059b94335d3d44d6f"
