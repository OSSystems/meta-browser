# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "96f876327280ff2c364acb08ae8362d3"
SRC_URI[sha256sum] = "61addee7e21f305156725ea0ee35999e6bb2d479db10fdc870bccebb0c962750"
