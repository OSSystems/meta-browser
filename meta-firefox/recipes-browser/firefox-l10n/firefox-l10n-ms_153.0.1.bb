# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e2bd59a89ef5624dc3989c532d227c22325124d5e99940d17d09323c3b7ed4b8"
