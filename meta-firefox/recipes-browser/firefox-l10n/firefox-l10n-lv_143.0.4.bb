# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "25c1b52032c5094ded1441896bee904d"
SRC_URI[sha256sum] = "84b03b7b3d6663cbc4c38aa9453025d70956ab8bade389776bc8d45384952a6f"
