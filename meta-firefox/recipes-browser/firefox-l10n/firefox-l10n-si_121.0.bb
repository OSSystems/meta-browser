# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1f8d1b9107d83bc6553b30eedde19fc5"
SRC_URI[sha256sum] = "9698e01b864fbf24a09fbfa69f8bb6d5bd8e33d4575fab7f7607e70697bb5e3e"
