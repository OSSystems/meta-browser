# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "361611ebda981ce886dca6057d2f383d20a8b884d84a6d6a5997e77a29861fed"
