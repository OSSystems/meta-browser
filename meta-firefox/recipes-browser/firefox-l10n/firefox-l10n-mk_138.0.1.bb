# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1c1854a57e6c652e49ed0bdf7600e70b"
SRC_URI[sha256sum] = "04b64a9edeaa47a36fbbad8deaa95ee0d354c4df3e26f4994837b8e07b9fac06"
