# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9c217c6f77565da665a952744fa3e2c9"
SRC_URI[sha256sum] = "b010a0bc153ef0205585d8e8bb18ac5c7b17e019f9ab867b93642dc2d438a9e0"
