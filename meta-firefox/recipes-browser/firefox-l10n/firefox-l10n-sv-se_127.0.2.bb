# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e7da49aab6e61ede6866cf013632309e"
SRC_URI[sha256sum] = "64073a8524c6b6110b0e26a881727b3a97689cdb873b7bff7b82589c2fc314b9"
