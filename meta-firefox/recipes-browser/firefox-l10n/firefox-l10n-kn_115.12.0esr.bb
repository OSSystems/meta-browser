# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b2a88540ae5bad178b4e901c823c55e5"
SRC_URI[sha256sum] = "604b3ff7fe88836d26991af7c7a08ca22cf689cd54fa69aae553b7ee6a3bb8cb"
