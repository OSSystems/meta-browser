# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0052d8fb8748522404ea81b462e59efb"
SRC_URI[sha256sum] = "f8f157fe22433faa96f6b634bdb0ebd900bd6f85d0fa01d0731e9a4139950716"
