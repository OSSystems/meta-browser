# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "875191a88a3a6485ebb9d9e0ab3c7727"
SRC_URI[sha256sum] = "a7ba4849c30c9525093fc9db32ea833de653af1bbbe174683de378c1d03b975d"
