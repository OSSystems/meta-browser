# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4d2d4fd33d70cb86a4b48ea66c886df4"
SRC_URI[sha256sum] = "e6e7f83b99f768413a3df376b2f879ae672de52f45a510a0d50a6105debc0f2a"
