# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "59a87dee296f88317b38f3b718cd6ca3"
SRC_URI[sha256sum] = "eb7435722ab10be1e2c8b2c0c3e5d0d50b337955f74fa3a24067a712aab64ad1"
