# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "39a9b524702c84139808eda8351fc73a"
SRC_URI[sha256sum] = "2aaa7f8157dfbff66b7d037686c34837723eec54233e0dd41b8e5451be015a29"
