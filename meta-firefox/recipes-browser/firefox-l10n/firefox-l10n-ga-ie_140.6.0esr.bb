# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "95d554ab8c4545d739bc4cd95fbd2052"
SRC_URI[sha256sum] = "4c4503acecf0dc9d67c56458aabbbe76101dbdba3ebfbe18561ac51fb0be6c08"
