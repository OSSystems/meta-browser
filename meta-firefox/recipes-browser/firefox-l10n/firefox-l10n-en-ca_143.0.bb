# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "489e8dc6ac4ff79165439e87cb438fad"
SRC_URI[sha256sum] = "a2fe544020ae62ae6047e50a22ccaa2f8fe0fe73130b88beed8dfceeacb0eff9"
