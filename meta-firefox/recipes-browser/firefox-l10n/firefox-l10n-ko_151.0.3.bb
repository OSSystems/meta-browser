# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c47cd091c383f7a55c886748ee4fb7a3852fe6bd2c40190437a78364af2c8040"
