# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3bac0c1aa4d4b09c8edb4e51a86e64a6"
SRC_URI[sha256sum] = "0d176146d383b0a7b75135e60424f6cd9588d548440f92353f4683b0053573ee"
