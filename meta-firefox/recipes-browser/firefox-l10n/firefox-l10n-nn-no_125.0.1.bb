# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5ef825f3dfb672c5b3fd03763b9cc6e6"
SRC_URI[sha256sum] = "f332ba8dc7942ddf0f83160d179dff42553739a5e02e9927f845efa52b38b189"
