# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4c467b9125034e0d4f9eec71ab2de7f4"
SRC_URI[sha256sum] = "e56a7918ebd73f1f8c34517eaa6a068dcf7e73922df4b50d3faef21193da46bc"
