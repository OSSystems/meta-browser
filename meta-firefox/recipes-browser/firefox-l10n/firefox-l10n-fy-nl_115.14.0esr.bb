# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b31013374d94d321afa8775e11e95edf"
SRC_URI[sha256sum] = "12c2bb138f7973f4dcb05a62e95c3deea32f7775d5508015f954345a58cb7ca9"
