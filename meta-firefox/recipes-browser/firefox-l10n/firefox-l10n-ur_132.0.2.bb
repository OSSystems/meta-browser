# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8b8eea84149f3437e77074fb9ddd4091"
SRC_URI[sha256sum] = "816650df0d89efc149bd991730729a7998dcc9652a3b027f84f1b2cc6afc6339"
