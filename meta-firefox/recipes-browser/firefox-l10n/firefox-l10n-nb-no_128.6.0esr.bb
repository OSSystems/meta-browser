# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cc3536414de6f103ed500e6777b8b213"
SRC_URI[sha256sum] = "1b877e848e245ffd449f30e7fc333dcfd7529115baa20f29ad8edee8e4189666"
