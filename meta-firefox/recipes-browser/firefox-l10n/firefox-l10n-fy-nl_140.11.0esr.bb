# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2ffc3937d6edfeea475f1fe29649b66a89e442ac2b8129424cd80a2e6d74a8b1"
