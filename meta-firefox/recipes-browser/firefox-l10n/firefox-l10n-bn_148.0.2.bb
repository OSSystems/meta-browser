# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "be332ac047d2f23d07a1c84b73333e09"
SRC_URI[sha256sum] = "7cb94d3de44365d437f501e983047a287a3a3b594ea3839b79e0f2ae1b4eb29b"
