# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "485f77cbfa2fdc44955983fb9a33dd7e"
SRC_URI[sha256sum] = "ac7d512c46530beb91027473d8ea11fce9c5b11934e3f1523d4b2a9d48614edb"
