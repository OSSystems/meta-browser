# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1636f886796fdfcc702a15cd03e9526c"
SRC_URI[sha256sum] = "3fd6018b25bc224b0881782b0cf2eb3a550ffbd207ddacd80673facb7d1d161a"
