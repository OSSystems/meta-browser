# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2d5532adad70bae4e26a10c8557a10c6"
SRC_URI[sha256sum] = "faca83e2b02d3360ef1ba778fdf1843ba0b77746393bc8bc9b4c2acec2c72610"
