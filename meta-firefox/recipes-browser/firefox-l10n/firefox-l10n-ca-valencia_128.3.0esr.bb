# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5165f75a6dccbddead5db2f783ad47a2"
SRC_URI[sha256sum] = "0c88774b9d5988009ec8d3c30f5f876287105675213811b2ba0f396ab4a621a7"
