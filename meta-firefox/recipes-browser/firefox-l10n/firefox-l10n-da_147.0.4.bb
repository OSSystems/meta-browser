# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b7f69a5af6b8677fdc3e02654143a1bf"
SRC_URI[sha256sum] = "502358f8dc28ec43cb626634fafa855946b6f99e3f6a38c8cc1b4a1fc365f286"
