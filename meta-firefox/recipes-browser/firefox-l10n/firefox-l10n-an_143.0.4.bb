# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a6abd156f9d44143e3f45f9b2ce9f43f"
SRC_URI[sha256sum] = "67c5efd9edc65addd0918b24f44485e41f713ebd3f90c8acb9edb11db3d361b4"
