# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d32e273614010c3e5032d7adcce61df8"
SRC_URI[sha256sum] = "71ae56f207f2cda52a3ba2a4afa7fa12847ebfc15240c96d0ec44405571732df"
