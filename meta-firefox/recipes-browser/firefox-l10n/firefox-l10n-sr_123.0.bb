# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6ea0f3fca0b75d6cef37ed4a19e4e5b1"
SRC_URI[sha256sum] = "3eb120493c6b05359ef76f477b5feaebd65cdeed0b105f2185eac8c9657f68a8"
