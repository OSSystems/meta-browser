# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e98965ba4638e62460e4034e205e2152"
SRC_URI[sha256sum] = "0f7ac1704f44ed58b8a756e61f836460ea5d0732917daa4f6e4cae7c56a793a0"
