# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5bd65835742ced70a8c92d25f9a199cd"
SRC_URI[sha256sum] = "0eb04aa7ec1ed2d1732f2c99f5c4382ff2543d74b18b7cf6d1a157e3568a9366"
