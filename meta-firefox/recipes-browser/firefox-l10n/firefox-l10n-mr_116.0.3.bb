# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6f185d92d5e976018b5a52f8d61c0eaa"
SRC_URI[sha256sum] = "5376cea7280ac2bc032a9b9632bfeb279a17292df0bb11e0af432d681c1fe114"
