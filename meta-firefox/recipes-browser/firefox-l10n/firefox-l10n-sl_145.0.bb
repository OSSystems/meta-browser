# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dde44f27014e68dae90a1d6b9eaafcb2"
SRC_URI[sha256sum] = "fb765e5e907c6f9b52eeaaa443c2753ff8d3b2cb6e5a40006adcb45d3d95bd27"
