# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d17f3d2fc9f2eda0e7cca029683f9863"
SRC_URI[sha256sum] = "a035cd3e311abb91061444bb76e56ec5e6e64fe6546b61f4e6481a45f51440ee"
