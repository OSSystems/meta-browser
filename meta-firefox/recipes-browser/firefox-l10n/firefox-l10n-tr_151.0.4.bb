# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e050090dbbea9ac80a1a9e15fee151c133489d6472d842e4d1ebd6d2a3e8c40d"
