# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2d1f9efcedb91174e80bd8d9931aeb1c172b5b749e8106bedae2e5ba305cbfd0"
