# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "a335010a066a9c99834c1944e7383f5cadd5d6e58c4262742974094d97e92aac"
