# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0da5a4aef25f325539bd1f7c022c6fa7"
SRC_URI[sha256sum] = "dc390069a5298a98cfba87d6b68db440a4e690f2debf38bfee35247f30bed1a0"
