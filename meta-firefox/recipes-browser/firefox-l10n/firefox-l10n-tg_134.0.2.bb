# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0a1196e20bb23f1618637af7cf377491"
SRC_URI[sha256sum] = "69f4a8ad21d3db5eb82cde098ee757a3ac898288835db69475b5d3d2bf938ab1"
