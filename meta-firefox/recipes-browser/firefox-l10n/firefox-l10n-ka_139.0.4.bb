# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d0f5dc003ab49126c0191d8231b274de"
SRC_URI[sha256sum] = "3c69d4ff15e22e645df9000b5111f23e66ce4df9f30e392ecd2931afb774c992"
