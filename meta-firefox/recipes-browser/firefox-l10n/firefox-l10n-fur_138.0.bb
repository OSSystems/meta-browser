# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1ab881df08201e0ed5191f6c7a38f885"
SRC_URI[sha256sum] = "1374fbf712933659eb95729ca8d402742926efccc6b999c4aeade49b737fafb9"
