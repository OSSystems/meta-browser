# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c6f41e62a1189ebbc01f3ef955649304aac2e874992738238455a6056220d7e3"
