# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "494966f5fdcb87ea9453ee91d8f7f106"
SRC_URI[sha256sum] = "fad071d2f7a09bdb7a1ee3238b25afa59a731772476641656d008c93fc28428f"
