# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "07fc2e9f9b45f9460bb6c50c38357392"
SRC_URI[sha256sum] = "fabd684595b03973f8af60687b725c6a1db85cc719e69704219f9e28568f6840"
