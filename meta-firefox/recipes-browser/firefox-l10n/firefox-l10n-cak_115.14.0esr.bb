# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8318a7c13a624ebc042b4ab50247cc64"
SRC_URI[sha256sum] = "3e21e6b88434192d39f20d5c3a8d772ffa2426376b40b3aa1b1612f2972ab3fd"
