# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "42c7bbf26747d094e71fef9da420627d"
SRC_URI[sha256sum] = "c9fa3353677ee27afe6141bf41263c6d3fc82a35c1ca3135e45d1e360fe0b34e"
