# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ff5d28bd346c4aca4787688c58fa518f"
SRC_URI[sha256sum] = "a7e6c281eeb3a8aa9b9dda29b010e252843a018264c5427c97ce729cac180957"
