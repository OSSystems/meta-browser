# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4155560f11711267c8612179edf6699c"
SRC_URI[sha256sum] = "3324e279990e7dba17c26c701a67747e3afe77a9ca5ea419efc7f94bc2d9f2c7"
