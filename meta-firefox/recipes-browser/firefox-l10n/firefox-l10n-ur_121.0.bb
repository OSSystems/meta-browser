# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "06f291e68df777702f568d87497235c1"
SRC_URI[sha256sum] = "039fbd1bbbc8f6bf61b10dbea14e7ce1dc2c4fecfaf5526ff9545410324a372b"
