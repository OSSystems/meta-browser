# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bc3134d058964bed20733b42cb45e9f8"
SRC_URI[sha256sum] = "e068ed50b88a236ad9a8198d903777cf06209ec9563688b034de83b5fa942ab7"
