# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5a274dc2de78342a9ebb248ba3c73fbb"
SRC_URI[sha256sum] = "5af9b2cd617046a902e739ed2f2513af68d894973425d87b9d116ae44a389671"
