# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "31690154d787cda07a73a013042cf3dd"
SRC_URI[sha256sum] = "3ec07b71e8d694394702837c727dc70b18b19c426303608a418cf72a8ab8b1fd"
