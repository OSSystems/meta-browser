# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5279215686e0c54eb38ea938c5118051"
SRC_URI[sha256sum] = "f1280064ffcaef1cacc9136d6c3d0ce428b340fde966124616362e81f0cc1657"
