# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a28a82d5c959f258bb559aaab1e1f3f0"
SRC_URI[sha256sum] = "ef036f1f6b65ba7e4dc26850977c2fbaed9e708a4e37b57c7b9b056906fa8ee2"
