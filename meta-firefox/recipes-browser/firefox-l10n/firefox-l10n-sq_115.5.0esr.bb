# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3deaed31ac71dba51a1e7a7fe5ab44b9"
SRC_URI[sha256sum] = "b741a051774d8d7273fe20560f50567bb41868d88a1b570c8c5f535e75f3662d"
