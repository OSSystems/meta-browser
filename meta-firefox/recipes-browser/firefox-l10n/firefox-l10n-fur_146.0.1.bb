# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "acb7b4a3631edabce1759734f37b253b"
SRC_URI[sha256sum] = "7fa0beb1e9c086c919ad7f62af86e4b972dcaa395e7ca75149db401d4d0de9a2"
