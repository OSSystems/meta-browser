# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5bc7b4d63bd8622bfb5fd3a43ea2b8be"
SRC_URI[sha256sum] = "5f126bcc6134e8ba0728cde383a3835f325e7e57d2d52b71c88f1000bf1e93ab"
