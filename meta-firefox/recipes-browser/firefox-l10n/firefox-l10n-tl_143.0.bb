# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9fa98897bbdd443e45f062ea40f37432"
SRC_URI[sha256sum] = "cd92b50cacc0d2d2e539e3a4f66bb87a45a28098359f612c7f6e8f89dab2e0aa"
