# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "33582f41e0dc263f202c8d0ec76d6480"
SRC_URI[sha256sum] = "1ee7e34c6f79496dca0f5d347327e4b09b30e78b6701a564040db1cc9d8fcbde"
