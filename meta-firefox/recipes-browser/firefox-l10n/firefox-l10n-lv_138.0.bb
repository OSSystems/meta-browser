# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "32cedb4b94e8dd7f6cd7968229f961c3"
SRC_URI[sha256sum] = "2304e28e168e8d53df4f320973c2eaeee854fda73dd5d75d608c2a16eeca85af"
