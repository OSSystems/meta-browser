# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3f04296d298167774fd5d8ca31a2dde4"
SRC_URI[sha256sum] = "75dfa6289e1cc5118c0229a298c5d0488d6df1161ec83ee305046838285b6bed"
