# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "f252b5a14ef0f44f87cbd838b55edcd9dc1f3120a1c7fc0cbce300a5308d331e"
