# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bb8cfd5a2e7c7e23d5d045fd4e8f07e7"
SRC_URI[sha256sum] = "66fb2a56edd1891fd6f5bcf0368a8a492ef321fe9e49dec404608ea3cd420d77"
