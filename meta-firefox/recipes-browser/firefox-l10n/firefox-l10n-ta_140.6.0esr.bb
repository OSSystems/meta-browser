# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "de08a74061fb387f7a0a8985fb160e91"
SRC_URI[sha256sum] = "8c370eef715cf7a379517b5f98407385606122f96ac7bde709e8c39c01de19b8"
