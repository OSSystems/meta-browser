# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "abef7fbe436a390865ec74290115c41d"
SRC_URI[sha256sum] = "8d6ef652184a869cb5611af86adef1255dc25a5ef5ee89a9af5abac60f7b83f7"
