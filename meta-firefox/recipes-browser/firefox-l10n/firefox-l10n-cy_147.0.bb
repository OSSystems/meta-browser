# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7b370c0c0b5ec57071519ff4c1b37781"
SRC_URI[sha256sum] = "1d815fe88989c8f28c6855c394c0162d93ba69c636f91494efe71ca65a3a7810"
