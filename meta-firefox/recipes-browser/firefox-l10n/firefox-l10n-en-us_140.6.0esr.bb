# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0baab738674778d8bf76f56f6420e667"
SRC_URI[sha256sum] = "c0e457da1060a7d6fd2b0894abe9a3349e906d0d27246186d6ca245821f78633"
