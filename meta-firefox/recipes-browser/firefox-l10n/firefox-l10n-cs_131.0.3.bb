# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c3b3d8fb53f71056d19037b8aed465a4"
SRC_URI[sha256sum] = "d9482086af4833ea839d564603a60a9d98b44ae335929765e5c47e959cc73f27"
