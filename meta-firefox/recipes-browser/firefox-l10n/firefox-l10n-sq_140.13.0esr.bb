# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "62af4c42c0b66fa154681c746965d2636fae351cfec7f937b5755c10f4b813b0"
