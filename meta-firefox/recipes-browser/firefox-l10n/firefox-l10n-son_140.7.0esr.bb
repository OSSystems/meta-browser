# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eefcddde5f7f362b20301a45b6e8f941"
SRC_URI[sha256sum] = "9dfaacf3ec5996c425cfdc2903fde1a3ad186226a8ef76beff7eee50831badd7"
