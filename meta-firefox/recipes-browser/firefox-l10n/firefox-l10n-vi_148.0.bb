# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3ad3d2cf44cee7c35c86216bbcb38117"
SRC_URI[sha256sum] = "0ec35886643d1408c785cb55899e66cd14b52d8a2addd9808575fe9204beebf5"
