# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f34588f29fcdaf68d252c945b6c82ca7"
SRC_URI[sha256sum] = "d0ae57fcd948e78c3b332ab5965994111a0b2e98cced7954ddc5b496cff9bd79"
