# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "056b5becb805e93c7c4fa51545f08e09"
SRC_URI[sha256sum] = "14a0054f6ae570cf5d95b6f6eec91e57d6968bad1852af95a80e6686136befe4"
