# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ad57a2cd8ff05180955203528f5fd81c"
SRC_URI[sha256sum] = "7546cb165050247900e0d05323b803de5211abd0adc70ea82d07ab6f0564a7c8"
