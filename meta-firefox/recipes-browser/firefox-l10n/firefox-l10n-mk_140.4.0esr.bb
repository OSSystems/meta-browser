# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f7e0063820b796b2ca66c363172583fb"
SRC_URI[sha256sum] = "cd0e95b2882f35bda50529a9ee6e19f47319ebf28a0a7c2cecc7eccd47d8c0be"
