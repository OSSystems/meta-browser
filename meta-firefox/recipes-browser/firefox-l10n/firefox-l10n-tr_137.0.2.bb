# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c9b5a3ef91141d93557f2e3358531958"
SRC_URI[sha256sum] = "82ddc81815a8d781d14938964437f00d12caa26e10f6bf6369754c6772c870bc"
