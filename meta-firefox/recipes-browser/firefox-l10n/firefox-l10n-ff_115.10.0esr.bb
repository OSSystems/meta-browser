# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6a6a4f3f5037a59eb9220d56f0ec2fdc"
SRC_URI[sha256sum] = "b0bdd4b7dbb6929deabd1a4c42525804173788fb53c2118465883466a7d49caf"
