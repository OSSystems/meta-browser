# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "41d0674326c99e7a16b4dac05e28f3dd"
SRC_URI[sha256sum] = "dca594b0a9279390ad8b1ba7627445507bffdd50e7b7796b840a0351f8f29329"
