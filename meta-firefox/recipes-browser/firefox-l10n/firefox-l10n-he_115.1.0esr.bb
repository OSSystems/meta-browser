# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cdafcb69c1b4243b01a624edfbbb4d71"
SRC_URI[sha256sum] = "5d4fab8dce8983bef1b466c2334018f9162a488d1254b5b7966f2d274ef3d159"
