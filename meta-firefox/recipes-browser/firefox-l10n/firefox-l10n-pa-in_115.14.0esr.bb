# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "44fc888e9b4d019fa5ca0564fe1eac8d"
SRC_URI[sha256sum] = "94260187232604e10b2969f27ba26fbd9b1a4b4dcf8bbe8ef3e80271c57410c4"
