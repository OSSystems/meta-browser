# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f207a51685886342449c8d6402f1e622"
SRC_URI[sha256sum] = "a329bef2ab28ddbe01e684529f59764db93b3207aa7c5c1d9b7982c2b92fc4c7"
