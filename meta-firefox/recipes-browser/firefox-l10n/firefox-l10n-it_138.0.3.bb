# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1d220fd72a3bf8eaeacefed5b6b7271d"
SRC_URI[sha256sum] = "a44072db7665cb88b24c025b59838bfbe9635617826e3802095602df81132e06"
