# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "68e02b71e6792ad2ce5326496b7bb6980748a88d964d6021522f0a31c2ebe627"
