# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1b75df236130e89459a0a9f4de2ec385"
SRC_URI[sha256sum] = "dd654308e5491b1306e29626c027aaa74e9baefd5b120def5085630947d7803b"
