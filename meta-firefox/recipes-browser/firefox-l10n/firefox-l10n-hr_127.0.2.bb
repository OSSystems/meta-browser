# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "999aac0381a003530d161b94d9741880"
SRC_URI[sha256sum] = "58be7dc338a57d13758e9f238841d5b8c14eaefdc1d80e796700bf21576a9e35"
