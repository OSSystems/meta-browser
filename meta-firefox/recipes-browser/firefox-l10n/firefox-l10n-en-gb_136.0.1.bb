# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "52a15d3c151565f501f34e3c198843fa"
SRC_URI[sha256sum] = "b1665959908327089be26973b8b14a1793cda92eb149edd61f7e562f4abd7357"
