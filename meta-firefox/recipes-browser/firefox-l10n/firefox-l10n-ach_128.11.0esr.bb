# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "78170a4c806c0bea6c31d88701fa36c5"
SRC_URI[sha256sum] = "292641ad60910d4278eb597e990379abb1ac96f5ae950f4024bf1f95bd85b1af"
