# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "59414e1289a834caf2b02814a4dc1b8f"
SRC_URI[sha256sum] = "a99b1f63ff4f1d4d300ab937ac89e89502ff8a139396a07ff0d199573cc3811f"
