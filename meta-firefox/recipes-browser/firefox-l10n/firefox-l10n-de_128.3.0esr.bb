# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "977d9f754b460945f8393b052adf70ec"
SRC_URI[sha256sum] = "e1cb3e77fe59146b284592e86ea86d0d10d48b4b21ac83d89dd3189b76dd5cdb"
