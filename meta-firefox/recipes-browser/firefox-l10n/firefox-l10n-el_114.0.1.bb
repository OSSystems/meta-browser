# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "364a7c11802c7459150c73c774e66e01"
SRC_URI[sha256sum] = "3e96db3a342b126d8e852dd6a132da8b8490d6735128655cb91cd124855a66a3"
