# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c3c0d64710c54dc50081cbb87214a02"
SRC_URI[sha256sum] = "f5f4dc00488c57e2095dadfb0d3e69c1149cc315158febe14c95bcfc68e4821a"
