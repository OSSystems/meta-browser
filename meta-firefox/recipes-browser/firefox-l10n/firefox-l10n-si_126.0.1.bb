# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d4a390134340f6127933650efc5f7233"
SRC_URI[sha256sum] = "d277b7d69cabf276c1a20cad88042c12ab17a90daac851d8b58c929b05de2929"
