# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "242e2fee06cec1397eb6bf032b63b72f"
SRC_URI[sha256sum] = "86a1a57eacfe6e6b2c37ecb0c9cdd4a62c18fe0cfad69904cd3697d91aa34e04"
