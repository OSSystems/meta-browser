# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0e53a4847bb077ef0734933d80e177b3"
SRC_URI[sha256sum] = "cf21600548f6de1d531e27ca5c1f0811ede23662965e42233a220710e1e4bda7"
