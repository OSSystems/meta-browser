# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "09d2e65dc8b7b1c41bd4d89b6a2dc375"
SRC_URI[sha256sum] = "10158de03dac2c3c264914664d5bae27f904888a8a8ecfd3563b0f18d9363a57"
