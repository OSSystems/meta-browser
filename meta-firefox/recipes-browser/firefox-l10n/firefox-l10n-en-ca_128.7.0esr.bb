# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3a7acb3de80e778e6a56d8d823068128"
SRC_URI[sha256sum] = "3539ede058a8c312168e88f3190262e8efe110db8690afdb29b11abacaf96665"
