# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "63458015ecdda601680fa1937d5181ad"
SRC_URI[sha256sum] = "08785d73f2f5344464676f711f2d42db55ec8308a673f864f1e84443318ae045"
