# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3692a6ff36f4d73c45715f819164be7d"
SRC_URI[sha256sum] = "960dc67b4ade544946b867c4bae90aa201c12b094ee08c1d523b93d33b640163"
