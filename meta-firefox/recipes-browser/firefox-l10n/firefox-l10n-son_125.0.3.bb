# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b9daba96720334cdd5f5ed56c841b81d"
SRC_URI[sha256sum] = "b690bb3b7bed9fc6948502eff6a6bc7ed3b238aa88c033bac2c776602efcf68e"
