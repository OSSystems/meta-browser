# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d88edb77daf9254a57071a9f104c5c973b41c87b40ffa79bd591ca9170377f6c"
