# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "aefb5b16424b6bbf0d7a2fc59aad01ec7f44f32639da8de0c0249ca5412c735c"
