# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b85d406092ecca4ce4e2f7f6522fdabe"
SRC_URI[sha256sum] = "38db9d5747b9fc2fb5c503bbaee0aaff24f268de73cf502267ceda7b2ec0dff8"
