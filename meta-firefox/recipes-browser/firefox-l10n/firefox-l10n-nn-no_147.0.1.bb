# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "19d5d23f3bff7c1c641e6cad09a63724"
SRC_URI[sha256sum] = "a723f606201e0d68486cf8f14df926d6a27b1689fb251691ada6735a95b95ff8"
