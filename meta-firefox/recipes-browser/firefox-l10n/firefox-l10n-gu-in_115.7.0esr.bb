# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bec8fb416bc89b8ef58cda7e5ad1b4a2"
SRC_URI[sha256sum] = "2bb8abe69e7b3f918966561a17e474c30f88306c352e6e743e69238868ce6b39"
