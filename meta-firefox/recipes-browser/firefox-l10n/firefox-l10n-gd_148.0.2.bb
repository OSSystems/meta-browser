# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ff54574320f65c28833192284e3dd3cd"
SRC_URI[sha256sum] = "7f9a118863d1d50fe26d565c8e969cc31014d8118fada264e817b171c19c1c4a"
