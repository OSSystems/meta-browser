# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "20a9e18110f8d72024914ae2718770f3f1f7d35a6a5697c5e53d2c060627d3bb"
