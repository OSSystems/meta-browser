# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f24f5ad6a4bb3d3900bfacd48ab6c8c5"
SRC_URI[sha256sum] = "8c2cbfd05cb982bd06d1740f7243d7f070ac3865d40b8988d6b5baa2171a1f72"
