# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "48800d0cca496fa6b0877ed469da403d"
SRC_URI[sha256sum] = "52ce5aebc3033448ae0be21d9be60c2f9d25180a5e7d8e5f5b9b5fcb2aec686a"
