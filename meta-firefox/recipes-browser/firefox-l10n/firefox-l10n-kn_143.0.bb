# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3418de4b5ee07d2e6bec4d74c7a4d419"
SRC_URI[sha256sum] = "909af22bcc6178df66fcfc401f2ebef7e4f8d5d48b2682343eb48827a9246c4c"
