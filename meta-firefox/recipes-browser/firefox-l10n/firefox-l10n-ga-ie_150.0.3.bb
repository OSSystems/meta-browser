# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "6e2cd1f00a5644f38731c95e06ed45c4302350a060ef6cb070c29002ed2a3cf4"
