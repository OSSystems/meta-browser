# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "38379f4b281229be09cf60c814dbde3d"
SRC_URI[sha256sum] = "6265402046a063bc21210778b172b2cf5d45c32776d8b70274ef7ee2129c66e1"
