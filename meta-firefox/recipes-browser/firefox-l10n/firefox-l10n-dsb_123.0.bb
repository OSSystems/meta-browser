# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "94ea229f3ff431d92ec4b8926c879e94"
SRC_URI[sha256sum] = "c72bcb83fe502fdd686dacfea2e3d335a04b6bb515859fbd46c6f39ae4eb98b7"
