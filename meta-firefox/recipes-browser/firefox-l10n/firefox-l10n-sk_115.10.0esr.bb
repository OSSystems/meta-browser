# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "20194ccee5b360a77e06f5102fb04006"
SRC_URI[sha256sum] = "d9e43874ddfe9fa7eec84c76d1ff9f4be4c1d99c03ccaa8571118083ed911a92"
