# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7c9800d3b2d23a9117b35f7d223c7ff5"
SRC_URI[sha256sum] = "07f000e394d579fa02a1d4ed670ad107415e103a120cef503320193be3bec055"
