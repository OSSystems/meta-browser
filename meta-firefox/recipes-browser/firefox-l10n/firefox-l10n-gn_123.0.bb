# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6ac018d1c7fb96776609f334e3191ace"
SRC_URI[sha256sum] = "377dca9b919987bf14bd1ace28d4b16eb2db9b89a55f1b012dca19507e5e8f1b"
