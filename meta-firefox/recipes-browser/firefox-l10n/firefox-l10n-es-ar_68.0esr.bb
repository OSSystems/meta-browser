# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "00ee177d425bcb743279278cf94e2742"
SRC_URI[sha256sum] = "0875aab1e4c85817de0defbcdd20764ed6bbbe085ab607ccebf2e9d0c1f6f074"
