# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b71a5dd49e49e8c4e20a797a6f7d8cbb"
SRC_URI[sha256sum] = "5757ba49ed3106284dd0a0f42a315330c52918d813ac5780d0ca2a490ca1c193"
