# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "b851fe6687ae91cc0923aa4cf16865c5bc09adb8b80b633c0593d84d0a83c1ee"
