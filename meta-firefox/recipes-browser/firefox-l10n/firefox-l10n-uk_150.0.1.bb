# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "54f880d518f8de426eec80a01d8bd33fb3e5e202385daef9f54e55086609c629"
