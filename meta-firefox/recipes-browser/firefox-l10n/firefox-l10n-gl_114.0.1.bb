# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1379175fc0abe481ad84ad83d9afc4a4"
SRC_URI[sha256sum] = "64a90f907c739d2936a37e8cb56baf0cf7e5f847bd43fdfd4ddb5f97a90bb212"
