# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5c153345b914fafbf8145899f52cb88b"
SRC_URI[sha256sum] = "e23515afa7b8f7d2bbf831d2f2dc7ac5a8559b30960efc1e55321cacfd8e6e8f"
