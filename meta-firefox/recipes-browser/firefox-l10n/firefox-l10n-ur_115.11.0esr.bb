# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "78639f160ab7235b0186db6547284747"
SRC_URI[sha256sum] = "a829b2ee9aa28ab5cc703ce305faf3e5c0b9082f508d901e2de3059a4d4072fa"
