# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c7bc4ffdbe65c29e15313c99a4a635cc"
SRC_URI[sha256sum] = "4aba22b5661b7c5a1f517002115e38a58f6aa80c09247e6e041e110032fc4f65"
