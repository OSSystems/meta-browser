# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d6bb01ee1fc961f9382c0c3676541b50"
SRC_URI[sha256sum] = "78ee323517a2007d953b540868301d57df3a16ce04d4323da70baf9db1d353c2"
