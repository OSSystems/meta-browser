# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1eaa3738ad7cd60cf763f0c4672f6ab7"
SRC_URI[sha256sum] = "55394000fa70c500a9c81c06c0caf0814a0da2b5cdc78988f9f73caa1d00d934"
