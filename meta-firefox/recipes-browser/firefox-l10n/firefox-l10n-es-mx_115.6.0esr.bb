# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c7cdd1e0ab52b89152528bfbd4798c88"
SRC_URI[sha256sum] = "2160337cc9cd8217e3fae49396ce0fe0c09f9349fe130f7acda1103e852eaf89"
