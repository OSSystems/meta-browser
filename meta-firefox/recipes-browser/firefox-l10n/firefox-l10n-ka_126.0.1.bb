# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8b668457c2b58fdb8b456e0861afd02f"
SRC_URI[sha256sum] = "0c043db20cc9e5a3b3d2e36069cc858ef76f15b8f0553cf35321ef51e2517e20"
