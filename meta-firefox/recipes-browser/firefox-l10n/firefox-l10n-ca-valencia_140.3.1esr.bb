# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7eaf851a812a2b317d75183f21c1df55"
SRC_URI[sha256sum] = "e68093054245d2235500c93f9887a65572f0d766c997a2722db83846c298d532"
