# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6a7b128cfc3ce732ecd82b11fc4f6874"
SRC_URI[sha256sum] = "61076e11713415dc4966e0c079b9c17787c2c5d533c8d3478fb7cedf29a612ce"
