# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6677b18c607af80a36f5dfa24ca8e8cb"
SRC_URI[sha256sum] = "ca59e76b6f0db1d847f98130363e3d37e96f4d7b2d03485bcb811849d89d14a1"
