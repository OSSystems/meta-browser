# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ffdc21907be4367b7fd8a3627d4e7970"
SRC_URI[sha256sum] = "0bfb21f5943b23b72075ef2d497b8588c061b0b8e684de6f8b8b5f5e9dba35f1"
