# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "55a2b04f4fa497de4be25413258e1b43"
SRC_URI[sha256sum] = "67790768b1d104d6764d276b289c23ae339e4e3b1ed7f38a028bfa7baf8ca3de"
