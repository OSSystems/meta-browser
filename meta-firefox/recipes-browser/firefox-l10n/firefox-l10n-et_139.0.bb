# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e5b910464fbb86840101e351cfe2463b"
SRC_URI[sha256sum] = "4d50011114c5c2627ae6956fb1071e3ce067fa325da5228ce68ed92ebefa3516"
