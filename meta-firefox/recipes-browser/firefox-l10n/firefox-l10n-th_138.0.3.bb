# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "49433311397bb7607263519a8c098c5f"
SRC_URI[sha256sum] = "48891cc4ae95e9a4d7966b5007b02861f544c66a34702ea24f3fdd5fa7868681"
