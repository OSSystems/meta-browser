# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aa211f80b68f96da8e2964f018d453fa"
SRC_URI[sha256sum] = "b03b059f25e4427f48c19edc68bc6f5b2c6712ff3460ecef7968eb897f1b8222"
