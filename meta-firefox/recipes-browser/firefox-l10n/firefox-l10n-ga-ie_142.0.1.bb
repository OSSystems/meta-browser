# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "904890435acffc0176cebd034c090a57"
SRC_URI[sha256sum] = "3a6cd9a34531e60ca79e62b2cbf4c8c69012e75ec968be24a6e3f5e68559b116"
