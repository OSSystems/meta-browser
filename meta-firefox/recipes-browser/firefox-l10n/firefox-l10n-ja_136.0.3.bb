# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7c58ee1b9e2147cf3d0a7d1570f4596d"
SRC_URI[sha256sum] = "2a2c5e96ead29d0def15c216b313684d2a8fcd603d4cde8f655f16cb59010bde"
