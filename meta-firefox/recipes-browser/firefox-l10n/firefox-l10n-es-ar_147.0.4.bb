# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fa6e90880973c1153effcfbb37e6a91d"
SRC_URI[sha256sum] = "dff67e7b4aa41d775dd577b5cf58fd97c4be9b45e2e46123533bf333f84aa438"
