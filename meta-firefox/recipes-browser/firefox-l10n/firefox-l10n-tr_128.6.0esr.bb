# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8f5e248a53acad656888e70a91e2c744"
SRC_URI[sha256sum] = "699930f9f4300e85316af4cf32327ab4e47083823ca2ac14a72565da84e34d9c"
