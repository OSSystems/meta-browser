# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f3d65d885880d1ce02438210c4a78f22"
SRC_URI[sha256sum] = "e28a0b675124cbc5b3b3c95d81f059a1ce3f5152817623f3d973ecc805b07b60"
