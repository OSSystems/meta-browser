# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "518b0526c3232455c23a5a72c5e3cb84"
SRC_URI[sha256sum] = "aa1222ecfdb71956f34ccc6e70054a943cd6b5ddd3232c9c346c6fefdc7590e7"
