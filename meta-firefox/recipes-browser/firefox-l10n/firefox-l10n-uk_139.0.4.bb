# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fd6cd0449bb92ef930e6e217a8f2da56"
SRC_URI[sha256sum] = "8eef9f5bc63a278e1af070c775b8f2e6d53be51edfe006424ebfdb883066d856"
