# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ab190b387708da3e6178d8f967a81a99"
SRC_URI[sha256sum] = "feb92526759084d8c061e4f6c7030d8397661b43301dbd7b4e097f424722bbb1"
