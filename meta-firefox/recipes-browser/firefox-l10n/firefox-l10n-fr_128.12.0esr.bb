# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2212c4ed0da28c5606f03ef2f36a6026"
SRC_URI[sha256sum] = "8eabadfe79dd8fdee5d6ba3e29d5c543b1cfee9c534f4d8166adffd4fcca5054"
