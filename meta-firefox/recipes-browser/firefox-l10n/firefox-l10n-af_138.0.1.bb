# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "13e57efdba3e2ca0c046a1f80a70ffa3"
SRC_URI[sha256sum] = "ea6f4e8f6274f62fbcbad7a4590904cdd940975cdb24961d009035931a31d5de"
