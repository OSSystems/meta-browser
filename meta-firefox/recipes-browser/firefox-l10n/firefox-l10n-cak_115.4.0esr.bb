# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "64a67dbf6e9e43a955fe9664a5d5c0df"
SRC_URI[sha256sum] = "dbf0f0b65d02dbc80aa8714ca41374ef10373163bb4b8d2f99574f0cd56c4036"
