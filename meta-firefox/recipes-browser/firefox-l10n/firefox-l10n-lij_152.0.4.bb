# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "0f1fb1cb259e0b4d889d620f1c23e601d6af0b5dc10685b54ae26bf53a833607"
