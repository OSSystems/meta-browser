# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1674baf3e292285280dd5afcd019ed31"
SRC_URI[sha256sum] = "dedfdacb5746da0e41ed9324b0dc280b600e1541a4e123cfc06ccc163ead2dd1"
