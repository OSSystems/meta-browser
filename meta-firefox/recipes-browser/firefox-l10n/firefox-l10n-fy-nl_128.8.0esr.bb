# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "61b9d54cc2399d67dc4ed28591be3bd1"
SRC_URI[sha256sum] = "aa86cb827cbb302e4e29abfb9d61a359f54c928c40a3bdf0ecf7b9fda5e4bbac"
