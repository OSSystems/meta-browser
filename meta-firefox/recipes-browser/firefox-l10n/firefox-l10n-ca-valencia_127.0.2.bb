# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b36bde95a5064fd232201e9b88868e29"
SRC_URI[sha256sum] = "f841b1bd1e5dc35147a81c1cb918a2613cb6f0b9cc969b1e0d1ae9a7a48d1c65"
