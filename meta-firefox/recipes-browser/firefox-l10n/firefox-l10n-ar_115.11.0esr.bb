# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f89d8dd98206c29a1ed3672f471f7d0a"
SRC_URI[sha256sum] = "caf1d0d0ad86efcff4f4032342dbe31d2268227df87bcfb8f306dcd4b7bd01ce"
