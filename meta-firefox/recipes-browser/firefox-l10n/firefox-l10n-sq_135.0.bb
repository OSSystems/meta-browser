# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "17e9e869181a545c27ad740cd4e43380"
SRC_URI[sha256sum] = "8c8d8eade2bee44ce34b469c962d85a17fc806b0ef9c4b2dd71fbb019886c641"
