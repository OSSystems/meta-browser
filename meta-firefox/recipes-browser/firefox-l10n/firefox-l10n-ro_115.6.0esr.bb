# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7b12c5ad93815692a68471dd209c61e7"
SRC_URI[sha256sum] = "68b3e94c9b395e27a0ddea6c6eb1c2318c041646f7652b3109b7c7e41187f14e"
