# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eacdb76224a6821d7cadf71b2dde770d"
SRC_URI[sha256sum] = "78e353f1db4e925b13e66d81419c7806c9164cd5647141f87385b9a660a483a5"
