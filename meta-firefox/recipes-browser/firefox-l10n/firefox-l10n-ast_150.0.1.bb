# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "302909149dee7fe5f76968b872d7641c2035b4ba34d3c557113910b149fa2a9d"
