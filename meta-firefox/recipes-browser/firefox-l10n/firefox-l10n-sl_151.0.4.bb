# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "29d7406d3637a4cde99cb0a68a121b709776c2abd2a3d78b623481f0ef869783"
