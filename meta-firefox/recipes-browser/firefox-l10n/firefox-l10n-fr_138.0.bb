# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "33a6f465e3d189660e0994550cca72e5"
SRC_URI[sha256sum] = "bd69ae241bc5118329807d455e9f385985052799b757e24606eb16012ef0905f"
