# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8ddbb79b418a65ca4ea3381926ae5774"
SRC_URI[sha256sum] = "db8cf4504dc8ab0740cb15b3bdc2f812aa868395554a8d10069cffa0ac3802ea"
