# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f8a519b2df3bf46a917c5b3c67c11ee5"
SRC_URI[sha256sum] = "2a3552fae77c5da873091f275e41bfe588b384048e85c596f0a3dcc63ad91398"
