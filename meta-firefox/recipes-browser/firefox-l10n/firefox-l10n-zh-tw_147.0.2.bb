# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "28bde917ca3576e279bf681e80363efc"
SRC_URI[sha256sum] = "b26eb2f3e260077b7b431eb56ffce7bb193a3162410fd9c8f0855ad1791e7040"
