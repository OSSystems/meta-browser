# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ba6cda89f1bb9d444082f413b1b03f8"
SRC_URI[sha256sum] = "8112386051028bdd8386619de967d4a885e9804538293330facb8525ff3dc39b"
