# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b8e725f0795e647f7b22fc145233d3dc"
SRC_URI[sha256sum] = "ca58130cecda1fed26746de37167d39827b8b834913e986afd395abca65e02d0"
