# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3b1f6aecb93af0e955c80b7dfce14e5c"
SRC_URI[sha256sum] = "2c6872b4a1821d72f44b49a519f80f263bd440fd96433bf04f8166ccf7781979"
