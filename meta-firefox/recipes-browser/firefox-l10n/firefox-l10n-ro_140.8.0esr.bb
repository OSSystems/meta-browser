# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "543a82e8fab0b14700d271bba02a5559"
SRC_URI[sha256sum] = "e390a28603f4b6a9e969c34bf6d0b7cb66fb3715e9e225e97ec74c954d83044c"
