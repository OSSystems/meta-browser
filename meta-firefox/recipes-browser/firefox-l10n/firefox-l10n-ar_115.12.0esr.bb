# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a347f15380e93c769f43c862a51cdd20"
SRC_URI[sha256sum] = "38bcdd6875fb37f2115c0bba5cfc9a90edf82edfe0e26cb157160efa611f4180"
