# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ac63eccf4ddd2e97f78b2c8b3689299e"
SRC_URI[sha256sum] = "8f11447dbb1d559bef94a602fc13662e66427215aca1422c7cd25b7061fadb85"
