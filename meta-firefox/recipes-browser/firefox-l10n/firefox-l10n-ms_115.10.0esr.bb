# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e172d3df57b809a21ce58445de76ba18"
SRC_URI[sha256sum] = "db542f74160ab0b0715a4ff0a8cc4a8148ee57600af48b5f475177ee56ee764b"
