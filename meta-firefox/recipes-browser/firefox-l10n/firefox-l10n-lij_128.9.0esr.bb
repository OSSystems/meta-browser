# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c1c13af354f833603412d8f16c4212ea"
SRC_URI[sha256sum] = "c973fce75105f411f325d3f50449c2f16988b6ecb7ab524d7cd11a1c3105fbfe"
