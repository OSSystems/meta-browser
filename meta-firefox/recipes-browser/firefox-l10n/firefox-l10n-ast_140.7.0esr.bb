# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c29ea118c5df347ace919ae7841f7a72"
SRC_URI[sha256sum] = "3799678854ab42cfc2c491077d482eadb50c5c6d99afe31c84cd185f6239ab7e"
