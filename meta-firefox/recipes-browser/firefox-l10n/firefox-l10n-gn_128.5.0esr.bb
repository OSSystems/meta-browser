# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "67b9d09acbe3af511e7cfbfee99d6736"
SRC_URI[sha256sum] = "10a17e4ff3fee2f281f6d606db0a886e8ed46c06e5f33ed8a97e72a949283a40"
