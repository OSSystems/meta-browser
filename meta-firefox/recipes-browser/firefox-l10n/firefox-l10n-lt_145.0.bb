# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "89589ae0cad2e6269c1ee4b8a231399f"
SRC_URI[sha256sum] = "ecd89b67f92814b2bf872e1e755acb554bc0e5fd3f2f35b266508e60cfb552e6"
