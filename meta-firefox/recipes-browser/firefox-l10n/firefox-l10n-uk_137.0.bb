# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b254d2d9024aa6e3e946ce6e9641d648"
SRC_URI[sha256sum] = "11b1b54d7851057364177d210db54048a2835b42a75ebdb2d430e69df677edcd"
