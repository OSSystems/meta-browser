# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "411d36e853cc87a5c5428f2524c7f3e1"
SRC_URI[sha256sum] = "deb26c1ac5e367bdcf5245860f3c2e025aa15f1096ca27b5f82af13f3087ca7e"
