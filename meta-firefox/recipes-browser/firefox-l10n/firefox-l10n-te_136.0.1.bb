# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "025e14a35fa7147b3594096c786d70e7"
SRC_URI[sha256sum] = "ffcfe6ec52f245cf66f09770ba9a8d3362288d318015a6b1c27ca3945c6005b7"
