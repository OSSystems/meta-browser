# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "80fc65b1ff607805efb8c060d530e217"
SRC_URI[sha256sum] = "27bb11bff3ae791b29117039eab45cf94fc034c1f850f04506399d2afcfcb2a1"
