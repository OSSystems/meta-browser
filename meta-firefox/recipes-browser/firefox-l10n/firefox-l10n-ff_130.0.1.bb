# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "10a39f0e547a56fc06f942e2d6a55bc4"
SRC_URI[sha256sum] = "0455852cdb31df882d7ac218b68fd582222790b69a56fd6580517d1a2cab4184"
