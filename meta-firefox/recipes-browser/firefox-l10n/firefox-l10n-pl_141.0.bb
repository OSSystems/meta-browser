# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3d9d487e24434153a38cd429e76d6710"
SRC_URI[sha256sum] = "bdbf9d9d4d9d985134e24457f7c1ed140db8b7ab1d5a9e394cd47ad9781383f8"
