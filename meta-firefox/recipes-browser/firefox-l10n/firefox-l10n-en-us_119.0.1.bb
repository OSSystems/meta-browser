# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5ca2edb0d641ae4c4b101789ba53c7bd"
SRC_URI[sha256sum] = "d1bbde7e9be720d62eb972630b87007d0d897eb3ab2fb920464fa365fbd271bf"
