# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "112ccd7f19b1a0737f2ac629ea9fc2be"
SRC_URI[sha256sum] = "65e4371294ccbd694ccb0dc805cb503edcd8f9799c56d823ac09a738bbdfe645"
