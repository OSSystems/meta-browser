# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "29741545a45891c72ebd6bfd935daaeb"
SRC_URI[sha256sum] = "70cba4225941c6c19c97e01258784d05c5e318977773de3cc0626a4050b7e474"
