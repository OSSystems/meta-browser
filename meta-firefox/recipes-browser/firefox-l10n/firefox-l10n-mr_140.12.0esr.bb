# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "76898c35f7b97552a1a3a48549fee8a583233d10fc5aeae368f5a19b56218d19"
