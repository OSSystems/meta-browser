# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "00acc021114fe076754f201f18fcc332"
SRC_URI[sha256sum] = "593bb4e026d021d2b1b79f5165c404b20f0225f80fe8210d1f5ee33945162a98"
