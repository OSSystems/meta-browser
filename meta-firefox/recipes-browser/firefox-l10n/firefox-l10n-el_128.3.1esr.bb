# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "baf624a71c61dd5a37ae625e5cbc028d"
SRC_URI[sha256sum] = "d86b96d12cc0061995ea5ee9ca878d562103223ee8263362762c96b38c131978"
