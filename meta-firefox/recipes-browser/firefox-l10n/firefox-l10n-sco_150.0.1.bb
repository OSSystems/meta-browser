# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "5a3f6eeb480b236f5ec05e6473373ed1b201981744c0d27b8fc571b5f3bda015"
