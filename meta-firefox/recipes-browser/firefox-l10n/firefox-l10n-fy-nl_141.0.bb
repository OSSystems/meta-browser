# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "79b3b6aa16c9fbc3926153bd74bdd2ad"
SRC_URI[sha256sum] = "6f5547a052bf0f68a2837a1fffaf5e2a0c616f639ee638cdc45911c05dee6cd8"
