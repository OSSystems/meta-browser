# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "390623efa0e87a79e39dcff8dc725c3b"
SRC_URI[sha256sum] = "6f39f748d371a7032c226d6b2321bc0d0ceb4748896095c330233d7359300321"
