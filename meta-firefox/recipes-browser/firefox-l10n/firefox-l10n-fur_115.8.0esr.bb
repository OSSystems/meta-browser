# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db3aea7f17912df7050dacff1f861dc4"
SRC_URI[sha256sum] = "8e821346c5fd2be3fdbf2eab50141c2c1a4780011b221001874203bbc364dcd7"
