# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "edb1a535881572ed86bb5631b9f0074a"
SRC_URI[sha256sum] = "837a0bb65d1a1732743058dcb53e007e1d77cb539dd98258ab951391f144e5e4"
