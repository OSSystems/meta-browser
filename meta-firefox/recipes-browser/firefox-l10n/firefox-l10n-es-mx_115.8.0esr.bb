# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9290d46de1cec6a54a46a569c722d66c"
SRC_URI[sha256sum] = "47ac0af872778884936e3c41901f9c424156b3279fa024d291a9eca219d3fcfa"
