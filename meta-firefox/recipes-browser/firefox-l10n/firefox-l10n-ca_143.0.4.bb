# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3ee5f7392fadb318f31ff11c8590e495"
SRC_URI[sha256sum] = "cf4ea0108b6f04924abbad9c65b5304ebd97ab19cf6715a2f66725c8d63f00d8"
