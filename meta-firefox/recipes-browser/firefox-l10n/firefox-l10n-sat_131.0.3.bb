# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "50e1ce9179ec96a1a24197d9ba4dc2a2"
SRC_URI[sha256sum] = "3e3ebf44572b4dfc11dad0ff02dda8a2beafd6c800fc64b617292b4ce3abbefa"
