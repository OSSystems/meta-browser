# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d41b78e5bc94b17672b3b54b27077a12"
SRC_URI[sha256sum] = "97d8b55b1d91fc6e75c3af4c556dca477980b6d551b70ca23e3ce30f09666805"
