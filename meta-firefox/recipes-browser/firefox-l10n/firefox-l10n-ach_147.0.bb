# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b0b7092fb291d8de5397065cc1f8d6e0"
SRC_URI[sha256sum] = "03a5bf8305749c5caaebd1fa5628076e0016f57c45029487bcf0120aca5e0fe8"
