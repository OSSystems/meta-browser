# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "906f01c15bba11c53189a716220ebc61"
SRC_URI[sha256sum] = "7180f0e9397285b919000e3d7b8f498758ceb407004e68f919b5950ef4f8dd4e"
