# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3b021d58e2162f5809cbf0515fdb61d8"
SRC_URI[sha256sum] = "bb19a3a91a043706bc31d808201ab77b900e868a0c58a44a65a3c2ebbb1ebd22"
