# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8daffc97fd9a75d55630d6780fd17b0a"
SRC_URI[sha256sum] = "41ed129f800c98f15e510ddb64decdcccade72a5b6e211cafc6145cbc33730e4"
