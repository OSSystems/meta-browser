# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "958a0491ea606101324077b5a1fe41ecc80dc56d2341f34fe64d33645230ff09"
