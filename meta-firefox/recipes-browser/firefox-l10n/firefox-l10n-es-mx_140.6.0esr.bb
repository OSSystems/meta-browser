# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "56c9b78bfd4c568086908f9497c28205"
SRC_URI[sha256sum] = "c6ee412865f67d93e6fef9d058995367fce5bf39b138227709685d6c5548fec2"
