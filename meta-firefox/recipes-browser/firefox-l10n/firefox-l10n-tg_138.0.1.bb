# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "58d3638a2a5c8fa3ad4800735d181be3"
SRC_URI[sha256sum] = "ef0f5dc6e9f24e79030d4c45829972b69eaa3e569b73c506e78b06628f5f46ef"
