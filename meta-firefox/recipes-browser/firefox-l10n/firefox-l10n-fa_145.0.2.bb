# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3ba1679cad5d7fc8ff77e06218cd896c"
SRC_URI[sha256sum] = "6d4aa200f4a23f3391f19c006070a8ca3681fc08d94d69e94c7aefb0b36d3650"
