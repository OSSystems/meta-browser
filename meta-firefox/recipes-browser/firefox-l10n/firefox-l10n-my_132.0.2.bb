# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "312066fbde3616f4e484d6b4a2d49455"
SRC_URI[sha256sum] = "d21a38b7a71b559473374c3c5a1a1acd9c78a0c9b978f3d047fe63601c5e3a68"
