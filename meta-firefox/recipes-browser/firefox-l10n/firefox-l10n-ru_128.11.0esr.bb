# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "725c9a284c91478a34aff7317e141129"
SRC_URI[sha256sum] = "822db92c581537f3571f87fa91fb35f8fb0c8ec43f296f13c2006f774f02782d"
