# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "24cb5ce275fab2a6568ee819cd03439b83f02379cad35a01f5cc61d323be0a9c"
