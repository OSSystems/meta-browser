# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b5059feacf358660407ad2cefe26bf04"
SRC_URI[sha256sum] = "278f9a9ad1b2848c75a6be9aae73847fc0c5d0065072fb6dd0f503517c11fad6"
