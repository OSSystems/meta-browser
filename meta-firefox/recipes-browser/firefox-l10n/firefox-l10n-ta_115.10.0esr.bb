# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e75c75f8f85f29d09466723ed6a7d3fd"
SRC_URI[sha256sum] = "3f3b63a7700b9fbb5114353beb14dc7d89b89348f1b1ed8fea793c0ffc9b3781"
