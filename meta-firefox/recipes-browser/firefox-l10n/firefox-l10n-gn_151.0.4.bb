# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "516d630676eb35a40df2ef5af3fd7f617aab7f34930cf90bfd254961827fee11"
