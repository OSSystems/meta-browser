# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0b9ab2eca384ca9ff34a0c24f9cde8b1"
SRC_URI[sha256sum] = "5517e645fc43726b2e155ef8b7e18ede607e6d4d0f68b5e280e005fcf27e39f3"
