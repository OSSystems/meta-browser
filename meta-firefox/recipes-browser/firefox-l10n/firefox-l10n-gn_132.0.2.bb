# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f41a68b1e5e184937c490da26fc6d13e"
SRC_URI[sha256sum] = "8815c7fb38d57c1f388ea7ce8a76adbc0963f4ad25c89a88a7065117c198bfbf"
