# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7623eaeb4eb7835a85c86f4354b3ab88"
SRC_URI[sha256sum] = "5e95ce440ad018b20dffd8397b295b97b25ae8d9ca548471ea78f222fc71241f"
