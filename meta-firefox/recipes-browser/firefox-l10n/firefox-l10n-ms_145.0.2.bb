# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6b6fa1cf35c4c1534ce2a7acfcc590f3"
SRC_URI[sha256sum] = "1b0045ba781eb6a52d6cce0f021981899a5dbdd19931e8cf81284379a99afdae"
