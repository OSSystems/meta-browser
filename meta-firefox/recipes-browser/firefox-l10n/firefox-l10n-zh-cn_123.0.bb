# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ffb7adfcd72b6336975a382f5ec6d881"
SRC_URI[sha256sum] = "e0575d3126b88f41b8a99e172d6195e2068788bcda0d4940f1e776c5f4da2247"
