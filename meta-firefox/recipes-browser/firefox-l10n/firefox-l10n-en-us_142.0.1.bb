# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "733cffb8f743f9153761969856726a15"
SRC_URI[sha256sum] = "efec5a3ab439c6355e185c7ad0d65492bf7c095eb99b47793df18572c62ed742"
