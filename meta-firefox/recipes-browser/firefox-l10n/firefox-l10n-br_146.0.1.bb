# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4f7137b5fb89360e8dd686310f2ca1ed"
SRC_URI[sha256sum] = "9c860b73b24e2009feaefcdf828df7b5dcf9691cb46ce2d20285a618062fbe89"
