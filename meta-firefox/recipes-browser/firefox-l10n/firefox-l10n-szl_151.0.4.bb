# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d8e2288061252ef958f4d35942b0a8b088373a6b74d7489448e1eb0eac5ccaba"
