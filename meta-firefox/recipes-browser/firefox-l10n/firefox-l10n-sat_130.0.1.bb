# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c236642dbab153f50c36575ce1973650"
SRC_URI[sha256sum] = "50072be14d197c07fa43c0cca509529aef2649cf80fc65765b47c4071944c7ab"
