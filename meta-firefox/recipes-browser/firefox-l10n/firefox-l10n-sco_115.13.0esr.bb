# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f2c0446ccc701051d8b05f760b0b6de5"
SRC_URI[sha256sum] = "5cb6216feb723fd05ca3cff22a68556825c68f21b3aad39b39f869550ba72270"
