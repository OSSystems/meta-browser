# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "57b427a830f7911dfa1ebcc1dc4bfddd"
SRC_URI[sha256sum] = "b2829734efd0b6f7abfa122e80b301aeaeeaa6eb58b271f830589665feb1829d"
