# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2022b9d9813dd692c42279b360bf3a1e"
SRC_URI[sha256sum] = "a9e2f4acda82f198db5ea4173b7724cf86827f05c5a5ce41ed5328069d5c9f80"
