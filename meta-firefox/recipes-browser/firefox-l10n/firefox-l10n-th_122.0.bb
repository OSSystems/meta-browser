# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5aac5355cc44f0c03936ac5f00cf716b"
SRC_URI[sha256sum] = "ec1be579658fbd36fdbf162948e3d3e5b5294dcd5b0c6e30f940bbae609e10b8"
