# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "253ec2e0c8760ac8c13dc18e30eefe88"
SRC_URI[sha256sum] = "5af631e87f3ecb0734f4fd0b8dda7fdf03c1aa0ef6d49008370961e7cf6f5793"
