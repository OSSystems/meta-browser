# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2355db8b2143d556ac32927bf54e97c92bc1056beede0f592275c4b240919eda"
