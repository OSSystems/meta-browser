# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "04ce7d5f0f60113d57ea6968b17f8532"
SRC_URI[sha256sum] = "52b766568cfa7b2f16922c44b877baacad5535dbf4a529d03febd3bb334434fa"
