# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a19cd20dd16ca41d713eb6e20e60a40a"
SRC_URI[sha256sum] = "c4f774dc526491404bc81618f9580e8fb6844bc703cd3e79fe84da60eae52904"
