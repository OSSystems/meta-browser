# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5f4d8b552e44aa7ca05b5008f4cd6b1f"
SRC_URI[sha256sum] = "8f8a47cf1f00f281ad8415e2be1150026c20399b422992d451221e74cee732d1"
