# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3c8f8b7ee14e4c1f3275ff761ebcf1e5"
SRC_URI[sha256sum] = "ad39dd31340affa896f5d942842e1b7e6bd1d4303a3e012bfdea3fb4d8663e27"
