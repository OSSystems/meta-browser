# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6cddfe0741ea2be02ca2beb66c0982d1"
SRC_URI[sha256sum] = "bc168c8066ff09c1eec169df498d49ae713f59573e9dfe91b6032f23f5a91036"
