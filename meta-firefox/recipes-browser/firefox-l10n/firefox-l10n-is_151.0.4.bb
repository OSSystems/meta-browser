# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "263daabd676ea27a5714fedf72e81449fb739415d2e5f8b01788503bf2c2f9a1"
