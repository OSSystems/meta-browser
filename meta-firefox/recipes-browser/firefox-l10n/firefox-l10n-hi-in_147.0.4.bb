# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "426b7cc7f016e921e7a5cf3987bc7274"
SRC_URI[sha256sum] = "ac29352b52aea01f77f8cbf52ca1dbfa76cdf2a12b7553f47b40295d3fdde5e0"
