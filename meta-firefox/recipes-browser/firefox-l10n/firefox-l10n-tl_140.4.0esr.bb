# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c5ee8a7102da69aef433fd1665e592fb"
SRC_URI[sha256sum] = "5d22aebdb69e37748bed7ae309a7d9a917204e4c1fae22101b71293d6b747a89"
