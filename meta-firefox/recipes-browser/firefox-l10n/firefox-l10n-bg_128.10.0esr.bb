# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e7fb92bbb14549e517eeaef93c1d3439"
SRC_URI[sha256sum] = "d1c2758e724df9a4e3165ee4ccdc50acd1431ebe7433665bdf8ab3356dbd6401"
