# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8d14d442e1c93836de955e02975928f1"
SRC_URI[sha256sum] = "5e0414df41c6602a32fca09ee4a2dade81ac32b65a7e6084ec099b0b4573e114"
