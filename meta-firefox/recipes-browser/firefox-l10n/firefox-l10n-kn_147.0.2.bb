# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a80288b969755058f3e2ed0905d621a8"
SRC_URI[sha256sum] = "3ab8d5dbe6cd8c9755f3a64f23901486c2eded2f1b2bd9e5baf72e23c8e2f1f3"
