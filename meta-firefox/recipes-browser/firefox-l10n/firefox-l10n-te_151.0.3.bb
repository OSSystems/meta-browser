# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7cfbd36925b6563a4a21e362254c6b46f697be7c057c7378b8eb8f8d1179be57"
