# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "da1c864c3ff33560d49f7dbba9667b3b"
SRC_URI[sha256sum] = "0584b7c27a7149ab15f4fac6400770916715ec30979e13aab99c6cd1027b59fc"
