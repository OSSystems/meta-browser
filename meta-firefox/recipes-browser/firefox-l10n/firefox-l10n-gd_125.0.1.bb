# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5c8995a31b4cdd1197047bbc078bdc13"
SRC_URI[sha256sum] = "3f1bd5cbb0f4a628a0f8b97b11fdff3a3e220d15949adaf7c7892e876af184bd"
