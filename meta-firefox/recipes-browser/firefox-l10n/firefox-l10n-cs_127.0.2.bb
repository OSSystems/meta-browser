# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c57580b1450a948caf0e5b65e9656bc7"
SRC_URI[sha256sum] = "94335a0b31be95026da55fd21359061e50f43914e642913a748025936aa8c524"
