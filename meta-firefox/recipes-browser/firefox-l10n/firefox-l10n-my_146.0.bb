# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e8d6d35d66ac2acefa0e533ed55243d1"
SRC_URI[sha256sum] = "efee6096589f472c0b45a565790e75c79f92f2e1d43c0d8e5527bbe50bc30f2f"
