# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7625c04579365e282b80f536d299a678"
SRC_URI[sha256sum] = "6cc06fe4d3555a26cc171999c3d31b468a3e10ed58404ebf41faace192b203e6"
