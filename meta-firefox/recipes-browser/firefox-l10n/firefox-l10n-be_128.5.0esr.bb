# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e1c9acb9f9a030e0e3d8729d27d57759"
SRC_URI[sha256sum] = "0a1e6f9f58587070a8d2ca795e1d011d82175e83e6c543686821be8668e39241"
