# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8aa5954b1de40672e646d15703de4804"
SRC_URI[sha256sum] = "3d8832950f8bb083ee53c4af3ee2546eadb1393cd3c677a1482afdac077415e2"
