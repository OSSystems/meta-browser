# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "efe80980f755f6fd1f40809c6ded942d"
SRC_URI[sha256sum] = "3ac83a0d01a5557fbc078be66ed98332b02846d6ad929e020677eb0ec73fc1d2"
