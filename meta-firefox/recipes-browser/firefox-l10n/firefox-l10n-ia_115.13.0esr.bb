# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9f370de846368114800300915af785c1"
SRC_URI[sha256sum] = "68a88903ae98bfc412d2d554d1376fd2a9a02e479aea1984aa2a8d9ada2d9ee2"
