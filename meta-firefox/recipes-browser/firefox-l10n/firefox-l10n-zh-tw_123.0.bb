# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "82939777ad9404b667d9d5be35bc2f65"
SRC_URI[sha256sum] = "c0d4d8aa7273d02f1a3efeffd0081ebd63d8510e3204e7d71933d8ac6b318a53"
