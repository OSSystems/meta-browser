# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a3ee761ba2399495f5a3877a1fb55cdc"
SRC_URI[sha256sum] = "3614b37edfecd94d1ae7d66a77de44960b28b5d979fa33282247ed5c399cd334"
