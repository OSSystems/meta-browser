# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5aa0339a385f2a9752a0bd69b4e0eb3d"
SRC_URI[sha256sum] = "72762743d55ca068da2756ca92b91e6197558cf0f833f0f12ad2731c0a51b2f7"
