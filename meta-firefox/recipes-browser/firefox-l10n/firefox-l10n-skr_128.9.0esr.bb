# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bd44d3056f06c1b133ec837369cf6fec"
SRC_URI[sha256sum] = "c2c8e7f09be7a011cc13ca6f03b7a889d363e9e2e5f1bb6f88ffe05a3e7eb5a7"
