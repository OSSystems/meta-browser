# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3f3b668c938d6b64027dd80fc382a9c9"
SRC_URI[sha256sum] = "8d93d5c4df7586a0e4b72599b97bb4d4f9929daf9648a489f6423dbea0304b84"
