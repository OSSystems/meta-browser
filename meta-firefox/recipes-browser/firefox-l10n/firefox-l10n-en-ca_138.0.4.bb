# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "21365e26549a13c1e9728b876ee39096"
SRC_URI[sha256sum] = "73f0ab72bbba1e8cbdb9db943a22103cee4bf0717c79c42c4faa96d4f0a3dc6c"
