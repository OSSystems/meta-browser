# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "fd301b1494f72737fc47da8890ac144f3231f9d80ec41377347a6b3b552492b4"
