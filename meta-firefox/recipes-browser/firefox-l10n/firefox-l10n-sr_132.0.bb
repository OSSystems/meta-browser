# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8fed76858b47079156a661b008c24717"
SRC_URI[sha256sum] = "f4551f336e6ea271b87f2de7c328ad0dd68a658c0ffc93a5c16d598dc2fd929e"
