# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e19b18f262d93ebdd2d6e61a26c30332"
SRC_URI[sha256sum] = "32e224041a19b8f4a8eb585c64e2d15ef77fa7086025c24e345a45de101d0a90"
