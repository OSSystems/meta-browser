# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e23080011ece34a687678ee9557bcbe3"
SRC_URI[sha256sum] = "113fb3675231e6824ff9c07be5fb7257326f75c7cbc2debc6d3d81794b00ac94"
