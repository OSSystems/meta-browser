# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9e2e58e127747bccae3d324a63d39bb1"
SRC_URI[sha256sum] = "317ce31a44b69d52e227663ad930c6f43ebf4859a2865fbd66707cb1c7daccc3"
