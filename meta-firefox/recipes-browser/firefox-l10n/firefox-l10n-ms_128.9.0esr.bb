# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "582fa8bb85b0e0122a8900b5abd38af4"
SRC_URI[sha256sum] = "7c60a7ec80488a036fdc3230e20607b66df3ae50ddf03351b5e338d814fce85b"
