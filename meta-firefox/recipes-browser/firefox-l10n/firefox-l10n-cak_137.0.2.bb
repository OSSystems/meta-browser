# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9eb7af072a3a339ba581abcbbc2b9dac"
SRC_URI[sha256sum] = "f889494b87350d28919d4ece61516353fe599035cccb1ab642bccfcdec8ae0b9"
