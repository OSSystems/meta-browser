# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5b70904e17c234ecfc09a2936c653323"
SRC_URI[sha256sum] = "252d8b805cfc4f00e200803e667923e7c3a63975100efcbffec947aecd7085ac"
