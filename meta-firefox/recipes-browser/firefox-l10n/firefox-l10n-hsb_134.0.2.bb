# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "803b8526a4f78de58d5c830fb8a0f693"
SRC_URI[sha256sum] = "94f263f8b403f0b48b397f41e39ca86cd27bee52766985b2f8a6908c9ff7da08"
