# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ad33add1318d259bd79e3e072af93ef49bd6f7f88731506103318e1a8b7fa366"
