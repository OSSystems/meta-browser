# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d592a5147b7bb17cc819e04f21ea3404"
SRC_URI[sha256sum] = "78dbd63387fa0b4a74b914d1e3c165aaf56734cdc65afd05ac5abea2165559ff"
