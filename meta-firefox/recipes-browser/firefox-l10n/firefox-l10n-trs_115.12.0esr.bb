# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f55e5b0e9e132e7cf13c83693df7d243"
SRC_URI[sha256sum] = "0bf40cec24392bb8aac9b73f2c12915630d1dbb8611f08cdbb2922b85f4af476"
