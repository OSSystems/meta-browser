# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4fab7a41fa777fb3006988f8f5c41fe3"
SRC_URI[sha256sum] = "08e61013ea890e872fa23e0752b2c163231e8f18f98e93826623f7f7b7b77c9e"
