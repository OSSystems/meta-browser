# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8b677d2974cd06cab2dcf289df4492e4"
SRC_URI[sha256sum] = "384e68552c2324a495aff7e4cf593b7af432eac8256f6ed5bec52610cb35b1e8"
