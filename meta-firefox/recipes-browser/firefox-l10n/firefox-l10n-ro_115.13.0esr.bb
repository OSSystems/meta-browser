# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "97c3bd0df3fbba6285de6942d1266b5c"
SRC_URI[sha256sum] = "d6a4e55e87aa6b0b73795f4ae6cdc5f91123cae1fbd0bb9b48475813c19eea94"
