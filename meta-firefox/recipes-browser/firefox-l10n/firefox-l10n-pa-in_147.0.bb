# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "00c9791876d69aa3ae3a0ab168986301"
SRC_URI[sha256sum] = "1e636e8f83ccda1bd20fc8484542d271c5a84c956d1746f105775a3026f113b2"
