# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fa4891e4f350d3a46a394bfa2b1066be"
SRC_URI[sha256sum] = "a7393a9d2f9e311b7e31735585e68a0f3a08840b6cbc05d29746921e267436e1"
