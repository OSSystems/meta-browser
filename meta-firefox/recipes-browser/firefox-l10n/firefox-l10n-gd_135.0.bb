# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9a42ba6791a8d21829381fa6f5f73c8d"
SRC_URI[sha256sum] = "e93fe5b5f51d4d7b1a03dfe33c5593a32d10e3cc7ae18eaf3fe51945a5671920"
