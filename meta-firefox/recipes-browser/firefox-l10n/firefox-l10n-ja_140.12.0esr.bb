# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "98cefe6e2abc90331c434e07ae0e8b20946c32b424f706b9c55ec94d3d06d15e"
