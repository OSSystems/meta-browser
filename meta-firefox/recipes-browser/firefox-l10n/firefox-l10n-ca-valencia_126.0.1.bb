# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4757e3ee54e80857fdbb3eacd42ccf96"
SRC_URI[sha256sum] = "28006715dd822ec4012acb3b4f7b98d17a423d0ce5be659f62ad26409c71e066"
