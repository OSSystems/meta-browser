# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e80ede2357ad6d07437be4ccb366da3e"
SRC_URI[sha256sum] = "43be62729d23e77078f53f0ee7c444ad526325b9c82980e977d536f3c63bff84"
