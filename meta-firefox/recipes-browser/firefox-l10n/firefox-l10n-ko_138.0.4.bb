# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "38896db47e9ec33dd2212cb27c9c7a41"
SRC_URI[sha256sum] = "1bdf1d69a973ae0624aa57bd51eb92839c258d7f766dd74a172f94b2d2ae23e4"
