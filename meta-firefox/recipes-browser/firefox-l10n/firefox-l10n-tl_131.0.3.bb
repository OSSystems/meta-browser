# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "85122d479fb26c46c2637f818978dbc3"
SRC_URI[sha256sum] = "48206159fab4f4f6ed5429a338edaed2401a053d71303578bfd5583c47f12aaf"
