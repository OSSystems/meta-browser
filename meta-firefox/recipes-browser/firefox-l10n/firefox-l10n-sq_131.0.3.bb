# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dc8f990bc9c7817f66f8040c87343a69"
SRC_URI[sha256sum] = "1c8ec10ba717c7b2672d18e4370fda6348f8afa2cf39fa67d2df4bb760f08c5f"
