# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "abb334b8117342c5183b5eb64fae2bdf"
SRC_URI[sha256sum] = "be911b3e8d228faf42644f14b0649487b267109a70ff5a9914b7bbfd393523a4"
