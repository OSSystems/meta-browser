# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2fbabd95c395e1f1f68aa1f67d3ad295"
SRC_URI[sha256sum] = "c613e51c3c78073502b310b1b4ff5132b16c4218f9c5ceda51548e23d059d8d5"
