# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7e8e0f5846328b64a86cca55493448ec"
SRC_URI[sha256sum] = "00a8b87602a603be50e8665a4c4f457c3ab6815ab70a3f78b1e31ebe67e9136c"
