# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fbc574f5c1b4798d125ffec8da011e5d"
SRC_URI[sha256sum] = "c471f8f4a5bf0ee9d593ab6a9f8f589dff8c9df98377ede9f9440d3af944da04"
