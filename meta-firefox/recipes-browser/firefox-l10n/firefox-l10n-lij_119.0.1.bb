# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "84802517f663960b55538014c8f16e5c"
SRC_URI[sha256sum] = "f20049c2c4186dcf5eaf1afb670a06408b1fbbeefc8c18220e9dd2245a6723db"
