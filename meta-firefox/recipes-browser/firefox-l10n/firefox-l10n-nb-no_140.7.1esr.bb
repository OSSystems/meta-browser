# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "12243b0e21cb0c94f1a8bd03135f29e9"
SRC_URI[sha256sum] = "d938575d90a81cfc3a02c144eae2a86c5c8cf20f609d8aff38be5052de1d398f"
