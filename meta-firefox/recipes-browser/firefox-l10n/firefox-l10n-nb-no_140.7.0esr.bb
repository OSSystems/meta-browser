# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "50adc2a220dfb330c337e267246c30ac"
SRC_URI[sha256sum] = "eb904952f87d39416f42180fb8cebf4be7ab6eaeb31b5a3852e904b8a0c95d8a"
