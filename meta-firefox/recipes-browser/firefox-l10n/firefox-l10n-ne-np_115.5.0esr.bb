# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2382a5dc6208439f2d518249d372c15a"
SRC_URI[sha256sum] = "2bce4c5a40076edf35101bfb51ea94186eacf88ffeb643d01b5749c0d39c871c"
