# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aea0d3efb1b1ed48b99d971e2818a4ce"
SRC_URI[sha256sum] = "615e01b9d4361ec9a79df1a62e89072b2b324830214e3ebddd20ec2f18cf316a"
