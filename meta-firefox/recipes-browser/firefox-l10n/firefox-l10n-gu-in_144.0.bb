# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "16ad45de253c564879b37eff0a306da8"
SRC_URI[sha256sum] = "19f102eebfa54860980832c94d94ed67cacf26d9b9982decfe5515daef11af34"
