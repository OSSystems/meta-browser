# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b83b8a51fb5a6cc085e866bba86152cb"
SRC_URI[sha256sum] = "f8505d704a2efc74014b215f6a1916d499d76aed8f8864663df1f34bc7406585"
