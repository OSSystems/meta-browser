# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "155ab5b75f3e05e3aaf23e163e8f53d8dfb1e8b80973f7a57f7b2f1986c72360"
