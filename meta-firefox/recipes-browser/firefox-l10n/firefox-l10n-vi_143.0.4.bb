# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5c20eb1c1eadcb28206beb28b9e7a1af"
SRC_URI[sha256sum] = "4b171526e0c00c38e94e93abac708bab5fe75318b48b347ec6195a170936d2ec"
