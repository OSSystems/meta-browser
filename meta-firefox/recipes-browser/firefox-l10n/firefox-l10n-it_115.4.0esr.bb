# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9437d019f7c60d2cebb6728c4a62f871"
SRC_URI[sha256sum] = "2634105a0108a5282d26343e0d527470416e6bbbfb3a38f6186aecf8131306e4"
