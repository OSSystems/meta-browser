# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "18f04a9a44576bba79d8c46097166131"
SRC_URI[sha256sum] = "511f5807b87eec77e5e784443dd3e1e474b229cb8f4238c3dd725cfa6f93c471"
