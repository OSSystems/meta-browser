# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "84aa2937fe290b16b383eeaaaf973bba"
SRC_URI[sha256sum] = "53395ff20698606aa40de84e167896bd73586df69e468b75783ae4bd42cee989"
