# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bfdf5e1814802477baa1f4a7e0e8a59f"
SRC_URI[sha256sum] = "8719560c7e56f43339d6ff1fb3c133fdf7f910267c1567eb299a6827b047f775"
