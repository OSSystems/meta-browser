# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ad0c3ef47a8dda1764d371d4f0a90b7"
SRC_URI[sha256sum] = "e576d936c91e7a73874e36526939cefa2b37b393de73a396b1248f535230821f"
