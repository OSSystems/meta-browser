# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2889b10174de04d7110b32dbf8818bba"
SRC_URI[sha256sum] = "09d3e8b4ed8e33436296526188fef706bd454a62e536c5b89c4a6db0368a36c8"
