# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fe09d86f9894935a20455b4dfc02ba5d"
SRC_URI[sha256sum] = "323d46452be8288b0b469c1f2a41dcbc0aff83e5cc8b251cf0ee909777f18370"
