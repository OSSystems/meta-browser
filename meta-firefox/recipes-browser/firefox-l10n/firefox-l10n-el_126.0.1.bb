# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8d33cfe92783409913b63b501a9ef006"
SRC_URI[sha256sum] = "83ecd846dcf044fa380ab6f284d9956c74bae664c62c3f23999e442c85d2dc25"
