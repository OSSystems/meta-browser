# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3df41e4abcb94c4944a3308142ca3493b4f636012c44c90bd317dafeda30bf92"
