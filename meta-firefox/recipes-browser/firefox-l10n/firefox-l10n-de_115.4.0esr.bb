# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0f7ec88e62ab5a4e2eff626e628a5cbf"
SRC_URI[sha256sum] = "f75d958244c87db7302afaabe4a270946ee2c0ad69d2dd970c48772855e651ee"
