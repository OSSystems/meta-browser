# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6789b2481a1eed6d32eaec88f94b7ac4"
SRC_URI[sha256sum] = "5e9958486fafa7be5b978ef2fe62f977e3dc23769e599d98967781c1ae59eb38"
