# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "30ec1cd5a3bd6b01fb6bbc977cbc69ac"
SRC_URI[sha256sum] = "8f6a048fb088796370b77ad331cb021a3319497cf05a992b26eb94148d5cc75a"
