# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0e9515f3efee8eebef5932f4b7ed6687"
SRC_URI[sha256sum] = "017706f9a2f36ca5afe0e89fe52e6d8a56090ba7dfaadd1a62d38373815db49e"
