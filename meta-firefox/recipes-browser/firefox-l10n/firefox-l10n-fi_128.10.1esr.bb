# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "59a64e596743f6779f130c56c27f42e2"
SRC_URI[sha256sum] = "8dcca38eaa2ed375590902c2493e013db92de238a1ca137a8aefc336d6d16232"
