# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f82fd1efdddc5463a074bd196bb064c4"
SRC_URI[sha256sum] = "47208e7b5fc5de1f6be963ee8fcb588a2c7a14ddddbcda325015ded95883b68c"
