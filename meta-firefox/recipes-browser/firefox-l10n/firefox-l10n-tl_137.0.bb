# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1caf1e7a145cb6143a90d846603194e3"
SRC_URI[sha256sum] = "5ea2e9c99af85555201d71d3a9b9a26ebb77339f2388cf2856ae12182a6455fd"
