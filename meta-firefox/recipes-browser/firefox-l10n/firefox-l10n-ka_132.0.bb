# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0251b2a63d13410049808d31c4ccfe8f"
SRC_URI[sha256sum] = "1612a96ff7e2002bde67427ee673e4dc0da420396626a78d981cc6b64d7aa665"
