# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8ccbda7677c6e15ac7e0fabe546e6d42"
SRC_URI[sha256sum] = "a54a31d68c67d4610f3360eae1c67bb92ce84a12d137e643eed505c119d9af5a"
