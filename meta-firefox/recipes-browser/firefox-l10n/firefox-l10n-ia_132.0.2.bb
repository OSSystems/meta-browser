# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9d09c12b1e6f265f7d515e18d5ec3037"
SRC_URI[sha256sum] = "29875a271be6b5a14ee615265a65184c7403f17b36377e91548d798ab92f603e"
