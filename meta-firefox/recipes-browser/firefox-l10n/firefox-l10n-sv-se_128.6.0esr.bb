# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "57eda01cafe3509706f42fe80b36fec7"
SRC_URI[sha256sum] = "c5a72649425d5993dfd71ba18f6a528747e5d604614a95f22e55ceef07b3521e"
