# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "85e315b87ef6a19840eef69f82bbdcd4"
SRC_URI[sha256sum] = "2f4b01306e213dad38420b9dd56e3c102db53ab50fcfe486859e5a850e2bec3a"
