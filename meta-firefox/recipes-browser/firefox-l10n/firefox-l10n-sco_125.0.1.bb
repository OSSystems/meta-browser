# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6fccab8f35f65816640ce79abb46ae84"
SRC_URI[sha256sum] = "8d38bb4aa31c144d9b7eaa4e60858814c786768ffdde6aab99a9acf47cada3e2"
