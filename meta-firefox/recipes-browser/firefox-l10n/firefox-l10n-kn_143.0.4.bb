# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "792d610d4e57cae6d1ede27075f654ee"
SRC_URI[sha256sum] = "395bc4bb212fb3945bb1dddbd49fd9939d674d16c75dc7c458be34fb7f3e4886"
