# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7013d90e01a097b71050622b95a908e4a43f6e593250c0e4c378b8ca01581d34"
