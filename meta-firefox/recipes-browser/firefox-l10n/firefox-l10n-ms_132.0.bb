# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "afbe87cc326b156ab8e4af1de012149a"
SRC_URI[sha256sum] = "4ccdcb85688bcd2979bc37c7d2bc29ddb57cda868e354846d6d1aa60ebef3a8c"
