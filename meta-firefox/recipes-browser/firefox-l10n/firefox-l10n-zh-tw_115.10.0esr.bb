# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f668edadf3f0c6ac7157851a68b3d8e1"
SRC_URI[sha256sum] = "f74f2aa84585a251081b3aea75ec1de6ac30aaabd49bf0c05f4380b893a538e4"
