# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e18ac5c4d2ed51211afeacbf681dabeb"
SRC_URI[sha256sum] = "a9951bcf7c76f99bd1b71b009bcde2fe5cd080c67e848fc9b539ea78ae62d43c"
