# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ea649abb6e4794664a44d951c2e6bd28"
SRC_URI[sha256sum] = "f4461af3d2d24d334d3a98aa5f38dd9d65e377d2671bdba5c2469f78f467a8d7"
