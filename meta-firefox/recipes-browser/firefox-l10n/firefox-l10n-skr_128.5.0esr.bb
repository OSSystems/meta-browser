# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ec115e481f285d19e4207d602e6fdc7c"
SRC_URI[sha256sum] = "fa1a9958e146c5e7acabcb0bfb9ec4efc805b686ab51a804a13fc5966065da29"
