# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "790e3c41cf5cc309490815daf5437d2e"
SRC_URI[sha256sum] = "71e64a03b1bda29b12028009385e1f4dcc33e1c12a7e12dc3f499646a821dff2"
