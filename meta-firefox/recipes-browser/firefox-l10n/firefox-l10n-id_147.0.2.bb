# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3c2762aff870318756a3e7a2e8ab0ec2"
SRC_URI[sha256sum] = "c23c774d42e3527d03fa9df1efec0b96ddee5ff830d8a646ed7f497e8d598365"
