# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f773f1dfdbe2a05659461457c4c2386d"
SRC_URI[sha256sum] = "a956610bff08ef689d3eeeeee5fb406ab37e5802067c0bdc659135626e120648"
