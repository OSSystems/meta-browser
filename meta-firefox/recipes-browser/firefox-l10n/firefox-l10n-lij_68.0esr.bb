# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aa16c2b095d9614070bf67509ac786d6"
SRC_URI[sha256sum] = "bac5bbe4aa46776301123e155180f0864c326eaaf4f81e18f3cc2b6f12581f36"
