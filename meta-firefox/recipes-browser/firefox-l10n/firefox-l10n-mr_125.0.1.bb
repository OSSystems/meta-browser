# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7272424378f59673aff9575e93091996"
SRC_URI[sha256sum] = "c704fe01bb9480155fee81fd0e5e5a5910f0619bb6bbaf095759f9cab5f75898"
