# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "8ece79e20c072895ad892d2305684205411861370f4e4dd163bc74a1c96a7918"
