# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e61d6b71863f45277d8489918dbbebef"
SRC_URI[sha256sum] = "22c8413557f65a77dac49a577573e6364490d7bd528d1b7570d9bc959ef9afa7"
