# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "46ca7883574bba6cddb083bd6e7842c1"
SRC_URI[sha256sum] = "d70774a7fe20f8f8ea3d64a5e3c22fbb40e9f55b57280a7496e0787267cc60db"
