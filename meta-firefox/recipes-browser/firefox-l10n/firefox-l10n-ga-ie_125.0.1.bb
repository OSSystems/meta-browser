# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b82f9b893dfbf9add3b5e5fb13b548a9"
SRC_URI[sha256sum] = "03d4399b98946b0012372367a8723aa3fe8aa780eca4f2477ed8ee157022e497"
