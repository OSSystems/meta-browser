# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e63811e2b326e442c6bb63d334a65d3d"
SRC_URI[sha256sum] = "4d0d9cf751af133845b719ae30d77c54101441d3615fe74016caa01d2ad0411e"
