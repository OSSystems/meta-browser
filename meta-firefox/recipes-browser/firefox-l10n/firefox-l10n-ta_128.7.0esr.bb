# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ed6c2f32a3ec60d75850ef145397999b"
SRC_URI[sha256sum] = "f4fe759f3f6addd7ec3792a88b19b45c7ff02687d5adacb3fc1cc9b320281292"
