# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dfbe603520859dee0dd433305f1169ef"
SRC_URI[sha256sum] = "e75a11ee2de0cf2d65d8809e7b4a497de848f86fcd80a708e1b17c6d036c757c"
