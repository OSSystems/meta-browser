# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2bd3a34775f407c5f0bda94cd122e238"
SRC_URI[sha256sum] = "67079dde9d4dd146e2317ca6d7945f40ea77656eb523d2eeb6cfaf29e7e0de61"
