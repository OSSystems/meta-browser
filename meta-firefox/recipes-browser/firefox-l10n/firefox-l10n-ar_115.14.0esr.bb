# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "33d98b4c2dc84f1e45ea22d482f0e4b1"
SRC_URI[sha256sum] = "f1c23d32003551395f82932f4a4b057f19961ee56642e60f5c4064f0c8aa0f70"
