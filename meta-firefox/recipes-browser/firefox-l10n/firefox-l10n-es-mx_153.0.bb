# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ed3393e583b89befaa708deb3ec93bcd3743f4f1fdf662e54eead4acc4967e59"
