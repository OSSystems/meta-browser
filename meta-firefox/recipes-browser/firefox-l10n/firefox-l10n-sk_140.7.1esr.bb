# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f62681c61a2e329c051e8909500bf25a"
SRC_URI[sha256sum] = "01d96d16b9814baf5e2ce3a1e01c38794cb57ee51529f12a95d4f7b470c53029"
