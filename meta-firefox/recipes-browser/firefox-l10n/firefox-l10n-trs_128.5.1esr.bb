# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "85795fe1cecc39502843f5d975cb9d70"
SRC_URI[sha256sum] = "1c3f25e92fcd212cdd1cba9e8cea517e71a7247cbfa9905330c0da17efbda793"
