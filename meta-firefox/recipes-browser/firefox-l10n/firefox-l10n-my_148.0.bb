# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "827cb5962f7db6620ce28ad40bfce13d"
SRC_URI[sha256sum] = "98d9ba727a5b11a620c0141fd97bc26f72d5352439166941f51f18d5fac8d247"
