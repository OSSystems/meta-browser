# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6c7642455e5d27fd7a44a8ff860e07b4"
SRC_URI[sha256sum] = "8b5fe63c56757084035a601d65b725d1bf4cc489f3f0df21e8d4424a624ec85b"
