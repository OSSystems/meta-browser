# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9bb80989fc387dc18e001bbd3496fa4a"
SRC_URI[sha256sum] = "5d7cb70276fd1f2f43f3092d4041c5a4ab64672daacf19320cac7d447a0ec776"
