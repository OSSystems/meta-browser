# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9f2a08311197f231b3101d29794f3eda"
SRC_URI[sha256sum] = "eac145ada3e2c63e7de217662c93cd14af5db5fff9db4eb9cb624b02f98c0681"
