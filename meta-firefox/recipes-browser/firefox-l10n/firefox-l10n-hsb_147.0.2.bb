# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b1e1e6aefb0162b33502a30981176638"
SRC_URI[sha256sum] = "01363a3921914e5cb40f43b939d5e139534a1eb02e3fe4b352b965f36e10d84f"
