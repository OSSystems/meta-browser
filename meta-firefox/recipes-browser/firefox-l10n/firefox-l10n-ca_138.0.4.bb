# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cfd5abbc5bbeaf9c8b50ad9844e68685"
SRC_URI[sha256sum] = "f8e9ce14f46149b7fcac4013977e11bb47d5e00a3349183cbe6e10b980fa0a7a"
