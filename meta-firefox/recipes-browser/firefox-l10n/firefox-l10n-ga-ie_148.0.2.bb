# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a4579362bfe8f45bda9b2abde772b908"
SRC_URI[sha256sum] = "d1b573e2fe19d8e4f6edabb997e2832d820ab469429f12e5021a8ba41083f1df"
