# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ab5c9b8b432126a81bb16c6340b19fa2"
SRC_URI[sha256sum] = "bb59f8b88375a44b01a611f14ed25fcaec4146e8b4c3f5ef1ebfd07c38b6ebba"
