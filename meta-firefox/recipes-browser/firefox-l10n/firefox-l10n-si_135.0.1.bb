# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "04e10e0644fa80f825fc66fd11409d14"
SRC_URI[sha256sum] = "291f402ad1ef9a435b7cf5f3c63647eb2350b0c5a2e3d7157900af7a29550100"
