# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "79c7692a449b625c6bf116781f15210357c9a859909595e935bce91b3e0afab7"
