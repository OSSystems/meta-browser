# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "45abb15fbd522417d79f25a2660802f2"
SRC_URI[sha256sum] = "b41fe84c28983fc5fffddbeef3220ae22e55f7e7d107274b280e6735d2169b57"
