# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4ad0b2e2a6b9fa44d2920448d309126d"
SRC_URI[sha256sum] = "4261e44dfa2794580d5204df156f649d6fac47c4a83fef9e7b80fe11df634ea0"
