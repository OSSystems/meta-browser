# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1d17f6be51b376249c1d025fbf925d1e"
SRC_URI[sha256sum] = "07b54425535e76b4e50e8f3ada3be3e0770fc2deae50e704659dfd0316ff2b98"
