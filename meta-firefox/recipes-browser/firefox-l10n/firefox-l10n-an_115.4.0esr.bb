# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4e7f923908f878737feee4c6235788b9"
SRC_URI[sha256sum] = "1c49a7e580d603f7bf98ef24d91b7206912c3a07fbec7f1bae1f73019c8f6f68"
