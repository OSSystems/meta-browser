# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ba14f4766509f0ed67ebbe86735ea40c"
SRC_URI[sha256sum] = "7a80b0b2ed687d507b414da0d6f43365ee40136cfd4d7029f92a58b10057bf31"
