# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4fc524de97f71ca3bd84cb6ed3f20f35"
SRC_URI[sha256sum] = "93e3719a7743cb9d4a5b3c2e0fc999f74af46294b9f50cba3b966467eec32647"
