# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fb10fef34e7eff2296dcb7ed4a7ef329"
SRC_URI[sha256sum] = "95e5c386d6535f13417e4c24501924cc761e30c6160e47d8fb84f00f8b0f771c"
