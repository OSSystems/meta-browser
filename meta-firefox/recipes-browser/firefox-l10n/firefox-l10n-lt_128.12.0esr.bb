# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c0eb73bae47de905de6dd4082fc3397d"
SRC_URI[sha256sum] = "64df82f25ea24d4798bf9717a4e54968521453e4ae1a4ba765312862e94d68e1"
