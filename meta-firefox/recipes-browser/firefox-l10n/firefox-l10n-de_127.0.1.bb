# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e2d3e7f84d7ea3f987a4a5de9f627740"
SRC_URI[sha256sum] = "bcb456684f80cbee5a23f13af815b6cffcedadffe2bd634a5fcf4ef928e29ee9"
