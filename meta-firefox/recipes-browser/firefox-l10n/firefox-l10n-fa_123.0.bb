# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ff3ac2ec182f35f3c7f86f6cde3fc727"
SRC_URI[sha256sum] = "0ded781ddb8cfa467a97b2cc5e375f52ca6b2193296850ef6fc4b4e491db791e"
