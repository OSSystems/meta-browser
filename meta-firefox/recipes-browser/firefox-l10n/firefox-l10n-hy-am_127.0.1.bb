# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "40ed8c3a8d1f4cecfb42abf5e5590e19"
SRC_URI[sha256sum] = "2509c332a1842aad0ac63fc8ee72c5941e3f3f3e8cb6cc0abf8235ab3beb41da"
