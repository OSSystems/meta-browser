# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "02a078415c50983e23b870cfad131fb2"
SRC_URI[sha256sum] = "a3c0c8a582dd4c58d0ebd86ac16ea0a9079d1d916eef21e5c3caad2466063241"
