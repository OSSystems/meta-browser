# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cc3a3bc130ec0a5cfe3b7edcfb46c3cd"
SRC_URI[sha256sum] = "1f7e71364eedb79dc0ff75b85e1f126d1e67134eeffc1cf35cb3fe2b0e0c4bf0"
