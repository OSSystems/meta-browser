# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4e23beb4c3de3e6f2607a9f22eaac2fe"
SRC_URI[sha256sum] = "bbd8fe1e5676b8d7e2ac3e231067d7bf35a0c2819efac57b7ba38c15d47edaac"
