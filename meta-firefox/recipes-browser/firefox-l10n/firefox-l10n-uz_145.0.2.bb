# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f9273a1c93d3245ca4921d4063a77c65"
SRC_URI[sha256sum] = "7fe2f4e287f9a536f8f36d837cc73c362e8f03ef9cdcc03dd379b806ecff3e80"
