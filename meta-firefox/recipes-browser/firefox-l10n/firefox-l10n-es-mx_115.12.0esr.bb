# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eee35fc78c9b77eea38c84d6b1b08abe"
SRC_URI[sha256sum] = "14664902fc654151674d69eeb65062e4ce91d095ddaf92d63e3b719864777057"
