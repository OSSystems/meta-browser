# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "28ce6d09de86d00f146a1b00ece8735c27d49ebc67402f81389c98eaf560bef7"
