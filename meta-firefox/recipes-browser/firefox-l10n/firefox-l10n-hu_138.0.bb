# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6e3e05d46890006e80793ba93057dc8c"
SRC_URI[sha256sum] = "9365eb29778a4f8e3f98c6e5e93002000553a2c6c1cb4886e137dec35d56eb55"
