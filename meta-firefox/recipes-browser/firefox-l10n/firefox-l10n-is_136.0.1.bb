# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "954a21269bb9e8bf5110e5c341bedf9a"
SRC_URI[sha256sum] = "b9160a709d30f3eefd20f08d8428938945dfeac5df34cf3bda75efb6653a3e20"
