# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0758f6420a478bb1910a0513b3bd8181"
SRC_URI[sha256sum] = "29a934e3167c34e7c720ebb1d14c38d02c32e76f3d091b23a9d753864eb4f497"
