# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "75089dca90596a6f875b05a3cb977d79"
SRC_URI[sha256sum] = "d76c591d9166a27ae22a75d01b080659b07800d215d3a5e3c535c907a3fc7225"
