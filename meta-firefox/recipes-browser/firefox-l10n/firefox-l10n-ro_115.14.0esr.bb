# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "34f50b53909d4bf245f2151cacbb09ea"
SRC_URI[sha256sum] = "248a1dea001314527717d5105e2046a1eafec1f04d0698d1da6216141cad027d"
