# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ce736a1212adaa6b8b200f9fbd05130d"
SRC_URI[sha256sum] = "904893210b3e90c74efe3c8e1c00501dd9e52fca1a33bbfe5d32028c1c1de62c"
