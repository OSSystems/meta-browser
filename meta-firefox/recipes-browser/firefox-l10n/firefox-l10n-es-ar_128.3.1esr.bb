# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1f5d77bc8f9260f5ce0d75e8d4393731"
SRC_URI[sha256sum] = "7cce7daa93b0d9011a274b8d781b9ef892ba7579981020e41632eb5b56e71084"
