# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1538bb28255730b82413806b05e0f157"
SRC_URI[sha256sum] = "e87dc0677b423386f68c73719c08b3ada210fb3dd65f8eb127b56d1ac64f8ed5"
