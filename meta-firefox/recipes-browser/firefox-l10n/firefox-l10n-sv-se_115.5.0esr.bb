# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c0d6d3c904d268b2866934a456a21504"
SRC_URI[sha256sum] = "268872dfc98517f6d8bfd8f17c5c4739e2176091c94296b3473aa0afb017c600"
