# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b24c4c1e361ff87aef0021e116ebfe8e"
SRC_URI[sha256sum] = "80fd14bc4e05b0e9d175d2b8ccbde56fb806671a5b24a6b799e35db29fbde619"
