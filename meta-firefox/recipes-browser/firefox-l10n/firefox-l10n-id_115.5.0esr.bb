# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1baebc7c20129c49e57f2191d01e9bc5"
SRC_URI[sha256sum] = "c08b55f7516a4d6d00a096c54c02ddd284e9272fa3f906229728f10e327fb32f"
