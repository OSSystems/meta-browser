# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eceff5b0eca6f98b5bb5d5e5c34742ef"
SRC_URI[sha256sum] = "76493d3d5edca2ce8fa61ce56b1ccb653a25cc6833b8ec8a996d6ab5c5ad893a"
