# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "52a9dbbcdca3f0a384cd60cecfe95101"
SRC_URI[sha256sum] = "c15dbb4d1f8c15ff91685ab6572760525d5f7babb4d8de59b55338e3edc7a68e"
