# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "de946cda873a689a20dda26a31256b1b"
SRC_URI[sha256sum] = "cd3c519fd72a9893f56083a68df6a249492be66cd740639f9d44a3cf3e9fd21b"
