# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cddd18a3c987e5d2db2c556836546cb6"
SRC_URI[sha256sum] = "3ca144a49dd73ebc4babc789e997b5dd5b693de1ad8fbee184cf749cd16ae1de"
