# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "48e1c97fa3fa5f3584f5745cb161dedd9cd4b6590fbf03fab4f91a2de06bfc04"
