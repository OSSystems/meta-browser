# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a520e47437e2914a93d00f75f3baac25"
SRC_URI[sha256sum] = "8b8a2d66be8a6f5bbb0cd1e8ea3c4d9e7d2582c1c83d161b41ff9f72c82cc05a"
