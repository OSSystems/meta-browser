# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b98a14e0dc44b6214867549518b2b4bc"
SRC_URI[sha256sum] = "c55ce249bef2d50bb9a2ffd81654e3f9d49c2ae8ed1fec5afe79bdf81e5f1ab7"
