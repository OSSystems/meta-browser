# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9d20cb23540af2e4615e2a5851ba0f88"
SRC_URI[sha256sum] = "94c26002ff66ddb413e5faa7e088920149e59d5090eb18f13c36f9d01b709052"
