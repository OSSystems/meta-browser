# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8325ad60c46c7ca8bc2b71ec194805d0"
SRC_URI[sha256sum] = "79a10209a98dcd2907e65602a214c608af9ff40dad6dfe67c64696fdff5d8983"
