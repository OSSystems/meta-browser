# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "af1d04f807d6d0a1b76c5d3583a7c874"
SRC_URI[sha256sum] = "61b3b428639f8f9c26d57e45ab5942508d846b9d81ae3c6d30631be725a15d16"
