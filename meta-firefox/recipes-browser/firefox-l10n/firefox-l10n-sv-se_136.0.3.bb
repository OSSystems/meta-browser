# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9c90614e9cc8cbbde73816078eefe622"
SRC_URI[sha256sum] = "cdb81bcef94e20103263acc8958eb30fc7e67829a4b7eadaf327900e1e2f5ba1"
