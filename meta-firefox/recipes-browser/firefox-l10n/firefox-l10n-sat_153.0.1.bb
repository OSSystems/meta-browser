# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d260310dcdbeca71c848a48078b5456ce26b6503e3078e948f4938443b79b517"
