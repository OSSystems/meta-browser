# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ef07525a719fec34cb2d5d31a9840423"
SRC_URI[sha256sum] = "bd925ccb41a9dbd89bd88f8dc51a21cfe358bce5fcdd90fb0789f906a6a2eb08"
