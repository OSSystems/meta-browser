# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d17c46cdd41f5501b5507962f3cf4bbf"
SRC_URI[sha256sum] = "6489c83f992f3156fdd12249835484a85dfebdb96a82c4f24ab55fe35c4ebb79"
