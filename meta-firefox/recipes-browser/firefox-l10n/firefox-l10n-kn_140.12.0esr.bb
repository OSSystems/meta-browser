# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7756cc596cb90b88f71687fbaaef410edd0bb0ab7c4fb5fcf6746b19e914bdce"
