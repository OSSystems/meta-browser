# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2735128e29e80c1a3a5b4826a8c3b686"
SRC_URI[sha256sum] = "91639f99b50053af1972347fcf4e03806ed19223321006196a9951f5c95694c9"
