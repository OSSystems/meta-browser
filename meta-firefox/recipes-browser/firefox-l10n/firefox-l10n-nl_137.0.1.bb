# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7a99dc41e1ffdfa1a9d751b61811412e"
SRC_URI[sha256sum] = "fb311b84727ac551b1d697ba02e0d4aca0c11d8320936e01410c1e2924d95848"
