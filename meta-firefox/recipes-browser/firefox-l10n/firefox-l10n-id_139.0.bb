# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "53fa30f20889564b8c580fe9ae3ac505"
SRC_URI[sha256sum] = "9bcd5949c5c2beb789ca3f5b49a6bcc13080b4172e9f73d638cebe5fb9f55a56"
