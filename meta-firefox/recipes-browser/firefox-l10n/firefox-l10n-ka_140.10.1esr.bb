# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "566537d169c1bf53b0cce8d5fe2df7f6a49f8da4a77c7fb1153d36d886f398e3"
