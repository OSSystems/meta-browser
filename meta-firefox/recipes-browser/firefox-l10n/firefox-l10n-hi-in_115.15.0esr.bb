# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7de24c9ef984ae0dfd28414d19d7ce34"
SRC_URI[sha256sum] = "40c8fbe67eabb794ab49e2ccc42674ddc9775482ee3f3ffea0ba338d16d5e330"
