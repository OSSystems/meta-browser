# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f4390914cf2640e2c81b03a096ab91ba"
SRC_URI[sha256sum] = "1e3004b1cd33b0de2115e2a5ebdbac184f8b523bb991b1ed848438815927fc48"
