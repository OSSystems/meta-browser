# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2bfd43f759c191079f085d8337708703"
SRC_URI[sha256sum] = "606e77b3df66b7adb860e6bb42b24805e898a9c1f78d3184938cfce33e5f897d"
