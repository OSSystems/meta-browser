# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cfda3b92efaa5884f24529ecda0f057e"
SRC_URI[sha256sum] = "618f6f651a7f178975d4c44b24080abb3e9fa9379ae2e470f295a306babff5b1"
