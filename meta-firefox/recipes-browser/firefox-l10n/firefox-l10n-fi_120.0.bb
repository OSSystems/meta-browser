# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a090508b48c96af1057d524d231498b6"
SRC_URI[sha256sum] = "27c75e94c30beb750d20f99c7391157c245c8482f99e80318aff15f1eaf38f55"
