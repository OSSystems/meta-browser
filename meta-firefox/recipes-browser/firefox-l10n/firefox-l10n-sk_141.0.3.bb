# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "66cc84aeed2cf2df0e0c405b781b2104"
SRC_URI[sha256sum] = "c5f04fc11d8e0db9264fd374a355226c546044e1bab0d5da1d992e0686b8dfb8"
