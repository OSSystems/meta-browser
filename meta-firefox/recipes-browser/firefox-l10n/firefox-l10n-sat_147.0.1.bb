# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d3e2ddd3313bb28a8c3ee7dd276daa3c"
SRC_URI[sha256sum] = "5e8b03886ec4acf42ed9959b89f1bbdd6ea5ab2fadbc5e6cc091584010868a2e"
