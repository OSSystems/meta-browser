# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eea125fdbaa96c2f824128c21e05a6fe"
SRC_URI[sha256sum] = "89df5595fe1fbe1f0bc0730bc3856e977ac5a2550d0d77320821072e5c868f8b"
