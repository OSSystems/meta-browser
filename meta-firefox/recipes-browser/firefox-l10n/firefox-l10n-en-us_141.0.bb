# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "04083458a5915e14aa34e43de36904d1"
SRC_URI[sha256sum] = "41290f89e18477af1349572db26eeff890d04c6a1200a071930722c035d95ff3"
