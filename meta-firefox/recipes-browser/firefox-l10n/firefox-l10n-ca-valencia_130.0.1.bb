# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0a18e61dfe6a8ca84f3ac3c8338c5381"
SRC_URI[sha256sum] = "d19e635d7affbd9a649bce549c3f00b04b025ca21c8236bfa1193b01d209b3d7"
