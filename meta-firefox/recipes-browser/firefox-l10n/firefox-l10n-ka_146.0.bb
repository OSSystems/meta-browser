# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bc6c3ff5d40e44e0740e656e07979dd8"
SRC_URI[sha256sum] = "eddac3ae76461be7c73c25075db316d09cb34e06e1029a79619015c13a81a350"
