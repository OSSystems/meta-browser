# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "86264bc7541a03109726c58c6d392a7d"
SRC_URI[sha256sum] = "96e115a82639c43f625c8badee09cb76aebf5d1431cd2053bdcbcf81ce71521f"
