# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ee521a32801b5f7dca76383857e4a22"
SRC_URI[sha256sum] = "74a1f5581725f7cbf20d2e91d6764a541dee267be8de657e049835931dc4029d"
