# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "10ca6d1672d1edcd1ef5d208393f3af0"
SRC_URI[sha256sum] = "01f266df047a672b43590ec5acc7bf48cee076e806db3e88ae2cd64ea9f78805"
