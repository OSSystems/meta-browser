# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a9247a6968f7e6ca86ed692a23e79715"
SRC_URI[sha256sum] = "fdf955f6b868be47d86e1ddf253b7e583e612a84786cf0319e2ab263c63b6fcf"
