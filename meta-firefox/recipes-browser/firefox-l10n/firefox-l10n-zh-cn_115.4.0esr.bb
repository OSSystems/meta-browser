# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8dc268e89abf75c90aaee941ed31c6c7"
SRC_URI[sha256sum] = "c27869b4a702b4b122cae44e7ce2f3401fda799cd2ac9994c51867bd4176adda"
