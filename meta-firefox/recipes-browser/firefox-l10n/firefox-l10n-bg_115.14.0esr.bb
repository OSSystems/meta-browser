# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e3dd983793c93a814f6fe0cbbf772122"
SRC_URI[sha256sum] = "a60a627b87e3534fd8b6021155aa2876f41d26c4e13f062cde8a9d698f069ea9"
