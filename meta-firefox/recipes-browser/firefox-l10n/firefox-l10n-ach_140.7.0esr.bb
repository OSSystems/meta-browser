# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8d8572ceef48c689891cfe413c4e8a5c"
SRC_URI[sha256sum] = "9e0b2d9d723aa56cec58791bd0bf4f6cea340fc86d2ec6ab6e4163514cc23c28"
