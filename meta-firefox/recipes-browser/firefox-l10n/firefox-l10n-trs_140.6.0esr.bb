# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2d4961eccaca41d95c9d83a66f124fd9"
SRC_URI[sha256sum] = "ed978b3a733eee6fc4e49e0415f45f87a3fa3137775247636a90df045939b68d"
