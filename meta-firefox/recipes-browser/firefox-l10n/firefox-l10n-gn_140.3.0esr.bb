# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "62f96c45fc78c83f8780cc47ca1f87b5"
SRC_URI[sha256sum] = "e18a032a4b6506d2249ea7fb4ff9f6587bc75e2a93385317576d67dd36a35ff4"
