# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cb63f5918249167e07ef32fa509be116"
SRC_URI[sha256sum] = "0fa8d590dd4a38e5fedeca4a8e9634098570d76bd605ba4e403c324f4309957a"
