# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bf6e39fe6f155d953f51031ff962dfd0"
SRC_URI[sha256sum] = "8c36cc89d7d3b9e967fdd63b50ef187deb270573da72d163edb5407b138437c4"
