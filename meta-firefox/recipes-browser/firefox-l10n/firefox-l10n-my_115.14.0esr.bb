# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4f8fec05e90e8ad072b98bc67d77b8ca"
SRC_URI[sha256sum] = "53ea7753006a7e149cd8c4b78c6e6b954535b16f3900e6d55db2d429878a9d4a"
