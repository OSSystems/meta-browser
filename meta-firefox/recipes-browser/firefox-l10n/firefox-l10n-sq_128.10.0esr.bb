# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4fe5afb524ff6013312e98e286f472c4"
SRC_URI[sha256sum] = "f3b864868f506c698ba03a3d6e90c60cca516eb67cc1baad4ce90f512e672ce4"
