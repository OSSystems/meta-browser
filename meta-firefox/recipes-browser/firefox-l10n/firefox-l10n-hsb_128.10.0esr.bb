# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9e1dcba4c762dbb15fb283deb1bcbc2a"
SRC_URI[sha256sum] = "73b8cdd341f618c820740b6217e4653482662ffa67b73d37922f1b6d9c95688f"
