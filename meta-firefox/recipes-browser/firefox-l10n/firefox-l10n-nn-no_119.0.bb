# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "78f1ed433dbea08128e5a77e29841a60"
SRC_URI[sha256sum] = "2f936f0fc850b5bfe80af47dd99a09230586860f4c2dedc0361528dabb4fdfcc"
