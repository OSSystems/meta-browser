# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "551a301401305664de568b24d3eed8d5"
SRC_URI[sha256sum] = "20db91b9187bd5a03cd9084755ab6fa32230431a34cf005ac511e42eb3bfbb7b"
