# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e76d3d0d9a0e6ad0774d12ab27584c14"
SRC_URI[sha256sum] = "8bd25447406b43e05aec3e04332ec92fab82afcf0783c9c1d78e4f6bbd01e7f8"
