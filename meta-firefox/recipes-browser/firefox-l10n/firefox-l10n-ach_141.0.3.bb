# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2bc48d834f5b0947ef18a610a4533d35"
SRC_URI[sha256sum] = "2387cffbd07c9e2ce762603bcaa726dd6796ea36a614c5636263b34c4000b541"
