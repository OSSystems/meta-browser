# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7e99ee743b68d80a32022ffe796e8faf"
SRC_URI[sha256sum] = "ce10e8b07778bd1609b7d33b41130d69a1775392f1d83c12afab1e87e52082d4"
