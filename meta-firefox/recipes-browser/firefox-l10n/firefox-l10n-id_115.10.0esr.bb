# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "88a2a11a591a65844262fffcc3b1407c"
SRC_URI[sha256sum] = "7bfdab5aea278553aae69c554f046781a3e3934a420390a13d83a62ab77977e9"
