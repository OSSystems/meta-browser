# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "74aeb7c8a25113e05538acc2f3ce271b"
SRC_URI[sha256sum] = "e5823998c4311b92c4d52fe6a4090e6c17870d224c7539588498f140f090a9ef"
