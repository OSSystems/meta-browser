# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bbbcdffbb49b98246a5f03b35b6225e9"
SRC_URI[sha256sum] = "5fe4993779f82e97b8c2a9b1a730f121ee737a91f86660da4e751097f9aab48f"
