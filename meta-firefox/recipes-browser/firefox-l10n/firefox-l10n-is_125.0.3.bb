# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e9d361488b1ebffd49138aea4278d66d"
SRC_URI[sha256sum] = "cf9f136e371871fd56a63c89d8d4d585e90de85cc236deb870cd704b8f983ef1"
