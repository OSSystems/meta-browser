# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0a29698ee9bda7c93955ee6096ed3949"
SRC_URI[sha256sum] = "1828e90853ebccafb844c5e0ff42ef0af815bcde5ae7e0e9a887a773e4ff43f8"
