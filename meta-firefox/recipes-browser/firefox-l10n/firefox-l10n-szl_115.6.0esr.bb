# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a9753ca3eae996a765e79b818dd5cf97"
SRC_URI[sha256sum] = "9c3bd37b9b8fff5fd38b3696af213765b3d05493e5389fa440243fc9b4d115d3"
