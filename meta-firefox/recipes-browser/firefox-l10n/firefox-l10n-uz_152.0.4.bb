# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "17148ffc1f2a271309f1b019ad0b00feaa7c8d8e72330080630aff3977e87476"
