# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0037405c0671c41789bea21016359b81"
SRC_URI[sha256sum] = "3dd10e5820fb070b75ad78a928851e6d1df5409311a44ea66be6a430f1ba33fd"
