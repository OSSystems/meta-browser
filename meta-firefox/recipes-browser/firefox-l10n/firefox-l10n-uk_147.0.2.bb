# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3d86c44fe79b4c766b419643dcdaa45b"
SRC_URI[sha256sum] = "d7f187d1378758a8b773edf76b5c2fdca7d3ae73e5d9b20a41cdb019509f9e40"
