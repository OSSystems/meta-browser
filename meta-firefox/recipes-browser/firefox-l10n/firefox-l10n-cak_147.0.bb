# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a952065d02cedc304bb9160f9819f373"
SRC_URI[sha256sum] = "f02fcf103b59cd752a7aa2a8d572cf8fe3d3cbc1ae20c8f0f07dde6dd65f1576"
