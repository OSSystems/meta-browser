# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "70c2f5f9242dc078a6f35df6822b0118"
SRC_URI[sha256sum] = "1784e06d6ee45da8d4db52d31953e7bb11531df2491e757e518da403d06bcd11"
