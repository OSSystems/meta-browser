# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7f9e16f9f1c8b407c022d62ccdf46ca5"
SRC_URI[sha256sum] = "eccb34a6cfbea76e540c1263e8a4ed3a77eafd146f840755b757dfebbfb8918c"
