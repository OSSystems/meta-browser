# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3c6f0353d3b6e2789a28f321e7e7c1da6c06d6d3deb2d4568f8e6ce821359d1a"
