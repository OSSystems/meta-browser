# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ce76b1dea34b8b1150c652f4d889fe44"
SRC_URI[sha256sum] = "06910c75106d03aac6a50e68ebdf01ce5323e33d3cea1eb006c6f881c308931f"
