# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "259684ebc16fed644cdd6e9dd863aba2"
SRC_URI[sha256sum] = "48b5a9abddbb1d347500180a4c3bf49142de7167f3792a16a8683f796e208ae0"
