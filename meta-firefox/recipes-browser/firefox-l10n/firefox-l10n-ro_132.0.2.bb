# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "33cedae046426e0e3e51be761630e13f"
SRC_URI[sha256sum] = "f5a4c6ce488a8987599ca7a651e87d6bc9751627e0f65997f1f5c66b4f01ccbd"
