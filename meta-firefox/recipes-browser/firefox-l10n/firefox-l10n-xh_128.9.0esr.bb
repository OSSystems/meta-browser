# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a6a7096ac1900f5565cda5f1c9045082"
SRC_URI[sha256sum] = "5cc9b2d5d5f2e9ef5ab5b3a1cf53b9298991ba3db5fb5bbbbc42a071c759e2c9"
