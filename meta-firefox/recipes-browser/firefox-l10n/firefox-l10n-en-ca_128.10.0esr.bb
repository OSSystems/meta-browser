# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "496a5012dd1103fc4559bca927ae96bd"
SRC_URI[sha256sum] = "c34bb1edbdf3a50ebea28f3117e309635a5dfebc25d90ecbbd72a3d3e85bf111"
