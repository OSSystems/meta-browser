# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d06d046b1e82192f5dafa861e12be7ca"
SRC_URI[sha256sum] = "e2cae286d8dbbb57d2c34b9ee8d3a5be31a784357233b1a41291c4d27906c632"
