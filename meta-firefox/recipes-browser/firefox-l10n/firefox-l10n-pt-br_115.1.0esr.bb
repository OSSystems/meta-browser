# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c4458e47a3272af67fbb6ddb7dbc1937"
SRC_URI[sha256sum] = "2df1ae164f87dc765603713db04dbb47e991ef12ed3b3c1012295dcebc0e527e"
