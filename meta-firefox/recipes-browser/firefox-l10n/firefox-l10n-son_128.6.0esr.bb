# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "96bce594cb31ecdbeac1b630b3b31952"
SRC_URI[sha256sum] = "ecefafb6dd2b961084b9502f1ce7ee45ec88bd4602cedf31d194c42c8a67e18a"
