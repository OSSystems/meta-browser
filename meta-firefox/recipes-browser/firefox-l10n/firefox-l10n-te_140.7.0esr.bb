# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "317ecfb4a12bed03b98b6368a7cd9a65"
SRC_URI[sha256sum] = "5409824db0a490d3b476da4cb119bcd1a5df77f1f21bf62b884f0761cbdeb038"
