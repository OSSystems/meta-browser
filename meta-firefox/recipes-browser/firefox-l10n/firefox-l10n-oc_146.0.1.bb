# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "38458003e9c1eb531934d5a20ecd50f2"
SRC_URI[sha256sum] = "689178a47d1dbc91d08b5fb6b829add24d0a1644eaeee7ee9b4a3bda31e5beac"
