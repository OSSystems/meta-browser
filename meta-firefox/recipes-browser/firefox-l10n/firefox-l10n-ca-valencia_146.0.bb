# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aada654b58a4b3d47147104f4c5372d7"
SRC_URI[sha256sum] = "9df46557ec3d84e7a3220c3e9ff9818dabab78035d16cbf503766c0d82896b08"
