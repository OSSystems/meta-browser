# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ada4464f4686465599b7ee0029e4a4cb"
SRC_URI[sha256sum] = "b63e4ddae1be21134aa8c3f19a6b326e75393a38a6aef84287607d95c693b2ed"
