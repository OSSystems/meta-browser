# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ff3cc03b8a69a87608f38051e823437b6eecf988f9405518f411ef54a19ab9ba"
