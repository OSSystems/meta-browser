# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1651e380cb28659b883769b440df9abd"
SRC_URI[sha256sum] = "511b0717c3f6dc862321865fcf3b4559cef145a7149a229c829b30668c53a86d"
