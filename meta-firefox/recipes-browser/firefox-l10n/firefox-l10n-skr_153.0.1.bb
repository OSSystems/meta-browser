# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "b51f0fe6c8f994953dcc2ec267ecaae61961beac4d458932a97a2c2196e2ea38"
