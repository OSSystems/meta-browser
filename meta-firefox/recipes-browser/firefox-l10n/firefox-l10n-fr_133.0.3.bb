# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0a5960b50c7b9fbbbdd55db456b4db27"
SRC_URI[sha256sum] = "2d0fe3e0903e097ee2f370c8b4462f9ac08d41a46da8170f28c8267272eabf7c"
