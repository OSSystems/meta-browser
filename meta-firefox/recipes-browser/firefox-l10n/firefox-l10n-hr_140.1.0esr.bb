# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f82c4c15779a24ea4eac86c42750739b"
SRC_URI[sha256sum] = "2f4f98099f89ed2b03514cfe00ca0b0251398b4378d9a692896573e8f37026fa"
