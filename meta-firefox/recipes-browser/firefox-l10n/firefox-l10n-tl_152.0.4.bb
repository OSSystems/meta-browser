# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "0a1eb737aad4e2dfcc02337955e26b94e3ba40762319a616aa58aa706f261bc6"
