# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ec47a91e4a08f44fbe3912f1a797fbed"
SRC_URI[sha256sum] = "a7261f8afc35951b919c56c991b4f71c106f3d19e4df1e75ecde6c2ba3b69ab3"
