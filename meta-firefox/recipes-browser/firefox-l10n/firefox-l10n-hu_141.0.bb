# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "34e65b02de31cafca774fb5ad70d22d1"
SRC_URI[sha256sum] = "8857353779e25e649306de2192c060ac0aa352a86fee2804402dd983a0131337"
