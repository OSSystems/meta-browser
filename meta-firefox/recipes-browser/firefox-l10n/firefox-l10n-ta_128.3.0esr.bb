# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "875f5643e17e882bcac008deb65970ae"
SRC_URI[sha256sum] = "b429f9e565f118b6c9ce8cdcdb58836f92298333573a65e0a4fc05e461ce1e07"
