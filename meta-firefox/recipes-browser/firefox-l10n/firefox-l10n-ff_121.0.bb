# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "606c4c9644b5d4d384c670a981da54e3"
SRC_URI[sha256sum] = "6e3fd01daa626ae244252c249e398cb802e78e1c144dd12eb9a3ed3d9aeaa92f"
