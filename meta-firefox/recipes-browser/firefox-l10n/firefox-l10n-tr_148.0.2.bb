# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ce778cab178a2d29197761b7a9983139"
SRC_URI[sha256sum] = "2dda752c52c1d31e91755b32acf3693b597f6235cee72ecec65f585291ba643c"
