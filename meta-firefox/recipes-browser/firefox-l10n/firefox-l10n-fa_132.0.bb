# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8e4188200452aebd57e855dc76e62d65"
SRC_URI[sha256sum] = "7f1bd4edfc19bfd152a89c91e806ed3b1f1fd4af8bb9f94e5474549f90165787"
