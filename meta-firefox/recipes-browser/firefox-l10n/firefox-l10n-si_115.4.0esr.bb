# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9f30f5eddf3fbfffe7811d8ec3f63a6a"
SRC_URI[sha256sum] = "5f05b08280a10dbcfb2eedb032583f28762723f00d2c013d4fce4dbd2f0aba41"
