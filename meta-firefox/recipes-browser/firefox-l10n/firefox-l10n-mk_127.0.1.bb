# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c98343acd11848f640472bd0ac0fb1cc"
SRC_URI[sha256sum] = "d34e15070de03cdc74edbe36cbabf7ed02989997800c1dd9cce42d544330653e"
