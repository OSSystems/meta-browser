# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "71ef9df6ae73157a1365154b5e1409f8"
SRC_URI[sha256sum] = "b6e33eed9f3e2701af814bfcf3abf1bf71e204147619efd38b063d1eb40ae4a0"
