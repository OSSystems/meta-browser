# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "543c247917711bede8a7c61e6df24f5a"
SRC_URI[sha256sum] = "a029ed5ec5aa3452117f1d46aed29b06fadcb4e90e74dda31fe55cf371f2d516"
