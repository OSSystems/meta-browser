# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c7f5eb8562d95ca5c287eefd8ef8e5e1"
SRC_URI[sha256sum] = "7e3b1c7f3d2a5e0231091d6eec53363f9fb8880a4796b3651fcdf1a9ddf7d352"
