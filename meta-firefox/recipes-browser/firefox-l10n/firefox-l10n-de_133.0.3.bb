# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c2794cc2519b8559dbdd975f4dc13ed0"
SRC_URI[sha256sum] = "4a63253db8914729aacb7e2eeba409caa63a891298a5202b43123755ac4b33df"
