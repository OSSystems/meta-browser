# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c6482ed92ae9b56d7bfe6a11904e661e"
SRC_URI[sha256sum] = "5dad8dfb4751c585b0747a406feefdfaaea33d344d06e24a4b565a59c499ef21"
