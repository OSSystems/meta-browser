# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "477144f3bd6b12bb49de0d9797d3a397"
SRC_URI[sha256sum] = "3601e451082783131d67400977ebce0fe8cd400f599aef6cc8b877d8685ef960"
