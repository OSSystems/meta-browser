# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "99e55cf4211aaaa498db26997d4ed6a3"
SRC_URI[sha256sum] = "9f99d2751e3b3ee7cc98cdb16ac4dbb57113d9a49a5560b50a9b8690d7734a9c"
