# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "91cdad23e7d40bbc3d7020b12240fba5"
SRC_URI[sha256sum] = "d6aa43aea1b3fd7d42ecb451ddeed20c094bb421eb6f436db8d4abc7c8eb4383"
