# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0d9df708a19ffe23971b63b86286321f"
SRC_URI[sha256sum] = "cb44c6cb5d87a46a9825bd41898154d9dbff8a751ef01a788a0ef5e49b639695"
