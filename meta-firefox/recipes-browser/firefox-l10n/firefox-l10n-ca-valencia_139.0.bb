# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bc42afab572a9d769b5350893b37f6c9"
SRC_URI[sha256sum] = "ef79fe8355997fce1c931417552b3895c3ca7a978ec76214d3f34eb6dc119576"
