# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0a5c16635f17675d9aaead33f060f332"
SRC_URI[sha256sum] = "0cf0b2765cc36be48e8395287c1d0f9dac8337ddaec04ff2ecf5a781ec6145db"
