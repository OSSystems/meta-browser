# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "26e860fbc5de94bce72e6c85031bb1a7"
SRC_URI[sha256sum] = "147b8c51dcbe3b20a0ecdb7bf6e8e162bb3a8f557462a1d28577a47529d027d6"
