# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7c2dcbff097e48859768d917bda8b2dc"
SRC_URI[sha256sum] = "6ea82d87fe4c7562c13a35b572704eb0ae553a1815c62e91abec81490fd52e03"
