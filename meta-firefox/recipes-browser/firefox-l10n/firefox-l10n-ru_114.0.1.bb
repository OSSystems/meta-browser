# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8a672074e2b61f19c1697ac987f874e8"
SRC_URI[sha256sum] = "3a323502755b30757e4ae2d3e6edf79f724846b4a4e1697cc177ecf6b4395d7e"
