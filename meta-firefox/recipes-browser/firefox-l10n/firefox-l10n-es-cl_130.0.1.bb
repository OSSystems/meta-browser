# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7d79c1d312724004259a8d5d8c7e6798"
SRC_URI[sha256sum] = "c1fdbffba6f8ea29b2cc3990edeefea3fb703240334b12ec54287c9f05ea6974"
