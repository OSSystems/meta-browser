# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "59f5745b7fc4322cca5f0e2bece5d85a"
SRC_URI[sha256sum] = "f0a7553f47b119a339d023555a63b6ac0b31808b5a157c4ecacd95cb14b05eae"
