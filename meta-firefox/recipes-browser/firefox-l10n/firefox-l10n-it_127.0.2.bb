# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "63c0b968445da9d4917b549697479a33"
SRC_URI[sha256sum] = "02b96cd04f179a9cc214454c47914af7a595b4bc923e5d93a6a7e2eeca4474b4"
