# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e6949d8f6d3a3082c4327d2967e65ac7"
SRC_URI[sha256sum] = "8e267a1450c63dccdf8dbeae2498a314e415c6799b3c76dece77e922c8d9b009"
