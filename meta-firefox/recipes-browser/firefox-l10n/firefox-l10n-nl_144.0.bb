# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bc294f539639d2a0a4448a2faa37036f"
SRC_URI[sha256sum] = "fd576de80df09e51e0a3820d0383566d0b3339090c8bcc5d685c23734eba7581"
