# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b73e5a0e85e773ed4784e40292a7fe82"
SRC_URI[sha256sum] = "4a29269b0843b367dcca59d1f63581a580f154850051fee95547ad50fa7beb26"
