# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dde7568f7db67bc87223b2cdbc44eb0e"
SRC_URI[sha256sum] = "6c5be5148847c60b9a6959b371fa7e672170c6bf8a13a9d78a7d8306e060f88a"
