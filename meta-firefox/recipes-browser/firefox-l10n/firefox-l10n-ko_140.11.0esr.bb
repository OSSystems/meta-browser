# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "82daaf8782ce05e906c87fa66b6159d237f1e92ce3ee56e75c82c979eb71ec78"
