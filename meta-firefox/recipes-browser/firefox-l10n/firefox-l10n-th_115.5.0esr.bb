# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e2109200742d4fc1e324a9d04af36159"
SRC_URI[sha256sum] = "2c526eb20c556ef56080e8e48cf2f15a9fd7093c5fda0559876e932e73653857"
