# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "da286a75589c77682439d0f4b375f2c1"
SRC_URI[sha256sum] = "91725fcbdc4209c95f9502b7c8c02b84fc5dae741f14df2778babd6a34d333a6"
