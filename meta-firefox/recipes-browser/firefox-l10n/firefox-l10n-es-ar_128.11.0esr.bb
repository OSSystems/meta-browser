# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "159892d71619d91f1162ffb0f75b8c64"
SRC_URI[sha256sum] = "4160dcf175234f8d0f825028be232a9fdbd8d97681a639f2a4f119d9f0866eb9"
