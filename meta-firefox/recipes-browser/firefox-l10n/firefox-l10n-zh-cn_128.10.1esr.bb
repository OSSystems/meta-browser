# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8a0ba4cd2d177ccab791982067a164ae"
SRC_URI[sha256sum] = "a9c821fc43653f71bd9de1dd3a460523b6ec16af82b76cdfa3f95c9398b7177b"
