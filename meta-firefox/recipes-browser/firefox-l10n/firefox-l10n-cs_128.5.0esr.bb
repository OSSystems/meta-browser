# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dfc3f5071885fb84cd5abda8823755d0"
SRC_URI[sha256sum] = "d712e90877ace019242b36266cb2920100b13c2841ee3eb5c4a8f2432f0a0024"
