# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ad4ddb659f384e32187cec0c9192d0a828409b2d4bfd9420fa1620b8673c4f96"
