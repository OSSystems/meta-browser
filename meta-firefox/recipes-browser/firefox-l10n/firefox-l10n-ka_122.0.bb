# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "326aea64ea4afa25ffb5d38fc8f60ed3"
SRC_URI[sha256sum] = "0c50e9c667e67904067a81954d511912002bb2dd5496b44c0beb28055d809217"
