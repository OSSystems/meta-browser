# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ad9a0fb404c336d31d61de9499c4b097"
SRC_URI[sha256sum] = "f4ae76517026d71a48f14aca0d1b14675925a98664ceddd83a89707fe5437ece"
