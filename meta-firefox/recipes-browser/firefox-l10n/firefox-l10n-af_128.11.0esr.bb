# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7732fea91ccb6a1852bf9e8d1f2e1842"
SRC_URI[sha256sum] = "a3ca11abc2f89f25136d6858da11190d48114b59fbee1129c73549441dff6677"
