# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0151d591e479784454b00fa01a5b973f"
SRC_URI[sha256sum] = "32ec05a53ea058d49e8a84b8b7bf5f13b7563656a7f54c03802515ad2cd54585"
