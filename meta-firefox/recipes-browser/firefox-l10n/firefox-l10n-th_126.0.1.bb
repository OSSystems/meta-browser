# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dcba8381676a9dffd007cdf2b8a9b343"
SRC_URI[sha256sum] = "9c8c5b8cb3b92d63593b569254022e2879c890ea90e5d8a3cc4d9c03dfaa7867"
