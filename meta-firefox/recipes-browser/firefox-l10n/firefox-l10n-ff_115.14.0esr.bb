# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1c2c086f81789c0cbadbbb3061ae98ba"
SRC_URI[sha256sum] = "e1cbf845c76f9aa5a847d4645454a4485a0fc7d158c8b970bf7190e2f133ba64"
