# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2f9c68d794051f7cca560ed92c74902f7ea2acee2d8b21ca087909c28e8fda75"
