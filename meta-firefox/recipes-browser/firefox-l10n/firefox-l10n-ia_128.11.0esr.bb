# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "590f277c062a36b0c8008e43108d8df5"
SRC_URI[sha256sum] = "fa14357107e27f2fdf0a5756962a4feaf66e440f00a9eb45134333dde3140ba9"
