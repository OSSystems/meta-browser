# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "36da86a97dd8bb3ef619b87a04fec539"
SRC_URI[sha256sum] = "ce247a9a2fbe20f68c8aa7bc0d62d31123afa84e8cbcde2593ca478c6a4ae81d"
