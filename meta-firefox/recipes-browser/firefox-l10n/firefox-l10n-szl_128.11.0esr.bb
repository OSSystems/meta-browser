# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3e1e9807e956da975a658ef2acab5e1f"
SRC_URI[sha256sum] = "a298ad7ad2656f7ada25f67750c9fc2b76edc37d588b96b95acc46e0e750edb1"
