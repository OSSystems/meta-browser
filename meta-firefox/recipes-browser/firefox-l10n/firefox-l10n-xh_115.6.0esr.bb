# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "23338b7639fee7784fa4cdc97a5e6245"
SRC_URI[sha256sum] = "6b2c1a750bcb3e628092a8155661498ae861cb1689747cd800a915255f139b07"
