# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ea7255c6a597428876c2b3ab2f0322d7"
SRC_URI[sha256sum] = "6595e057053e2de39626f4d2d5736397e3b3f354725d9209f564e06930632e73"
