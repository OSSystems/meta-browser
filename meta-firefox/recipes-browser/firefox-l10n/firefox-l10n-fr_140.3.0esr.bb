# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2bff426f2c0e9bfb7f239c1d79b14eb4"
SRC_URI[sha256sum] = "ac8ea664ff79c44d0b24ec26f20e73b8cbc5d97f7c8eaa6b14e823e2bb47b1b9"
