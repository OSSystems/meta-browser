# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e1d269cd82d8e0d41a6f2e89fca5aedf3a925b92d1cc1e44aa6b0ba62474004c"
