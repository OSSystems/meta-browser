# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d503fd1f751eacc2c4d8a577840d503e"
SRC_URI[sha256sum] = "043d09d036a8eda957265ccd8ea18e7aa611eaef782bd4c7cbf9300670711f7f"
