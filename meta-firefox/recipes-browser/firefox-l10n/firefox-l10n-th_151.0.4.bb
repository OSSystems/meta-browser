# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "a1389a0fb7327d87871c45f94c013e9ccaa22537c19edd0e6139294f29500400"
