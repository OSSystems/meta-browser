# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "625eed48e6e460d451a21dc2508f48c8"
SRC_URI[sha256sum] = "5b93a2f998021372d58e543449331f625fd3d36d24d28e07f63f52488e8356f0"
