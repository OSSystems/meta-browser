# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cbec100c5a16be8b1a766736a0120fe2"
SRC_URI[sha256sum] = "32dffd560243fe4365749c84464c0f23d28853740acf6a4f65acdd873c063d70"
