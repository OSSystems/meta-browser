# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0abcf2523eea56ece2b6d1cb6c35d754"
SRC_URI[sha256sum] = "3bb616f5118f217760a4e33a2f632cfc8a001ce57b76f01e59cd45f2140ed9f8"
