# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ea4a91ebf44eac1d75cb82edb1338e68"
SRC_URI[sha256sum] = "811eaaa150c4e3839d55bb12614f19754232ea733be554e34fdd181a65154afa"
