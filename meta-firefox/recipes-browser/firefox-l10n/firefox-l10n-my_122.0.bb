# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "31d953debe0b80dcf527b6583254fb0c"
SRC_URI[sha256sum] = "a0dfa74bf30a668bf2b7e415e89bcac7b6e90c29da4a51d3b3a4bde0008247dc"
