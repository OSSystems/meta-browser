# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "09ce452b3d29016b1220b78a951a845b"
SRC_URI[sha256sum] = "1c96eeeb3e622ed00229f9d3da896f98906be636244e13321f16d07f10f120f8"
