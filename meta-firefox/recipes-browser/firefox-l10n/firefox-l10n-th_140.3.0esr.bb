# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bfd6cf1803f3b105410595e55a2b8e5d"
SRC_URI[sha256sum] = "de07f378bcacba6990264c7ebdc7546d8bf6398ca729d592425b80ddf1a883f9"
