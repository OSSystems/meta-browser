# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bb615039d296c96195ad1f1af7b26847"
SRC_URI[sha256sum] = "6d5bfdf051a9c8b8fed514d13b8942fa95e72dbdb31ae3bff1eb50bcc13a6ea5"
