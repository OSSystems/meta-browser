# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "96d27edf0a4668e5ba8915bd0a91998f25e53a822315be0f88c85ec80b2cddf7"
