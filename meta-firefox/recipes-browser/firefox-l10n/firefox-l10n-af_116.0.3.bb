# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8fca38dcd6a56ae4ed7d7c6434a901ee"
SRC_URI[sha256sum] = "4235f67ae814dcaaa173e2e165f203c20b8a546f883f4ed2634db1ffa333d561"
