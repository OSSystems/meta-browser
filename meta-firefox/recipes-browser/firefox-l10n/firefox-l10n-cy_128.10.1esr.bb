# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "74f6da99020334401e600fda8b7e02cd"
SRC_URI[sha256sum] = "e6cf350c796446b1ce2ddafdd612514cae35f4a00693bef504c3d62368e68a83"
