# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "105d98dfe969db5a09c907c7641f3a80"
SRC_URI[sha256sum] = "80732a656e51ed41a0c2583a6b3386413c65ac96e3bab40d93a767c910efbf9f"
