# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "52d239972dfc776a96bcc6c288df441f"
SRC_URI[sha256sum] = "2d4fa9197c77f6df1469ba7ab075946109ad89fc563575a8d1cf3fa3d4f6814c"
