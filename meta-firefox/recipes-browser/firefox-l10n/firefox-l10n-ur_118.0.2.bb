# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1f446be6b6ec6ac73c2a3976c75f7b71"
SRC_URI[sha256sum] = "2447f72d35349f40abfa492c42342114aba3a8e48a59c3f61e1adb7354b8c186"
