# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d157b260ddfd421e0e459d8e595fb861"
SRC_URI[sha256sum] = "e42f001edbff54bddf41c7101e65e9efa99dae0313c97138e376a55f3b71f2ff"
