# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "80f0c9324203f2c51d91617db96bb5a9"
SRC_URI[sha256sum] = "2c29d24ddaba848f8b24c41bf0c0b630a80cae07150cc4af032082c831aaa930"
