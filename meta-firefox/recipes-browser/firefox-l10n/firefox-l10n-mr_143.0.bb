# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fe00d828333bc8ef4d9179d8c61d26ce"
SRC_URI[sha256sum] = "bb2f69010d85b2fa9fe9cf6fbb402973fd72e23bb2621b5c2d0a2892505ac9f9"
