# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ebc8564f17ee1baebeaaf8130c3ba83adba287dd2a109bc80f227c7b79906dfa"
