# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "011c938f8e1fb67f855cb2322ec896e3"
SRC_URI[sha256sum] = "82a2cc95323e7291c30fc68c7137a30817a3d9558a1d130405f6d509b67d93f9"
