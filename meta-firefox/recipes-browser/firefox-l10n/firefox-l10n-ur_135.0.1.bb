# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "48cf9b79cf58cd712f94e63dae156f8b"
SRC_URI[sha256sum] = "da249569ffb7f7e0db96a0127780358b832cf3d963161a959c8fb2e1bb40e8bc"
