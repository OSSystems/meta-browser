# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e16698ab495cdbed1d9f34dae3194335"
SRC_URI[sha256sum] = "e72e434ad1b492b909cf54c2ced1f3865fa1676ba7630fdb22a70480bdff6bb4"
