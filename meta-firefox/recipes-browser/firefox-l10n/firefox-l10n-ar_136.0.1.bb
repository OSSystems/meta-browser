# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f8ec5b8a16236c706846f7d803f9881c"
SRC_URI[sha256sum] = "4088df9c95b08bfe6aea302c54db245e75f1ee45acb925294c37f7b2eab3f2bd"
