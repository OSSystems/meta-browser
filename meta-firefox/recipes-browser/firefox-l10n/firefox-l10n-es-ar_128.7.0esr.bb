# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6dd5e380338017dd91d96d02c225cb90"
SRC_URI[sha256sum] = "c2382683165893b6a7bf2a17c66b2fc156dc5736f62abc4c7b105e8bfbe45f7b"
