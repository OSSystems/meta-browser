# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c3a9c5f0fa32622d3c17322c4aa5a0b7"
SRC_URI[sha256sum] = "24255b37895e3e0d3736c3c14d948df64b74c3c66a59477b11d85ebf2ba69080"
