# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "42afc4120996eda99cb4d9af6051578d"
SRC_URI[sha256sum] = "b6d860bb594ca4a3c706228ef56cb44afbc1ceac04b48acc2dc34d6846a1fbda"
