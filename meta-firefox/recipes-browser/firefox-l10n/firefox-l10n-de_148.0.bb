# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3647bea672d1ca2efef7cde5611286a4"
SRC_URI[sha256sum] = "9bdb39dc82adc1d14d3b79d2a1e5be4a85babadce6e2b129716af7d688ecbde1"
