# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1e48515d72a42c892ff79698f3ac74b9"
SRC_URI[sha256sum] = "f30eb8cb7996446f8e4f4d42fa754044af71c081b3ca0ce22636ebc8b8ea7f6d"
