# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0aca585a9c7de02b8323bac300e1ef45"
SRC_URI[sha256sum] = "d881fcc44d76eb166411cd7147c9f70f677443b83fb4dcfa951aebc2a551dc74"
