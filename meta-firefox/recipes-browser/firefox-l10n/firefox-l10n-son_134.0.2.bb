# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ff9e9205678506b6a5e95fa9168ba093"
SRC_URI[sha256sum] = "f406f673e63114ccf5a830dcaf8a5312f9a91ed6081d5ba1e1b4d5b45b3cbf9b"
