# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "965a877e49ea88b03c1004e011e49119"
SRC_URI[sha256sum] = "a468696daea34a7db160b9049cd4a893dabe1c0f377ef3df8a8e18705337fc8f"
