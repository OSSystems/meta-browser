# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "85a513f29423353038d18312455fe8d7"
SRC_URI[sha256sum] = "c092af717b8283a818c3b2787fde2e271c70778e4e3c2cfe6f3c4ba98a901473"
