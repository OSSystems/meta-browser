# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3ad61e6930161d9c1f9a36de69d86dc0e9a19502910f3d1321e0f10e3bbeaffb"
