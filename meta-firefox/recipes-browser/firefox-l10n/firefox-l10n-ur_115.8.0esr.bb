# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9d2880a60d3b657b82f427f1a6d14499"
SRC_URI[sha256sum] = "bbd07b73683e1cea58260b9c15b1da9ea0d7b45b0061176e19f4f00fab17c788"
