# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "af3c9ca2fa0211ad08f97ebe5f852561"
SRC_URI[sha256sum] = "9c433b11a58ea28e82082f37f31da93a45f3c8f2201095f5f51d17ff813b6aa2"
