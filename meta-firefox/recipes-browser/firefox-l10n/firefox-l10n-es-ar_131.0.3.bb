# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "82294a852d780edbb1dfebffdda4725a"
SRC_URI[sha256sum] = "64709bf3dbadff2c430cf496dcaeb7b49edc4c2de77e5aa819d8cc2945279579"
