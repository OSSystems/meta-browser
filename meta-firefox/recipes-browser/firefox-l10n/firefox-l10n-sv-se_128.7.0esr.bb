# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "75ee2c956b8e81b88c25d33db5f80c57"
SRC_URI[sha256sum] = "73c54fb8fe159e8db3c71a9bafe76774c98b61f2608fb1fcce853f701e81604d"
