# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c53bfcf04c8bdacbe8359ec06ec1ee49"
SRC_URI[sha256sum] = "c1e73a1a3f3b300110ab691b51f6066b27454e5a988163bc45123acabc8a9f45"
