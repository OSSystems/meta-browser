# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4eda2a85f153a43d3b763a7a0a6dd853"
SRC_URI[sha256sum] = "1e4a96d6661db46ae847b9af88fa906bf198605309d2e2a932405aa5df05a793"
