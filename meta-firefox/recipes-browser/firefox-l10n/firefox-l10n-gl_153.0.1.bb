# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e746b4d00b805700c69b60c1a19ba3816ed641f6e160b78d1b0525df790a8531"
