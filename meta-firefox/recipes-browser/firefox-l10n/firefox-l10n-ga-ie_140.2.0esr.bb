# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f0dd89475463156a49a3234bd5604070"
SRC_URI[sha256sum] = "45d571f6262f2a1fedf0521f960d6968a3340aebb27c115d9375d6aaf7daa6c1"
