# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0902a6080bd0eb293246f043697830d9"
SRC_URI[sha256sum] = "d6a09a7b1bb169e2c99f2a9812b32521b8900a0758e134431c4186a197693d9b"
