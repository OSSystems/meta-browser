# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4f5cc71ed11273c2128859d1334dde08"
SRC_URI[sha256sum] = "747d12c6f6a0af47fba12c23b755dcf36d885283e96bf0f166026ee333d1892d"
