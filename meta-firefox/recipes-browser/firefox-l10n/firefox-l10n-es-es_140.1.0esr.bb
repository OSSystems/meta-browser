# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5cc555e4c8ed2a915b6c06968db94fd7"
SRC_URI[sha256sum] = "8573aa3f97c3d4e0ffc4d5fc413a2d162aef3a2d2507c79ea063e14ffa1b7bd3"
