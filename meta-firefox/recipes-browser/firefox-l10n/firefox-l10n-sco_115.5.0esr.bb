# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2a60039e9f199d22b5d43a498a9244da"
SRC_URI[sha256sum] = "8d8e524189d284afa9a2f9243fedb14fc0dcbef3a949a44d4c28ded3ea5c1ea2"
