# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bcf908b69c78d1ccdb7c5a3d45ad6ade"
SRC_URI[sha256sum] = "3381d619a35f1844f07c917b3ec5982e6f82d68407165ef6b5d480c323476f0c"
