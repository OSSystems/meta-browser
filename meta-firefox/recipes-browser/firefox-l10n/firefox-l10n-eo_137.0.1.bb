# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bcb067deea78ea53be5c253f1d7a8af8"
SRC_URI[sha256sum] = "ad33f327afbc26bbb6f2368a210e45de10e6088240328ef81cc8ed26733a450c"
