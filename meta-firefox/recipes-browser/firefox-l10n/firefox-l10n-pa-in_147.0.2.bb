# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8fc6cba65e512bcfaaf6c47ccb8d4bf0"
SRC_URI[sha256sum] = "70c2512187a553376597fabfe540c9904ade8cd64777aabc14369fa19d2c78d6"
