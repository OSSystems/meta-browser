# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "512cb9b4c56beb9472aea259e06e469c"
SRC_URI[sha256sum] = "b26cad5dbb1f0baf44cf18c017fe2d069633560c72b0afefe9fb1164d9b46280"
