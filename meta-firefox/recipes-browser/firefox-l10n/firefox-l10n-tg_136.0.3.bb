# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cb66e4caa7d697767b0499fb4fd6f9ba"
SRC_URI[sha256sum] = "497e276ce80396701418337267993f8ce2efd4f1a0fa89e3237e2b40dc1aeaad"
