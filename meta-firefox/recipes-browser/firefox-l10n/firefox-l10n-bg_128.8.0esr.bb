# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "50f1c1f357b4ceec21dc556d70903add"
SRC_URI[sha256sum] = "adbe9ca064a69b9fe1c45ddf7b83d7f9aec7f4b0744b10d1d1fa0e99e49dc4fd"
