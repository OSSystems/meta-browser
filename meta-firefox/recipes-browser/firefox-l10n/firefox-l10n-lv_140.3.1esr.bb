# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dde4147fbe1e28778004b48724fe7c0d"
SRC_URI[sha256sum] = "e2f97fcb90112f12582ac41b48cbdc720a4da48766bd130637bae6fff1152bc4"
