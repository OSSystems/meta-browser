# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "305ab2efc87c6637350494acfe846796"
SRC_URI[sha256sum] = "0b477e1fcf4bc3c737c6fb70edf5e2aa52252cfaf8ba419f3a31c33147f74d43"
