# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "68febcb889543234fdfedc226fedba4e"
SRC_URI[sha256sum] = "b2ff2f5a7ad0eb07c8ad14e3f241c2680cb62203ed8ffa90f5892a68ad64bbdc"
