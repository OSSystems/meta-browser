# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fa4d0dd60784e47bc1a61a9e3fe53c9e"
SRC_URI[sha256sum] = "96ed98b7c82606b7bd2d0b42028a6b202395d780a48551c7b3762e1d09e42753"
