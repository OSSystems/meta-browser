# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "15d19220559f8f98df8ed88da86b7181"
SRC_URI[sha256sum] = "56540c0607926a762a8c53e7231f978697d2d0381737eba01f8f3b1727f82eb9"
