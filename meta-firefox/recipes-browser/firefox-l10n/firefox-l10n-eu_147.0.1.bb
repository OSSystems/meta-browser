# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a19f4d622b8dc08257e888195856182f"
SRC_URI[sha256sum] = "87d260a6fa78a398b4004b8c4b91a2a6e5cf0b373c795b975e01a73e1b6c0ec3"
