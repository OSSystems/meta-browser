# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c87bf1321eed710da89e39fd132be470"
SRC_URI[sha256sum] = "4d57ea431a4ab79d330b516c7daf4adced76bee97b78b1cdc470db880c672739"
