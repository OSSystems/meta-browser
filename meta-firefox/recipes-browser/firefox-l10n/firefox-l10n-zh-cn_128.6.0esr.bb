# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "277b0e8524b367bcd79d0255c5b2fa37"
SRC_URI[sha256sum] = "b591af8177c2737e7eae0985825cf968e0642663be500963b9aeb4e49f92be01"
