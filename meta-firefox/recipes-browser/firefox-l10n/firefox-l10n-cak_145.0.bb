# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "765d9355abf03c9dc113ddec4b34ad7b"
SRC_URI[sha256sum] = "5ac0c47e824083b0ba13584458ae894f574a5a25a109261762b2e04661736339"
