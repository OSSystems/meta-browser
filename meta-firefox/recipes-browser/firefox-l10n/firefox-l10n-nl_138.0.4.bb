# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "37443fef4debefb2042521a88b16f64c"
SRC_URI[sha256sum] = "9c6e688de6c9fd5938e43782ecd880c77a14884916c29ee1e8c9bb3a9a3fc05b"
