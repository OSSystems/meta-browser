# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "127119aa3d2b9118c4421d25e2a04148"
SRC_URI[sha256sum] = "62956781b95c5d212e96773f1db34ed5f1c8db518429d9de4f1de175b054267b"
