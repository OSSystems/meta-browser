# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d579cb7d458cff37ace554bc8e730d1b"
SRC_URI[sha256sum] = "5790c1cdeee14f1d6288588bf22fe6f04db3762e26f970e2f99008667714ac49"
