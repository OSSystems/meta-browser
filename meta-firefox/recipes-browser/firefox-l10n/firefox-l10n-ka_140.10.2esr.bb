# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "b5425493a5eb93d687a366f8a76a3d40a46f7022a43c9c427dbcd5b208145d15"
