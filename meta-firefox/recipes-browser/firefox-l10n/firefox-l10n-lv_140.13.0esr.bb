# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "619430261e2721dc2b1cd50cc5ef63bdebb623f5253371661c7bac932e0733ca"
