# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e9456b3d69563ce35a4446973ce5da92"
SRC_URI[sha256sum] = "a1dbf126dac0574402a66cf96b9199b572663dc8bc15031131f0e3230b873a88"
