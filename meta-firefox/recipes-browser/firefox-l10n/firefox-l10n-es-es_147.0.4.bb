# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1435ed41413caa444836a6fd41dd6666"
SRC_URI[sha256sum] = "2fc5d75fea8147e37e1863088bab28257f72738fdd34371fe86f39af6df9987b"
