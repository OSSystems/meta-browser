# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6618b575805a356ab901c75261d42119"
SRC_URI[sha256sum] = "ea3f6bc85b4d74fd36112416ed769a1cdadf8b04572d4cdfe7e57086c23843c9"
