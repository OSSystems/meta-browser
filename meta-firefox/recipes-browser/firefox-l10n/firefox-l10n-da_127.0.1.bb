# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5587a74e8a2542f4a6c7d18f43d51487"
SRC_URI[sha256sum] = "bc2ebcbe00a7390efa640209d481bcccce8eb51aedcca44a9fa3106297a38379"
