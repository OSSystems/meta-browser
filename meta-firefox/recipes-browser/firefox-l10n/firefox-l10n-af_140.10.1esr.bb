# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "103de3326fea3ad4079cc8eeda5b55428659c6154c7ee18c89676391e4c190da"
