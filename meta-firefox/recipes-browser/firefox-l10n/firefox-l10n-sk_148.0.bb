# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "496d5d9173f0711f21d756c697fd3488"
SRC_URI[sha256sum] = "97f628aafe7777296496e4fa661de1eb29990b5aa83d2179ff81abe0cb9df194"
