# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6b0bb93aec650ba75097291db64bcb3e"
SRC_URI[sha256sum] = "0516487bd084c80f7ee6387af136fd030e40bc359dc02fcce073aa28e51fffc0"
