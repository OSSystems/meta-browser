# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2e4e068cffeaf33e9ac500e9c37cbc4e598beb7dd838dd1f6289225f62556775"
