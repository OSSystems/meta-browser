# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "91d171cfb880b18bbbd6e7f93f077d1f"
SRC_URI[sha256sum] = "abbbf53912533c2fb3ae7d0d699f429909509d9b648f34413f1880fce4e45325"
