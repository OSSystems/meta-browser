# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aa9654d9ab4fa28d02dfce76c8ae400b"
SRC_URI[sha256sum] = "8391006c19ed000cdb26de11b60b4c067d04f2835ef1eeb932ad2161df8ac863"
