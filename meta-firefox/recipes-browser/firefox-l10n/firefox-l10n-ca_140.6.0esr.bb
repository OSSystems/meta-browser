# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a389566f5886bddae054e5bee3b5e5f5"
SRC_URI[sha256sum] = "a4241969ec4f0420bbea17945754a052c56d5f224da5883bce67af0a02b74a76"
