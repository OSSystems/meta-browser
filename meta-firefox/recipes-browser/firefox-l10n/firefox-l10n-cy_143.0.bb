# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "79ea116b69a29e2f40a3577848d27521"
SRC_URI[sha256sum] = "9025773c653fcb2a267d70924eb73de0438f01f7941e4afdc2d2ef5614290deb"
