# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "597b2bed2a6c4372e2edf90a79ce8608"
SRC_URI[sha256sum] = "e05483c991d2e778fe971f34c219a804271a3ccccf0f2245e37b1530951953a3"
