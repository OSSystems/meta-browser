# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "01881a0787063baf436d86026891126f"
SRC_URI[sha256sum] = "fcd1cba00f64460f90fe0462cc39cf4df4402eb57f6c2d90e14e7aea1e6be8a9"
