# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "79097c5fe07bf1ef75c4e4f9568e739e"
SRC_URI[sha256sum] = "4bf97d6a17713a27552051aa928a833619d34692b36ad90ad7791e8fab64d517"
