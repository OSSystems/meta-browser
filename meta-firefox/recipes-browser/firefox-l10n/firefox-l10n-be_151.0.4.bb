# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "fe3fff4a74c31610364ea53cd120b0891bf65ca2efb1656dd76bc4afd6b09779"
