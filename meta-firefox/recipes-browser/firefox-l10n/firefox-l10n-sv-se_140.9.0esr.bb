# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "de5f79833aecf2fc096632291d123119"
SRC_URI[sha256sum] = "d3258f16b3a19acabd76086a99eb66577a15b379d5ce0c1ce58badbcbb2440e1"
