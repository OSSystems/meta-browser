# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cf7bfc598b6d2a03b0c85ab7a01563c7"
SRC_URI[sha256sum] = "3bf5ba88894b4adc082429b37e29b4fa45f02d6d2ad4f6095b864cf097aea182"
