# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cd981b5f6bae3d1368e1e51526620008"
SRC_URI[sha256sum] = "12e18991b0e4cc7ad243e2d2e5a63cf38bd75d522f0724d101fdfd716f40c3ea"
