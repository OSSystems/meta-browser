# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3042fac271197dd82e1ed82fe9714897"
SRC_URI[sha256sum] = "bd5ddd3f18f33e1be4b6d761dbada78c276ef92bff1bb342d0775810aed871e6"
