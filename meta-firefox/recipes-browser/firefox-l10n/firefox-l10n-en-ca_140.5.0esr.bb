# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1006c1b847b9d752e55ddafad7ace588"
SRC_URI[sha256sum] = "b37e96edbdfdc29a79e2d269b39029381cf0502b43e990cfbab74b536d91d0a6"
