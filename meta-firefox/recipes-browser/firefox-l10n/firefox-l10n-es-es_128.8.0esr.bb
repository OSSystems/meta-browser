# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "508fa2c43108793b0d4170bfd96a6d8e"
SRC_URI[sha256sum] = "0071bde7aa64ac0b75477693418068bb403ad25f007ee44ba7a38dd409096683"
