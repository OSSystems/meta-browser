# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4fc634d95ba80f28967e9eaefde39042"
SRC_URI[sha256sum] = "16e86b6c1942650877334b4e8afab659a20736430746c972ed34f7af905cc1e8"
