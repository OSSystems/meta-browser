# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "5cc88c3ad7b9e5f340ab892a553eab2dfd1328d09a48cfdbe83d4753c044d840"
