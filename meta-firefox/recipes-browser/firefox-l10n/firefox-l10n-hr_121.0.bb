# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fe108f67d2582427347e59012709f0b5"
SRC_URI[sha256sum] = "cd56d28d0850fcdb70b0c3d77efec17ac35aed376b224eef8a2bfa5c71f037f5"
