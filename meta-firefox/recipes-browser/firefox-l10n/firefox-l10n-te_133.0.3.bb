# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "978dc111007a6cf79f8df45eab2f61d5"
SRC_URI[sha256sum] = "eccd24aedbc39c87ccceecf85060e9ca684f4a54d18caf05281def58f5aab0e3"
