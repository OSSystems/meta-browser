# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d9dc6dea0805287845fd84e1ae11cf5132ff7c000ba25712c8b1336e40388510"
