# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4d530c7acec4ff6d35c6bfc871fab716"
SRC_URI[sha256sum] = "fc39bea8c701934051684a9d2f549af0632c0c533089b217d376fc525d22521f"
