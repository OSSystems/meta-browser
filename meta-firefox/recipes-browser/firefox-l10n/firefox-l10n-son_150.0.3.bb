# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "59dfbaf36e8cb083d3708ef5f26034b5a3fe9825b298d2a4bba4b3b585e6b29f"
