# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "57e5e1603fea735d2de06602daabf4cd0b16e9c9742454d5300782585b9b9174"
