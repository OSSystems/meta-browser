# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4c288d3860baf14684474db4b1a1787a"
SRC_URI[sha256sum] = "f94554c0de390c475acb75016f8630c4ea37e34c96e189964e531118f2e116e7"
