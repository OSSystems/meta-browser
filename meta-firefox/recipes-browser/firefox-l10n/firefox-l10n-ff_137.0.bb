# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "23b12785123ee8b02a64d53808931e21"
SRC_URI[sha256sum] = "096c0f14fe4a0443fbf6705b03aa8fe0d547ffe8b24bd2dec2a28ace08a0c633"
