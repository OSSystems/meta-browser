# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "59369c9793a815e7002af2c927978e05"
SRC_URI[sha256sum] = "4a4d41d02bd64666541362ad54160e264080eaf6c445cf009b60302ee84e0621"
