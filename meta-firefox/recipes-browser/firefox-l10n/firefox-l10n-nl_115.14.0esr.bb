# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6b0d17f3e1603ec8f80a7b08495b42bb"
SRC_URI[sha256sum] = "748ff7558d58c73a6a789466d59d885939475f02daf77d464cac1134849d851d"
