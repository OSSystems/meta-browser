# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7f9b2e3c0f1ae6ee1b95beebc770b3fe"
SRC_URI[sha256sum] = "9f9562cd1eb6b0883b7d20186075c9cfaf68d3d173f4b13320dea3f011ef5c6e"
