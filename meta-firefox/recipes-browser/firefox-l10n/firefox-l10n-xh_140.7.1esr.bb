# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e617c465ef7117f8a0b8b82b9a04b09a"
SRC_URI[sha256sum] = "0269c3aa784d3aec636c5a45d9420d27e9b726b56986defcd8e6ffe334b13627"
