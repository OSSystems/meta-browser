# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7bab82ecf77d0f11767f9d4729f91918f66f91c49bd2a7e7aea46ccc75759508"
