# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f5c6f262de5037d1bc04e03d6522f213"
SRC_URI[sha256sum] = "4c8e7417476441a231c11601f022c1444dfc5af7c3c8492d3fcb89e667d23b02"
