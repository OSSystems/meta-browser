# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "888ed08d7b15f226d477315bb9b5353c"
SRC_URI[sha256sum] = "1134dee305ae22f2c39d2eb4f9b17b1e2dc42a2704f05e0cad9bd23e8daed4ac"
