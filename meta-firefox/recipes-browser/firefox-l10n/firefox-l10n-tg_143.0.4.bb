# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4bb52840c7f65bc7ec7a718871bfeb51"
SRC_URI[sha256sum] = "4a316446c3f366bfe1199bdb36bb6a6f7104397997618da6b246c9e7d65c81ec"
