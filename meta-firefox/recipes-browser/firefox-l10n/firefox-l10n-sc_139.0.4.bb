# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4c4d112d9b0e6880827a5088cef9d806"
SRC_URI[sha256sum] = "7925b878c5ce5b62dc0d04ab1c3644501c640ff52850be562de8250f908fb5ac"
