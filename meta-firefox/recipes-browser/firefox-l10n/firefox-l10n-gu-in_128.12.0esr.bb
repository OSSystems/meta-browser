# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2892d95177dd56fb11b25119809dac44"
SRC_URI[sha256sum] = "6c0766de21fc78ad2736df9f420f3f2ded0aaeb5fba523de33efe987036dc4c4"
