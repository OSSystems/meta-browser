# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a00fae24232f9cdc76f6ad5900dedda4"
SRC_URI[sha256sum] = "f45e2ca7230a65ed4d817af2bbbb4aee6a55eccf5ed631bef5b349510097f61e"
