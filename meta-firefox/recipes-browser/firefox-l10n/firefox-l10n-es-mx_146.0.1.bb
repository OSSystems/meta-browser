# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dcbaa6d7b20d4c343edf8a60d2dcd189"
SRC_URI[sha256sum] = "52012fa23409c6dba675fa2593ce60b8fa6ec1f2a4904709433a560851b479da"
