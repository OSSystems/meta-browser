# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fa6f09a944a5808746749db6487b81b4"
SRC_URI[sha256sum] = "72403577a7bf464b4396834f987c3fe688bf5be9b782739ba162a19fcb120bcc"
