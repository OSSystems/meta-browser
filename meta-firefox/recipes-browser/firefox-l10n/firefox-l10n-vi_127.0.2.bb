# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5f3f58a9f4ff0e808ea06a0ba129269a"
SRC_URI[sha256sum] = "6bfbdff8ef6dcf2cad4ab2c2f72790fd1c6aefd93ee86d8137e2df365c34bb36"
