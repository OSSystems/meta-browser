# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "52ac291a387d7e2e97ad45ad488de9d4"
SRC_URI[sha256sum] = "c0bca16e4e3e63fd4889b066fd3470568b0059be28bc200c6891e1992ee8bd33"
