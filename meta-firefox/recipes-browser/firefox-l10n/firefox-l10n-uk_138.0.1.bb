# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3b9e843d7a704d4862ce480cdf796bd9"
SRC_URI[sha256sum] = "0d301917c111625281d6617001f755e757f6b6e4df46e1790b61aa4d34a4c197"
