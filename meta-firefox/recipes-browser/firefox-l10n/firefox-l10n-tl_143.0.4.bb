# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ff578bf9fa7c4f6b16593bac15903c62"
SRC_URI[sha256sum] = "ff2026e9bd048c231d62d62f8a441e8559b12c91a31e67ce267592b704f8f46f"
