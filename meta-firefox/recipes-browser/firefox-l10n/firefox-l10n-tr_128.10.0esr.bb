# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c5c0ac373542f87ed4f579e6e72c685a"
SRC_URI[sha256sum] = "1add37a59eb0c1c6b3851242772d71d0852fc03d0586a49856cb9a78623dbdda"
