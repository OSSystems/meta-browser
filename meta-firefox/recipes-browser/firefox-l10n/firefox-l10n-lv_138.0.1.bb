# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "391b4ca35acf602a6628d2d24ffd475e"
SRC_URI[sha256sum] = "58610d292b67a9c3df951973337c81239bb9c54e97eba35bb1ae20f77418ada0"
