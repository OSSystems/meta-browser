# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6bd7c2e1c439822c4ef654e014bd4d59"
SRC_URI[sha256sum] = "d8a005e8a91d5277ad4681c2081748a99b8f07e93664322d125ae0b9e4cc9763"
