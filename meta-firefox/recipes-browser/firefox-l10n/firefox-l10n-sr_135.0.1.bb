# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "347fcc12fea4484ba0f6e24aa9bdcda4"
SRC_URI[sha256sum] = "f17572b250a18958efd6829e57f9482daaaf340cfcc34d8a02507db6b1fb8e3b"
