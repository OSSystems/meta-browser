# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5102fdeb7c818670703b9d4db1793e0e"
SRC_URI[sha256sum] = "791bad1a2d581940364898234ae257bdf7cc057df8e2f8ba37210b69c176932c"
