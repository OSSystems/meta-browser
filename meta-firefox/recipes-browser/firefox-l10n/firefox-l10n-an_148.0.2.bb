# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "94475a9cf1af356560dc9c9d3b5fd8d7"
SRC_URI[sha256sum] = "77b4818e4c9d90b147f245778a6205f3819d6ec7d063ec8451875f5a44c9a606"
