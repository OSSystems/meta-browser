# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "de59453291ea91f2070ce252c5598b0a"
SRC_URI[sha256sum] = "252288f9aa5175cdc790ae8be8e583170402b987b3d39bed1c36d44c268ac46c"
