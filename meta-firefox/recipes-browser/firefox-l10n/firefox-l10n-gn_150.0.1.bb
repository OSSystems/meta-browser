# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "03f2a444832eac3de55c5e78445a80a3acdb5550ded20932ef2f0d6d2782f698"
