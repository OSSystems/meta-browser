# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a1c186f5f2e380c35bf2e8fa9ddea3d9"
SRC_URI[sha256sum] = "c59953911d9102f18819607a8a4e568e40699790f685940e17a1143fb392a362"
