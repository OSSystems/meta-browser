# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "98c24f6362d5a77a4bd13eae1220930e"
SRC_URI[sha256sum] = "67c3a7ca7534b23162df2ddc0f537150ac860889c0fd67c8f3f86447f1883b45"
