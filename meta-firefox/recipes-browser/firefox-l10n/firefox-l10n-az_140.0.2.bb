# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4999358f291be41310dc3f1657eea9a4"
SRC_URI[sha256sum] = "8be3114a15105eb36b4cb4348a5c27ffd96275c9eda2e9df7a265f2c27b02bb2"
