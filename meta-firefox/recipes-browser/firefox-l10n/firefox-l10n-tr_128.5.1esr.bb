# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "60ba871b40392853d8d51e918d175081"
SRC_URI[sha256sum] = "a52e8276b99ec7220e95f9344af920b964af0ceca1fb2302415c1e4d23b22ebd"
