# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b8c211652448eaa1da3ab0102a6b7d92"
SRC_URI[sha256sum] = "dee435f5047a94bd21f5ee839c8dd1c18bc7732df8f77d59c0fa9ae5063d3e4a"
