# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "10fa6edfc518d51cafdce2dde576031d"
SRC_URI[sha256sum] = "ff02002baa89b3c17e5d0cadc6b4303ec52427c4c256734126dd723277bb7d73"
