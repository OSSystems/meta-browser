# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cd5b8ed53c29893cbc845ef59ec2bc22"
SRC_URI[sha256sum] = "4b8f1f6be9a2bab68dd457784591434ef0c289cc1b3d9bd90fd3accb4adc7778"
