# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cca911f8b2dbfd863fc12bc8f930c2bd"
SRC_URI[sha256sum] = "a5a846b1b0496f7fb1ef4f9f6d2c453337ced80eafa7cdf5302491ae033ff105"
