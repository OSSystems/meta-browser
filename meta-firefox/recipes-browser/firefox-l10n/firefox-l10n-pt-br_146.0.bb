# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9c54f13507a0b15afc9e65626c8b0d55"
SRC_URI[sha256sum] = "2a819d1ef75582e5598fad79c5d5c72d5b2be32a718d728bd5f1d5759b500b1c"
