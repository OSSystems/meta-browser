# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "163059c3c6e3bb8f45e8f3cb399763c6"
SRC_URI[sha256sum] = "ac1040428da1d09cef6506650a48cadcad0b92e68adf2c4ab2f92c0599dc60ad"
