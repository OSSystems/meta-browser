# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c591ab49030375fadc6f3ebfed82b28f"
SRC_URI[sha256sum] = "44d35d1db7e3254364a2e25eae46cbdd6714836d030e095825de2bf789b3f07b"
