# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ea9c7bccd91a06622ef205df4a1f2fcb"
SRC_URI[sha256sum] = "cc1afa7f5e8a051997c3fbad2cf7a7175a11a6217a50411a9ce1c2a57b990a25"
