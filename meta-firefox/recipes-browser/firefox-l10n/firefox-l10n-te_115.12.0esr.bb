# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d6950359b6ad3124f4ac1e05ba0c0ccf"
SRC_URI[sha256sum] = "0fb8bf5b1d8240f5944b2fe0e35998c673abffe12948347bb1d0564cad9aed6b"
