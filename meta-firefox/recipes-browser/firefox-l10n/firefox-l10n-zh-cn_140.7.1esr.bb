# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5b815d1c4c91a81f61262d0c3ca4523a"
SRC_URI[sha256sum] = "3312624b0dad15686839ef965ebed109e57642093378e417e1bb7657626e2039"
