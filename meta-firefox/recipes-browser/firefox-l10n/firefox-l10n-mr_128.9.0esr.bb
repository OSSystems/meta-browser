# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "845574111b16316f9347cbd484502ac9"
SRC_URI[sha256sum] = "000360b634b8c680f1f4aa6b00a3a051e2648a95830d5ca4062b8522647aaa4e"
