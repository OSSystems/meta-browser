# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e07383b8afc4cb090a9826ce76d331cc"
SRC_URI[sha256sum] = "372612b9287ecc07ec53508eccab454aa9badb24351e467a260d00b39a91ca02"
