# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "21b9e370df4636895c5a8d71ddc819ceb0c6fd51520c0ef1f14b2f5e70f130c5"
