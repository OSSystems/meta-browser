# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a7a617bcbf0638b2f6631956e2e1573b"
SRC_URI[sha256sum] = "dddc0b0540b3e6ca89acf360ad2ec71dc1189eb0154bc3fcb8f5973abbf00d30"
