# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7a0242f216b9888b31fd9ac057a16709"
SRC_URI[sha256sum] = "c3ece9d101fe274118188e6323668f3d7c70f121f643406a1c1d4b732d29bf9f"
