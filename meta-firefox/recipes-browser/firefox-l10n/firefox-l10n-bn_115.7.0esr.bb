# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e74f5a172e1bc7313f7495564e8864c8"
SRC_URI[sha256sum] = "a55b07f28d46f728b08c52994665beca1fe3b09a4a5ddac6eddccaa03d69891f"
