# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6719fe0ebb9166f0d6657d54f20822b6"
SRC_URI[sha256sum] = "e3bb5bb8925252a4c7cece19919979cdc057b75c08fe5276d81a777d31f334f3"
