# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bb20ffa13ea23ee89c0ecb4318032c1b"
SRC_URI[sha256sum] = "333c9d353febb4b338cceb5372d5eb399a26a3bf111c327e2842227c438be5f6"
