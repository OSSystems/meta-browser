# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "81323c34b6c90045711d6071d1047263"
SRC_URI[sha256sum] = "7adbdd2389d43ca25e73d173e45a4e9b97f27ec63fe4f494b042c875db5512fb"
