# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c195ef5f820fa2da7144a99cfe3ac715"
SRC_URI[sha256sum] = "d451d68f66cd6f5ae6a46d5211305760bab505488906a615e433848023f0ee1c"
