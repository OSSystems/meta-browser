# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c176594b457ed01ddff24c8b7b44f431"
SRC_URI[sha256sum] = "e6b4c8cd9309ca0b634e481a8d3288ac10cfecd4e0a12b1b95db637cf7d718ab"
