# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "653dc7e2b1a7fbfa3c1a678f3df96eda"
SRC_URI[sha256sum] = "319f9b678a08c527e668e1b0bd10813b1b1703a9c698edcdb705ae5f0bb80e8f"
