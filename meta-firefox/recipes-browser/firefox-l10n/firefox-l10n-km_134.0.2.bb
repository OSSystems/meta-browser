# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "079e10029d83a6a97dbf5e4701329808"
SRC_URI[sha256sum] = "e7a0d5029faa8d54af46f59f535387a20a15cf9b883a2a9efd0a92d28400fd1b"
