# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "afd198a36f50e899796ba92bd0211f6a"
SRC_URI[sha256sum] = "a32660586978f547bcac408b890319661d6d43b17e9dd85c3d62de27a532461c"
