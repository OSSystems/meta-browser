# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e64b239d595474d6865bb8f6b273f71a"
SRC_URI[sha256sum] = "eb05ba3777e7024b7f0377fc9d15a0b1e17dd9d2877561cf5bcb535d94c78dde"
