# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "1a29d79b20440eed9bd15b8dd928ed1919702a9df2f2f08d07175a54bc5b119b"
