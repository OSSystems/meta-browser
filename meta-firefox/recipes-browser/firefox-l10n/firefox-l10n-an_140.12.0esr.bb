# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "df07fe492fe255fc4ff4905f4c8ee5292ce7a619c22e338a82035e65134bc8eb"
