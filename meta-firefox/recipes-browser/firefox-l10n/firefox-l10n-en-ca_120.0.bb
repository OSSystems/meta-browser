# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "17b3f9c66d937fe951326de35281be36"
SRC_URI[sha256sum] = "8f9f56b5bd08c82aefec3c01d839b79a332813d53426838b69cd3e92a5623dbf"
