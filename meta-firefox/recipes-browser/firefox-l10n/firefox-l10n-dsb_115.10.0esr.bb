# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8bf9c1f1acf82d0447cadedab8d4f037"
SRC_URI[sha256sum] = "ff1cd0802203791425dbeaf1f624fe19d1a600e9c79a61b5eecbd56ba604d1b5"
