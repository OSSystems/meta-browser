# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "063766aee7026eda392700dbb7219d87"
SRC_URI[sha256sum] = "b1067576a9fc54b914c5f59d6400f5bfa2fed462ec80aa2b11cf39568e9209e3"
