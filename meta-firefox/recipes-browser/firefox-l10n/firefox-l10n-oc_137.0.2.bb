# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "85d98e110e1f56e14a062bb48e0e8b4e"
SRC_URI[sha256sum] = "7072ea7255808ff4f3ce1005cdf95f81afbca7df105cc2a3e6e220e74040e88c"
