# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e6458b5645090362acd1b2cb6e2759cd"
SRC_URI[sha256sum] = "1fad15f5d011dce16d38f1048f4f0ccb06dfd99454cca41d50d119f445953da4"
