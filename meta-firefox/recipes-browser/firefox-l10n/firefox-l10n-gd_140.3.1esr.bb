# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9e28b8040dd3dbe73715cf8afcd85429"
SRC_URI[sha256sum] = "f9560da21a95d5183106ba96572a4808d34ec0d2781488bcbcbbfbe6e55d50fa"
