# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b6dbfeb09adfc3a892955adc71af1574"
SRC_URI[sha256sum] = "8f3ac7b1827d1644c13d92457dfdede27b228c4bce46f1899425bac4cee05b55"
