# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aa8d632ed602d1981bf145700de88804"
SRC_URI[sha256sum] = "faeaa9569ed1d50e3083e27fa5bee7f297c9ec42e2adef55b718abf398e07fd6"
