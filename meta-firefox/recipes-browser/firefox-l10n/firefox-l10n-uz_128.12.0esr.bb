# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8cab64c19c5e690503661e105cb1c5c3"
SRC_URI[sha256sum] = "cf7c974e1f036289a5d7c7d08ec646a2adbf35a507e3fb016579a8351bb929d9"
