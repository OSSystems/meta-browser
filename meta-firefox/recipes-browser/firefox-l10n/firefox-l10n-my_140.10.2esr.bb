# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "5d9307b1be27305d2f4ec6ef015f70b0ca1ad7aa3476fca86dfd8219e2ce8cd4"
