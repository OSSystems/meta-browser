# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6a2e457b63063f02d2c3cfc7b8d2bd4f"
SRC_URI[sha256sum] = "08e2284cb8fbff120479339b7d5b6bbe5b2b9f880198653de6d74bfb664c85f9"
