# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "976730e049c6eb06c3edcf32c89c2b77"
SRC_URI[sha256sum] = "c37c3632de32f3e31b9127f65b23d2fe84cd5a5ee4ca9eef7609cfae81530545"
