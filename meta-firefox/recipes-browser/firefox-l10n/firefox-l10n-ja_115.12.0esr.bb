# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d9b0be5f91c368e13510e55e818a3cfa"
SRC_URI[sha256sum] = "51eb29f0fe77fa9059f7f0c368591dae04be0ef5d8fb21efd514e8a64da3f437"
