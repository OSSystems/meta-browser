# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "99298a9ee6323523c9682ccdc7ed8f14"
SRC_URI[sha256sum] = "b115b400809cafa5fc646de04b479681128bd12b2856a5cb8a2cb7fa2d6d1b63"
