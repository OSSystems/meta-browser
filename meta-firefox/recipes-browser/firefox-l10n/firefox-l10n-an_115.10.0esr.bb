# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fc2904e05b0a3b7d86f1900c5715935b"
SRC_URI[sha256sum] = "442859479a0214e01d88b73d3990e4c5a40cf935e000bf6150b9a38299951a67"
