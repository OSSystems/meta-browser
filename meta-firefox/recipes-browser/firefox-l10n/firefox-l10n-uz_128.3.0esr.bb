# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6952adffa4d172aa7c40fe95ccc4bc40"
SRC_URI[sha256sum] = "844086a3c958fe5c245cd97b4b34a9226cec955b212f6f5362e0923c1b2946cf"
