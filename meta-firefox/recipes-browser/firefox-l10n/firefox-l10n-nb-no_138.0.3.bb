# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db4c30e40dade444bb7241b18294bb10"
SRC_URI[sha256sum] = "c5e8c510dfb65feaeca3c9e52afac2f489236cd4666b2f17df1ff466c14afb9b"
