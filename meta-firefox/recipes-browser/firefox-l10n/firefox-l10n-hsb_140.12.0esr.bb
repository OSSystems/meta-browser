# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2d52e710bdac6f8c51862934d9d83e557f29d25bc1cefd2b6d32413a143f6cbc"
