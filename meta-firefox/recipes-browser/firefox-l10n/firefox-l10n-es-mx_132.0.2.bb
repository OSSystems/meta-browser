# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "62d2bac16aad61d312798ad73ae7baa1"
SRC_URI[sha256sum] = "2f66b63a70baf4d3c5d932f4a1ea6d5ef47989b2266282434373208b148df8fb"
