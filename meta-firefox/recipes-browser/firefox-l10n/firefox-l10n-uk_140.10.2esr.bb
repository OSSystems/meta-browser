# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "774f3df65bb46557952edcd5ec51bf68f9a9848ee83a43173bcba0f1a3049224"
