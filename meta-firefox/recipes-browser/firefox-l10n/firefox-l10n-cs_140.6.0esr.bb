# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ae944548b06b2b2f81b84e8953ba6928"
SRC_URI[sha256sum] = "3e2cd32cc4689f9b0bd65761968b9ef64b1d73caae0a25061216326a170b1c22"
