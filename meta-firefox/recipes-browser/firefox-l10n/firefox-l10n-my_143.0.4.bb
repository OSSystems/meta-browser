# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2108df6e95e0e0c5465d4a69c7b99dec"
SRC_URI[sha256sum] = "89f874e5c9519e733796211e2e14de5a8a168de8296d5227edc7d42b0c3a37f6"
