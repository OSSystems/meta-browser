# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "05c605d748e3f63a08e2aac9771e7686"
SRC_URI[sha256sum] = "df1f8dd88e0b1b270e5aecdbb2e9a3bc65176fde7dfbbc6c6b6179aef005d5d5"
