# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9eaaf45ea8892ef53eb39f1770c57134"
SRC_URI[sha256sum] = "d999b49294575a5ab35f5aa639079eb7d3232cfefc9f9b499ee32418fa0abdaf"
