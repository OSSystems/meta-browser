# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "01827f9f820ddf55e0762d7dedf58fe4"
SRC_URI[sha256sum] = "dce591111c48cf51a7e76762dd45fd141d4a10a864c9ff776b2166aebea33730"
