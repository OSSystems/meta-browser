# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "256be7c5ab79e9562fc026cf0d6af460"
SRC_URI[sha256sum] = "86f0125dcd5eae3f945097334e12fb0eb44112379ae94bdf05ae85ca15c4e2f6"
