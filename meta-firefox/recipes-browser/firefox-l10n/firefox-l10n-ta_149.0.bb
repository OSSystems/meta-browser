# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4a558c6b31d852618bb6ccb55b6819a1"
SRC_URI[sha256sum] = "df8a13068c7bd22845c9482b0e9d490468f123028ee0477abe333bc260a48799"
