# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dc413a3fe5e926674a1918d9bdda0ab1"
SRC_URI[sha256sum] = "88c344fdba22eb64302726a29a42d275cec8dbe02cf10fa0c927a39b9d038f0d"
