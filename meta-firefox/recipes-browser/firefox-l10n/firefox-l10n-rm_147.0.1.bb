# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ed65ca841b5af57bdc5360603195af07"
SRC_URI[sha256sum] = "fbd40de0290336ccf86065963dee8d25903ace81f75af139e0b2def88b95d909"
