# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "5f3ca5deb481392fcdbc5edfc4fc10b90ca77729d9f285bdd6b4564644ddac74"
