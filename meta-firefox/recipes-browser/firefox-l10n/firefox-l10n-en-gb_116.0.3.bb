# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a0982fe548bf4137e8ce77f632ec3861"
SRC_URI[sha256sum] = "efc9ed90f520fe64b000ffeaa11e825f20d1bb9f9ce9a5dd5b8cdb27a72cd0ea"
