# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6626d4eff622c67dd4ca95fac667cdc4"
SRC_URI[sha256sum] = "428166dc1416a518cf448d359a6b3e7a081010ae64bc8d0f0ca9e26b09584377"
