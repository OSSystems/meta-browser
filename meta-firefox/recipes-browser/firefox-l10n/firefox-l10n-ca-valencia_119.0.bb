# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3c7a346447946178a892a3a117769884"
SRC_URI[sha256sum] = "7f26a93bd4ec0fba7f87516ab13d2c4413ecc5aff071cb6b9a10e80c5e9ff271"
