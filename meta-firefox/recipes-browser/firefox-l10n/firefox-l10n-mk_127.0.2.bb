# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "43b9ae5f7f64b3c654e261aa58a14615"
SRC_URI[sha256sum] = "9aa1db605e5388d5e875ba3dce6adda25701b2e026f37b546affaf4a9a6191b9"
