# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9d3d9b82311739d18473b3b131873e82"
SRC_URI[sha256sum] = "d4a8be2871080fc24bd54df4bd6184534ec6b70cfbbd1ad53f38595e4a86b41e"
