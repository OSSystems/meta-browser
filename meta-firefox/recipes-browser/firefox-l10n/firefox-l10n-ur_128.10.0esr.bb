# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b8737cca753a3b3bc784ecadfcc58be8"
SRC_URI[sha256sum] = "7385f0d27a420299a7486f84b34248f9caea45f897c3fc20f60e804d15e7eaa0"
