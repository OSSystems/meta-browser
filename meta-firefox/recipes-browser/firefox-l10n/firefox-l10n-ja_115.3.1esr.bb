# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "be9b86b7443bb9ec5847d0794294f98a"
SRC_URI[sha256sum] = "926624b62660954c1196f74e0426e4b2b93bf1223bd634ad7b67d8041db36e6f"
