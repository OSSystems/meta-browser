# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "451bf4f8eed7e8faae0e469bcf2edc14"
SRC_URI[sha256sum] = "ea933d9bd7cad0b4bb1a3ca532e063115efb5a2382e62b4833610d06a895943b"
