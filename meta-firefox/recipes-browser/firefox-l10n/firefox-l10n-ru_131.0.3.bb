# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8d27b3f5b93cd403809bfbb74746740f"
SRC_URI[sha256sum] = "39564e3b3157a12ff79b902242e9feaf2f077c1afd8be005e3616e49943ad26c"
