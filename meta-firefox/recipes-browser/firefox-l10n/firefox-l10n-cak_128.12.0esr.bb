# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7b40e4bbf70bdb4507b9577cf1956462"
SRC_URI[sha256sum] = "b556d92a309998ed47fc065a2b064148eb7eb52e17fb7119e8e7bd152ef1af5e"
