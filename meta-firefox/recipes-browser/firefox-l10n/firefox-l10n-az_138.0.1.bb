# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8a55afe67c90cf13e97c4b9d8b9d096b"
SRC_URI[sha256sum] = "e07af4394603509dae31e16961d4f94f1012a535deb767d0b04d0d46f35cf4cb"
