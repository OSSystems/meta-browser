# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f2a080a7830aa5e00a35556865f8f830"
SRC_URI[sha256sum] = "7477452eb3edccca480ba472244a90b943e1d980c4435ad88114f92228e23315"
