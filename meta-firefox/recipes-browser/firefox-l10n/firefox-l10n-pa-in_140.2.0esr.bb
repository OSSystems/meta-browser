# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "af896a5e01da5d1596972be5ed3868c7"
SRC_URI[sha256sum] = "ca26e42462c786a729eb87d018ac3ce53b3d75542fcf344ebc10581ae7025e03"
