# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d0f59d5be69cc875c5ede99880630d54"
SRC_URI[sha256sum] = "8aefec0af0be7af8cad7648d49c3464f0c978ce075af8d7aa64945943513ebae"
