# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c507fa046ee47eddc85e0be72738d143"
SRC_URI[sha256sum] = "cdf8d7476d1721d5ec67195d4076b5447bfbdf80a61916f4673d2e8196157ef5"
