# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4780585b07b1b2f5c03eaada1d1010c3"
SRC_URI[sha256sum] = "803446d40347908583d1615e75b56f77a53371c267cd7ad5de137911ca69c6ac"
