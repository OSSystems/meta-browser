# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9c0612695b917ced81f5216dfbe25479"
SRC_URI[sha256sum] = "e74a0ca0e69d1258122cf60e6390525d9ed842f90842074ed17bd0fc999c8693"
