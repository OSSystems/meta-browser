# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1d7911774cb93064c9705d050abf5478"
SRC_URI[sha256sum] = "6ebdba0f735d9b8babf2420ac21617ecc8cd5399f4be4e1b2c250d78c593ea9a"
