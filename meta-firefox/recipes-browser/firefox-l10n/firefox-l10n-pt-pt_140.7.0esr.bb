# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ad0b18bd53d1c01d98e0ec48f9d9536f"
SRC_URI[sha256sum] = "04db08333315c0e5eb4cb81428b91cf867542f5a1004ff3b4fe1d8547bdf7cb8"
