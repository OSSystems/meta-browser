# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d9d737f333a74e9807b967fe75335793"
SRC_URI[sha256sum] = "d500113494b695f7512ec76459e0193fa1092ffdf333517c61702525980e4c67"
