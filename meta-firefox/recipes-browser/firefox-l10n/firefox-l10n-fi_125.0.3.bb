# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "79bb659dd56fa18e984f0c84009e9af9"
SRC_URI[sha256sum] = "f064d76185412980cfd72038dc94c669705790834d9002570276be22dddf6d52"
