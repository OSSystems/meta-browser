# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fefd9869eefb44c80b69f16a824a8168"
SRC_URI[sha256sum] = "6c85cc1b81b1d3de82b2857e8d4c6da9a394893d56bfbc2c4500b5e2524d2c81"
