# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d5ca89a10ffc6c339663b16828424eba"
SRC_URI[sha256sum] = "d0a3a0d054fe30d627ac3dfbc2af41f1c3799fccda72e8dbc4a03ac129b3c748"
