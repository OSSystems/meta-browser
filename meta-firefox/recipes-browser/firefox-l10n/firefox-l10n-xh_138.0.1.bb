# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "56be081d47b7c41b53b49995db2b10f3"
SRC_URI[sha256sum] = "252341112e5e0dd83687524f3c37dae7bdec1cc32fed6313007d5b8ea3cf3f27"
