# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "274b43f7cf90eac70985358300613fa3"
SRC_URI[sha256sum] = "60aaa7e7149c90b2dc2665c5ad86c3a5634088670ee5e8ca4b154573cb1f5fae"
