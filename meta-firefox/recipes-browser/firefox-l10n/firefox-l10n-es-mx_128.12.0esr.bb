# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "727309b685cd2fb6b30855efee37cb14"
SRC_URI[sha256sum] = "b2f331148ba0f97180207b65bc3f0634ad157d4b9b7b9413029c474d47e488bf"
