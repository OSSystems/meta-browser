# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "359106c6ed0ee733c431f841e78e576b"
SRC_URI[sha256sum] = "15f1289b53f8b242c5d701ca16d936fd1c7923eee47bebd11f741e247c5a78b9"
