# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e3973933e892ee37a50a31cbdb21388b"
SRC_URI[sha256sum] = "b2136854028187add421357aa8af7b40bdc8b6586541056cedca675eb49ee79f"
