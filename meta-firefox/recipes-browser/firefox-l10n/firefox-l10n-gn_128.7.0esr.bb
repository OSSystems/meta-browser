# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4a64ade17592de35d8919e8b4ed86a3e"
SRC_URI[sha256sum] = "297549913c252cab22f17f3fed43e189fbc398f24269dc3ba439b5a00bf2594d"
