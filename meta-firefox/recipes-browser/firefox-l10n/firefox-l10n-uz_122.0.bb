# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "63e3197659c81423eca98f419a5af3c9"
SRC_URI[sha256sum] = "b4ceae7024b0c12f96e38c07d013f8a6cfb52b0680034798b348b6802ae6114b"
