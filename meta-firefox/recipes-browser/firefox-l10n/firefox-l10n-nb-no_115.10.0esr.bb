# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1aa1cf0846787e66aebc874e8f6d8c00"
SRC_URI[sha256sum] = "454ce8e84fef16366f8e19a45d6b0e77e7020b002b061896aecbb4f1a11fb6a3"
