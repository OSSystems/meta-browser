# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4a04fd9440292d71519bc68ddeb121fd"
SRC_URI[sha256sum] = "a05d477ba80d7cf3e88bc72c012794487beea8af5faed9140b43aca19203e7bc"
