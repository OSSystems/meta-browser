# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "841c0b085731054e898c95549cd182d1"
SRC_URI[sha256sum] = "ef56de953ac885a559c93b5fbbe8fb1c1fc842e98c847f8cede7689b3c471d5e"
