# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d660dbdadb663733ffcc36405d435418"
SRC_URI[sha256sum] = "144594e0a285f96597926734259c83cf4c627bb5002ecb4266df5c8bf38bc89c"
