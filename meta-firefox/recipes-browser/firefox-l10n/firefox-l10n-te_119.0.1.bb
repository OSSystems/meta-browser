# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "410443de265a8ad2c8491eb4312b0573"
SRC_URI[sha256sum] = "db2af792a5c859d00cb116789da3689795ca3526cee9eefc5ff2cb46c5893e22"
