# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ff07ddca072aa760dd2ccbbb793d5191"
SRC_URI[sha256sum] = "2767b6e28d741091c64f029680d26b42a119d982fbe0e6623490f0909533d4f7"
