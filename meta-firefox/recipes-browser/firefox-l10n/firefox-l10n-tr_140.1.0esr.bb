# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1f7c44d6886edf7cb6cdd5610ef17553"
SRC_URI[sha256sum] = "4ee087046873f04e2cd0d78c29553184cc60b7a2069233d0ae7a134c0a9851e3"
