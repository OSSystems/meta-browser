# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "850b24437d7ef2515a6f72320d93b8cb"
SRC_URI[sha256sum] = "169dce2dea6b86154b1a6f0ac42afe5db193dde7274bff0442497ce766e7b03e"
