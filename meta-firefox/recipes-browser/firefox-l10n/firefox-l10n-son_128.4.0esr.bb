# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7d5e9436a093060a1cf3ae78821ce8d7"
SRC_URI[sha256sum] = "d020e9f2c34988ded8ec0dad1d2b495dd276122be3272c14526fc1a861bd938e"
