# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e879458cdaa6e99cd10ad6702c0ba31b"
SRC_URI[sha256sum] = "cac45634ed79913250de071164be0ec234e3e9f4b297ff88b109bf5861dfc91d"
