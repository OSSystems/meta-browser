# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "aa7a8b43992872c66a6ecf63a0771566a651f0bfdd2a2dc60bca3e5083ba7afe"
