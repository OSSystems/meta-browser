# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3545d6ded51ae5cab9e702b4e5d55fe9"
SRC_URI[sha256sum] = "fd95a73699d83cc89ef3a76be2990154cac28b7f3bb3abd6f7883dce5ad2dd78"
