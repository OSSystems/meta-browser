# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9a8b30a2f5ea45699a00230f034fdd8d"
SRC_URI[sha256sum] = "c7c52c033f794ee1679cc928b78e8d101fbe0e5169af3b7bc770b236b05ba64e"
