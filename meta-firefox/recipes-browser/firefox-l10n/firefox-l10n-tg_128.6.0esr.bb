# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "30843026384c60b635289688417f26cd"
SRC_URI[sha256sum] = "ab015fa8cd4b6ce96450ba99d4e33810badd5e28d784ff287614521efe82b535"
