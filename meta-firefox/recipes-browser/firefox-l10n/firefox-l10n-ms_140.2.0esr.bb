# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "17df726a3257922232bb00ba18bda815"
SRC_URI[sha256sum] = "73ecabeb3f6ae91f26c5f40de2b3a049d26d5c54239aef92be16927ae7779035"
