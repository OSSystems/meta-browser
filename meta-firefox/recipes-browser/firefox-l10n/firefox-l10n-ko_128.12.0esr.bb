# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e9d3c281a87ecc9f0a60771c4bb8f124"
SRC_URI[sha256sum] = "3c38b3e49b4ee89be958b29014296ed9fc5fb3fb9f9ebdb6c32212d06fe54de8"
