# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "0b10c9c34cf826433e654a0cee0135c8d14dcc309782a0b1ca62f17120dbbcbd"
