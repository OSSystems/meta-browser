# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f440fbdd83877ef4e3e656a82098a343"
SRC_URI[sha256sum] = "8219d3d0834f214eabb9fdec18e2db64ed19b0a570971188ec40aa766d62e889"
