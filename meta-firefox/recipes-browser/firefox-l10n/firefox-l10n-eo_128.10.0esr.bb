# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1b165a163ca8c639ff726080be122ccd"
SRC_URI[sha256sum] = "9ace2676efb0f347bfdeac84ced0233e571a1e242b3a69a272f56ae67303dcbf"
