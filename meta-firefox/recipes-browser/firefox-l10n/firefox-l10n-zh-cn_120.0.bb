# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8a099536dcce8f7e39cb51dd982245a4"
SRC_URI[sha256sum] = "b7c9b9ac2fa295fed5fecd3cda8fc6411102dcc9331910315af335ed7b31c946"
