# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "932753ddc8b0de4f68683d362b5788bb"
SRC_URI[sha256sum] = "3c50ba0a9671534c4d7dd77ef31d675277e308a2a9a87fb66a9eef50cf689868"
