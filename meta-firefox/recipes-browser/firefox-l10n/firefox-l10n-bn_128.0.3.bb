# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7b488cf7ed1fbbfe917f3ad22e79f4e6"
SRC_URI[sha256sum] = "47f8291b064b465dd002bc2e1391b3887aee59a6dadd587dc4cd3b901835fa69"
