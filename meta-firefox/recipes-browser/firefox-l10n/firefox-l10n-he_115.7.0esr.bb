# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "75334c74b7ac24b89e7c22513bd35f24"
SRC_URI[sha256sum] = "a9db9df560f0e0972d4a2282890b26b00494b885a391ecba275b016bf58a587c"
