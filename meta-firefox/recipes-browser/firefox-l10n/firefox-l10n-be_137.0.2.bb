# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cd09a81102e24b320182cc400cd86ee5"
SRC_URI[sha256sum] = "acf81ec16c4db6a39bb821fc9c67952c4d689b0970946bd26a4c80a0b105e030"
