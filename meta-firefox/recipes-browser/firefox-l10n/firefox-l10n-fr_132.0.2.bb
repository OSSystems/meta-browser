# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8200682506a7779f6f5e746f6fb1b909"
SRC_URI[sha256sum] = "54846eb3b72fe04c74fde52f83a99e014a3b2d06e856066f051125fa5e66d057"
