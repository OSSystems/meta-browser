# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "65e1b6f660806346aab1c51ee4bc5723"
SRC_URI[sha256sum] = "65344e165a2fce62dc7ccb3987a89f5e025616683ee539982a4f0cea16380e53"
