# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e06e8816c17be5580e27b881846fcc70"
SRC_URI[sha256sum] = "391df3610920818daaba4d1cea25ab3a38bcf160d824c1ee696aed358fa34498"
