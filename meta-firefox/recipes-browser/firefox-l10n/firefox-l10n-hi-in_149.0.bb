# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c5bb2c01f103ff6cb9794457dfaa9818"
SRC_URI[sha256sum] = "066596c1da2c8e7d6da24676829ed556b8b46a28da72d689c89fe8351daf03cb"
