# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c21f9f8e18392296ec31566e9449d8a1"
SRC_URI[sha256sum] = "ba68290b0ba56f55bf27d48910f9d5af452ffffb6dba1a99ee1586510580608a"
