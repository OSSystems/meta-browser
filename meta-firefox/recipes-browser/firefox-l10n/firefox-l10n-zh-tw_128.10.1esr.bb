# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "72ae96ca227e97b0311d8c25290babd5"
SRC_URI[sha256sum] = "ee620c7bc762d01b278a2e6dbe4c295ba0ac68228db7298ead2708ffc64c6888"
