# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "42c5ffcd09c5dc147ecf76ac9dbb0bd0"
SRC_URI[sha256sum] = "d905991ed6c67e0a54f84b4367ae855f350e7f7b06e0d0397cf6780b2b042d85"
