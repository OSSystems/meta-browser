# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "23d7377f02057069b21cce13fb7855ea"
SRC_URI[sha256sum] = "a6f0096aba505eccb0490e899fafa10f20184c41af628f81debb846525fe396d"
