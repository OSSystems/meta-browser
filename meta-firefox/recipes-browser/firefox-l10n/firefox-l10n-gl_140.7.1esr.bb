# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fbbe1ef969a77d3ccd909deb8b58b5a6"
SRC_URI[sha256sum] = "d772364fcc1a9be9304ff23c9e7132771769ffe7f23c5463a0d69635a8099183"
