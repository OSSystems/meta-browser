# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6175eb4beac4a4d43f97e58b8df9e326"
SRC_URI[sha256sum] = "44f520c9ae5edf4868a96f15cb0cb73d75095cc1427c75c705115b5c844e56fe"
