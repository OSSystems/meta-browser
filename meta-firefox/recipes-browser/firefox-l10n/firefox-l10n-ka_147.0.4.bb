# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a96327970629830def070946844146da"
SRC_URI[sha256sum] = "2a061aad14f852e59fc6fa053a0b33a85e5be4bc940ac816bd7709da44830bc2"
