# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "65b0e5579060bc88bbc4130266aab994"
SRC_URI[sha256sum] = "a0cee1afbac0e7ae3c8c275ebffc364f108ec16ed752ec8d7a65b29fc0ebbd13"
