# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ecbc79c3d836062cda7a57fd2b509d62"
SRC_URI[sha256sum] = "85497483b519ee4ca9aa045635db8f18604cc04cdf7a31afef7e8dea0c6cecba"
