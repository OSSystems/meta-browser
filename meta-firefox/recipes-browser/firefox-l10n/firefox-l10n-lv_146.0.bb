# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c4c567492fc65b9072f54607679902b6"
SRC_URI[sha256sum] = "b450c4d8c4338c8f37fbffb790660f8bf7f3f90e0603f981e604f2985e163f84"
