# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7c7032cbf6a92070f431e84440c7d16d"
SRC_URI[sha256sum] = "aa7a874306db1e188e59e421dd125619f4bd8fc20d8694a8f6591b8e0b0baea7"
