# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ad6a7508d0858f9515aff17538a0fce170428b38b13973b35cf849b0fd65f219"
