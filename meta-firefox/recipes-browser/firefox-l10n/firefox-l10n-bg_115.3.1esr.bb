# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c6bc118e3e8ff28c1f049972e942e816"
SRC_URI[sha256sum] = "22eab88ff1f48ae2444431b2b3ee363c6a4745b5d82396ec00a3b749251ed7b6"
