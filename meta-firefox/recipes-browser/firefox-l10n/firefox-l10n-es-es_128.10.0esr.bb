# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e7181eb8064b7229127853e5155051f8"
SRC_URI[sha256sum] = "dad14403ba50855c97536f1b84e03e460de4601c0cddf843769ab961c3a564ee"
