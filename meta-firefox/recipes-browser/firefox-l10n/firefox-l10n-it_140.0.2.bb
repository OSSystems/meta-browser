# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e50efe8e6c17e25f13db22f9e75fe55d"
SRC_URI[sha256sum] = "6423bbbfc871a963b372fe58ff4f431c174646c3e436693035e2e984539c6eec"
