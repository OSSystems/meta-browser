# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b2bb2a82fbe29960477e678162b29641"
SRC_URI[sha256sum] = "110f4abf62370f577bd3443104f27cfc03edcf40f344643a3e1c0baadc517833"
