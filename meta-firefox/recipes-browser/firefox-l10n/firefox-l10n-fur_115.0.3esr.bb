# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4831602a3e20a7bea6b8121c010ff5d3"
SRC_URI[sha256sum] = "675462ec84d88c2abf0452b8688262c4b58467fc537dcceca55f14cbd525bfd1"
