# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "81f5a1fa34e4d78b01defd11782242b0"
SRC_URI[sha256sum] = "913b43d7925ff4bde21c738e1700724fb24c9b5614881847d822779aed36f186"
