# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c8ca51739ba1d5a4f1719ebd01793e81"
SRC_URI[sha256sum] = "8cffb945da9d9238a0f475285ee8b056631006c7582f99b8e7ac09711ab96aa0"
