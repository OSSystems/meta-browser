# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0d12aea277530eaf0e1283d6671cb6e6"
SRC_URI[sha256sum] = "63d9bbf388a66349ba595ee8082918b70a51fd3cbf0110f3eca1407b042affd0"
