# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3e19be6019b9f4d10b469314e67e27ac"
SRC_URI[sha256sum] = "9af2b4a2b99466ea63d9362f7bef0af04984ff5d76573aa2fe3575fe439321db"
