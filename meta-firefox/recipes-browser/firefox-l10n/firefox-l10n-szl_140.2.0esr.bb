# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6bc7f8df16832f8d6e7ef06356097316"
SRC_URI[sha256sum] = "56791cc73ca1652dcf39df92285aa876bd89cd7bfcaef375f3106e38f6e35af4"
