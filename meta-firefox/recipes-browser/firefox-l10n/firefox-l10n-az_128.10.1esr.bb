# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b91a0f16eaa8faf93019e680808fc2bd"
SRC_URI[sha256sum] = "16c8e6b2d662cbed3f094b298beb3b78433d6f412f4bc881b5a21739cafbfeb6"
