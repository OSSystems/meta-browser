# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7d9da09c769a5cd75f7bb4ee26547ea0"
SRC_URI[sha256sum] = "91141dd8b1476accc88f812fc24f25458bedae54bc642fcc095b73308f715362"
