# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3c24ff242f4ea0c771fb8021b70fc929"
SRC_URI[sha256sum] = "1e6167ea4f27210165204258982b3fa4eb4b4844541e1659c88536e984d89081"
