# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d8243cc08375d05ac08696ec72b69c59"
SRC_URI[sha256sum] = "865afe49c6e7818abf95a92eaa718616e3d3aa3d71a623307ac37d918a87eb0a"
