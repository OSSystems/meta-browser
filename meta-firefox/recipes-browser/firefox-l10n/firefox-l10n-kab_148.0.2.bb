# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "296c475ffc3960fdf8daf9ea738536e1"
SRC_URI[sha256sum] = "a6d75803d99e66cd59145cf34ca2e24b1c4733b02a3ce809a65ff639d6b81a9c"
