# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d2ad71bbbc65df446ce431b198afcfc6"
SRC_URI[sha256sum] = "94f856691715eadc039bf3bcd231728dd9dbb0c76bd0475f9f0ca9d45ab83cfd"
