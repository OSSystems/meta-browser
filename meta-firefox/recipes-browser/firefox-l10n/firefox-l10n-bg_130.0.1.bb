# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "98ef57011f34567f4afeeb26f018a8fb"
SRC_URI[sha256sum] = "062a4ac74d99c89b4b97ff292bcc68ef667cc526d987c228ac8020d2d5a3222c"
