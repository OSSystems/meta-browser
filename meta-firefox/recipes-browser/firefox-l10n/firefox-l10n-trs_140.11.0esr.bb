# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2ceaea45b66c564b937f365de872fdb74e9bc3b7a53608cceaabead0be415fd7"
