# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "717f1119782bc9f7de62d291648631d3"
SRC_URI[sha256sum] = "96ea574ca370aca7ef207400188a280b767f9989bfe3e14254b94c20127336a4"
