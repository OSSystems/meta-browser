# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b8cbdde91aa802b2b396e3387daa787b"
SRC_URI[sha256sum] = "bd51e75eb7446af6617f0bf8b1065d6506a1618e5140ce27e2dd1578a89695cc"
