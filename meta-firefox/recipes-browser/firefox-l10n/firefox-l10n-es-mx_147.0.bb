# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b8f026463da6a8f88560fe5d3ec379ec"
SRC_URI[sha256sum] = "72c22b8aa062eee3da27f372cd1a4901e733c44df3d2afc507b8d274a6636364"
