# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d57b69b7a0db91ed973f611a29261bba"
SRC_URI[sha256sum] = "75dfe74745a9a9228a14d5b2025b2b650e5b47307e8136595ef195c88992a3b7"
