# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2310b99306e9d7809cb200d0ede20b34"
SRC_URI[sha256sum] = "ae6505af8710753a7fbd3813306d9319ff0b80b58eb3279c3d33bd047bfd7909"
