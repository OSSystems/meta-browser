# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a9fcb4d6d239f6a4345f98dcef39d4a1"
SRC_URI[sha256sum] = "3d81ca00c462e2405e552f32f9e26eb3960f62170342fe7b7e463edd21120279"
