# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a66a36fef1d5e1f09dca651607356cea"
SRC_URI[sha256sum] = "602655459e4617bc6cbbd79aa088085127cd554ff0c9f8dd280f3bc57c35f09d"
