# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "42763bc33b9ec4f7465c20908289d1b4f721de267cdb69805c2c20e7e3b44d3a"
