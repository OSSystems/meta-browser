# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2282805def12ebdffc08fecf988a8bde"
SRC_URI[sha256sum] = "9b4d8b7b9456a536a6e896d56c3d6bd699531a26455138514fa8d187d524289e"
