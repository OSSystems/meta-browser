# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3bf0933fdd8435bfb9a6105350ccea37"
SRC_URI[sha256sum] = "49611dd2905443e2c8bc8de28cf55bea8eea104516da957fbf009a3373a21114"
