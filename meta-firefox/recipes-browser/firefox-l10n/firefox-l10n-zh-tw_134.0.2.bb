# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8dd1f87f9af3fe59e6c1ecaa37297fea"
SRC_URI[sha256sum] = "3eaed764a0744105095823e3dc50ae9df9506e1923509af240c2901b35485b77"
