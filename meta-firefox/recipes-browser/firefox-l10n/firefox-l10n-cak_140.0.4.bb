# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "710ea052e155fd97f38e95a25ef70519"
SRC_URI[sha256sum] = "3d00be97b0ca4f9166ea7fdf249f3d6873d8be061d112c1dfeec3651d35f3461"
