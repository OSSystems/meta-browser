# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fe54dcf34685551a051f7c2af594fe33"
SRC_URI[sha256sum] = "eac800b9376c0aa2cea3d268290e9da68e5307b7cee177ec6f2908a248413aa8"
