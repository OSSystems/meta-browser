# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "75d8b3317dbb5562a9b54721e998fed5"
SRC_URI[sha256sum] = "f53906d39522e9612cdf607108040bacb878eb68e8ad0d314a5ee7cd5094840b"
