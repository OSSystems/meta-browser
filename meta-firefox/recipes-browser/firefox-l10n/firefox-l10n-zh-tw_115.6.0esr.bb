# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b9364f2f703f49722dfc8ed956d92c9f"
SRC_URI[sha256sum] = "b3e4bf2f799efb2754900c3ca32b466d1dbafc94343a430ecf94b262263947b7"
