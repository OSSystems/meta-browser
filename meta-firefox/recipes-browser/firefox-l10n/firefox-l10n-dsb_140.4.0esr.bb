# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8d9687c8f90ac0dd02a953d3addd64ba"
SRC_URI[sha256sum] = "6f49729fb4f043941886bcf35e1fec1beac7e6b6438f6789f8565d97dedda1bd"
