# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "afe47e42982dfb3abff1bb0441a846bc"
SRC_URI[sha256sum] = "7d704f3d386e3435bea7744c7ba0d512939cf20289b4c4dbf1cdea34323be8ef"
