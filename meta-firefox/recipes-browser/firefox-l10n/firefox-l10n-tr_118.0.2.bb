# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7a55622d9b041217e6dbabe170536ded"
SRC_URI[sha256sum] = "bbd198c6a333c9ba71ec65952900ed7085c56331445aaf2095074a7232c07c87"
