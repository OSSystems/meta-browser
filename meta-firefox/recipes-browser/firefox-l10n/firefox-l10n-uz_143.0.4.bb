# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c334a9bf19507e21b4d959eb0785d53"
SRC_URI[sha256sum] = "5c41076924b56e869adda0b4e591f386481c6286938b7e0d28eb439c00351996"
