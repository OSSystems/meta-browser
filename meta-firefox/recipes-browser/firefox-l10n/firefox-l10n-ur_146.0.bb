# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ac8733733f29c82780071bbbfc95d7e7"
SRC_URI[sha256sum] = "2d943bf2f1ecadefb62454a60ee0c0d0ae7662a74e30187f574632088989a943"
