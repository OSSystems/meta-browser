# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1617fe9f44acb2d9c61598900e5e405c"
SRC_URI[sha256sum] = "ee8f02d2b481b671f40cf20ddabcce5daab52962544f3288503a43e87b40a713"
