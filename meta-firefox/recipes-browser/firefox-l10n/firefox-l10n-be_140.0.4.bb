# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b8c34a078fa5bd5db003ea11ba1540f1"
SRC_URI[sha256sum] = "f055e5afa3c5fca487da72501f457e1c1f54550be1bdf0eb22971f2822bdac59"
