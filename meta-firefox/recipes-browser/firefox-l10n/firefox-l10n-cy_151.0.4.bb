# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "08c88cd8bfe05476727bafb7f947f778f7b8738954563f597d634d08b0e58b4c"
