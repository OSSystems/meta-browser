# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4a2d3ae649cd481516b5800b3695bdbe"
SRC_URI[sha256sum] = "d8d41aa9c0a3fc30c038a3ed26802be4d0d38993a94a0b8a82c579537099467c"
