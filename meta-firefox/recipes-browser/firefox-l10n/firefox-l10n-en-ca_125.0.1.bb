# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e3b86a9be45142a11778f5465bc76cda"
SRC_URI[sha256sum] = "5cfdc5bd995ca8e545e434981faa69582e3ef6d66686bcfdd3a2ce57628a86ce"
