# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e1d787117e27948f7202054d754b70fd"
SRC_URI[sha256sum] = "3a408669a98bfa4637e65f6f3abe5ec3191dc46c6866c7b01f328d062442a8e5"
