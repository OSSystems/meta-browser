# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9aaf5d80090e84daa88486433c30369a"
SRC_URI[sha256sum] = "5cdaf6bfbc73b324cc499727ac73ac06cf77f9c443422a396073ec0efbbd8ceb"
