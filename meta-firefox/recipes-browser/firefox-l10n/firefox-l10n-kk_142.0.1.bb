# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ac4b10ab581f1db740e368f09307f074"
SRC_URI[sha256sum] = "30443d472ed054ba2a1b9ea27772a8636cd08b2a05da53caafdd0470fe125d8c"
