# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c4c69f78e650cc3104194c767951cc26"
SRC_URI[sha256sum] = "ae2f389933cd627dc2603b51a8ef91b220af506f9709e77b0745e386ec6df7ae"
