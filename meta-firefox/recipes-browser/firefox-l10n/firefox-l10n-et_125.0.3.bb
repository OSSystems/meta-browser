# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "22f2aaa66a0d34fcb8f44d903107927a"
SRC_URI[sha256sum] = "48189eaf6da96c4091432bb22e8d8dea09e47edd05a447c182f84e2a3dd15bfe"
