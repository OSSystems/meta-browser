# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "113e8c26222f2649430b4eb764f1d196"
SRC_URI[sha256sum] = "be73abd1b1c97d638e5ab8a9dfdfa7d24b92f1159b5342cea99690e2aeb4d164"
