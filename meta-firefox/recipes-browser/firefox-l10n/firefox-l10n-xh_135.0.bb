# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e6965bc31a71ccd12aca47949d5c2ff9"
SRC_URI[sha256sum] = "f77883d4792fe2f9080d4ee8338ea378d9d7f7e7b2f4ec5f0dcdc333c6b03d84"
