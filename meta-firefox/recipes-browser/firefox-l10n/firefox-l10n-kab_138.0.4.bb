# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bc454f8b9eb7347dccddd6d96f22fc60"
SRC_URI[sha256sum] = "b905080bffa1f75a49525fb80062573ef2568aa9c247f0fd900a8e161deff33f"
