# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0bd477654286feb8ac8ffd9bc953c920"
SRC_URI[sha256sum] = "9342468eb899d2288d8cff94f7bb7b30b4a7247286719b49499e5949c3ecd6f6"
