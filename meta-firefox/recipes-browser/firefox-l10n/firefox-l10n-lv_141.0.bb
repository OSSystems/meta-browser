# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "28a3ef8243bc500f5fe87f6fb3020783"
SRC_URI[sha256sum] = "64adab53948e6f28709b17e21e50b119435c0336c708afb3bacb8c7ad32a9bc5"
