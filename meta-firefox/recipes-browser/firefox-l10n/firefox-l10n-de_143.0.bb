# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e30ab397c0681491b2f5bd948d1cee83"
SRC_URI[sha256sum] = "b138bd5ad8637ba70bfa837500129b7511d9b053f9368ba7dca65670c00d5098"
