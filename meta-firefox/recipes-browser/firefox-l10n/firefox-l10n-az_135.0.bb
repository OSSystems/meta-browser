# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "68ba7b2df115a157ea8d2d1a2e99992f"
SRC_URI[sha256sum] = "039ca15880065c711e519fdbf4e0c10792e52f78cf4f80296c747d45cca4c210"
