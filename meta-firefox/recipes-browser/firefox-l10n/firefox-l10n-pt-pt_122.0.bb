# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4bae3d7961711485eba35a000ecec792"
SRC_URI[sha256sum] = "e1add0ec4d24b29f29b27e022dafe396eba31f289832ec55de4c21514fe77123"
