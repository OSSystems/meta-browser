# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aa02d7b64bd07c76a6b83a08b87a6bc9"
SRC_URI[sha256sum] = "829789e621aad70965b18ad628596ba137957ad3eaf75c19d5abed94b10f3ff8"
