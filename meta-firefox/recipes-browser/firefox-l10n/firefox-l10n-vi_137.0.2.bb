# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "097ef572e015185c315d22fb7ff37afc"
SRC_URI[sha256sum] = "5218696360d9d01762c4d8115c5985cbc3c58c97ef0b5c07e934a7c2a3fddd64"
