# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e23899e54c838849f281dbcf6172bddf"
SRC_URI[sha256sum] = "5bda6ae5c7cd11324c5e59a3c88cfe29c947741d1b145fb1e2306fd2a80b05bd"
