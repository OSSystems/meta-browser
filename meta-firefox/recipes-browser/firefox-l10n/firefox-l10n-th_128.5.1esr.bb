# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1e38b24ecea1be08469dcc176604f62e"
SRC_URI[sha256sum] = "25d6a60cb2cea93b5d14ef9ed8913f167c63c354710ba4224ec443076aec9fa6"
