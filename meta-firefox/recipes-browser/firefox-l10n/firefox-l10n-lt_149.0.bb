# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1059f06a4f815b7dad8e98e67dde80ff"
SRC_URI[sha256sum] = "d75ae59b62dfebee869c29e7e306af7bc4d298be3600c4911a750a664cfc0b1e"
