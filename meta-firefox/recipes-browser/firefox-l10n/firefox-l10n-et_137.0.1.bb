# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1de8d183fe4e5a296b33f6d25f2acb86"
SRC_URI[sha256sum] = "61dce42cfdf276aed2c9af44fb59767a1100e5ec24c171e5aee61f4734509c20"
