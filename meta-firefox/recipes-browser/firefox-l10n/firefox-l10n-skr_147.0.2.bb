# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "48e5602db3d89766fab1ffd7a9f5acb6"
SRC_URI[sha256sum] = "5f0c3b025806f0c22e911d1e383e095224dec5f52fd0cb136d2f0d6d8fae791b"
