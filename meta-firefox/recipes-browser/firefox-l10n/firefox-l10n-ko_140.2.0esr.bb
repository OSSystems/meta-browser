# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "02301ffa8f1920a42cbbc34f6c0e645a"
SRC_URI[sha256sum] = "59ccb66ae37b4a1b119322a386e24193ad621ae2d65261b975e95cf36c215efb"
