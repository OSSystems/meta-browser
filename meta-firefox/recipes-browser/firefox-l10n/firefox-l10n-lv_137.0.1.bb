# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3594abdd76a050a0ffd50c437efafa86"
SRC_URI[sha256sum] = "02f90b7cc81df473ddfd4b9bc02ad4168df6000ad8c216ca7a10b69fd329e2d6"
