# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3a5be506272ebcc873658e7663573b59"
SRC_URI[sha256sum] = "e0b2e3ec962ca47e93c46d90701b09205f27e0264a1b22ae4a8d2906fd5ed355"
