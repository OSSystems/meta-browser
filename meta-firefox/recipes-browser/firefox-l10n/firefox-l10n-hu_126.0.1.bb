# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e8020b7c653e580295c612e53142cf7e"
SRC_URI[sha256sum] = "16a7a35dd8675c3a70896238c03f3c9e8728348aa3314fb3c828e2b2ad36343d"
