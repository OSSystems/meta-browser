# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "5f1525a0a785b1b899a29c63828448580b3e01e4f9d24362d5930d6f7c8ee168"
