# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b9abf4802cd23532be5701e861c56bcd"
SRC_URI[sha256sum] = "93a9aca2eed22669f4b56bec452a897e299f70c34f51515c1617b59554ba8533"
