# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "03ed5ff056241c14d9f9d0d4bdbeeb99"
SRC_URI[sha256sum] = "7cfe6332f0de717f7dac90c72ff9ae2297405ba19329d3009aa6bc4524e25cac"
