# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a014219b977a9cacbb16fa2b71a7135e"
SRC_URI[sha256sum] = "16671be8c1b7fa9defc3a07f129dc54cf118464d60483e49996615afe4f4b493"
