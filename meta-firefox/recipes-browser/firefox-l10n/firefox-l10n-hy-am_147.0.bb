# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "98259f82c8d67405c55fa2ec946c4259"
SRC_URI[sha256sum] = "95eb1f7d36c54f023ffde0faa51ce65766a725114c687598b927a23dda3fe58f"
