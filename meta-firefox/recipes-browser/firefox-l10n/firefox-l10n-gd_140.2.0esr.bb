# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "90c90cf07b1a4c42fae1c55da05bb884"
SRC_URI[sha256sum] = "dee4da68342b2cd2c2d163e2598ea1128df514d01cbe791845de68d5a96e4e43"
