# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4aa901ebeaad365f249b00737ec43d16"
SRC_URI[sha256sum] = "2b756bf61877315d72ada77310ac17d2b67fe737615f6a02198e72a64b02c533"
