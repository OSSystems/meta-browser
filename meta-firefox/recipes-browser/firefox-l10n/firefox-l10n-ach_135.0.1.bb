# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fd61a5822d3ba4500e5772ef40ccf901"
SRC_URI[sha256sum] = "faa076fbba855a0de3a097876af3afa4a95066ed7743ccacef8f016ce1075be1"
