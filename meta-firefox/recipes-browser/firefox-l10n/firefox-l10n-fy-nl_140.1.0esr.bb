# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cc46ef1df04c3a57c4ae358072544c0c"
SRC_URI[sha256sum] = "6794f826fe745250910b7ab4d440ca95a4fd7ef80317e0ba8ea06f615b5c5c99"
