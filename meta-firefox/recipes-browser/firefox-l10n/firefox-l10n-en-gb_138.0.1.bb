# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7fff6c9a0f7ee28baec49086df978d8a"
SRC_URI[sha256sum] = "4468e7c2d4d018def0ccdfd04ce2f17360db966af491db487af24d92da7605d5"
