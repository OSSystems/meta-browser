# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bd5bcfff8b441dd919cc2e98b00ae3fa"
SRC_URI[sha256sum] = "bb6dbb2f84d26e4d5ebd70ef60841cb9989549dfda4f1cdfe77b626a2ed54ba0"
