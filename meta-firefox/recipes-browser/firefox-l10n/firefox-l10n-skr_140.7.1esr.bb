# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4eb924a54cf3c2b92e31e68b6792c452"
SRC_URI[sha256sum] = "18c15d817903211b003f00e5f9c9f0ec95453c477d48d94fb1017ab9a6c09be1"
