# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d6dc40e37a6491f77cefa886eb1e46a2"
SRC_URI[sha256sum] = "3eb47dbdab25f8d37dbba0b489e166f38b2779f17ce65b1e191216e3a54ec9d8"
