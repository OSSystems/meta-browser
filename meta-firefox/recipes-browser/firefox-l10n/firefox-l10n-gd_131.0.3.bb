# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0d93f45eed4b7e3dae59226761f0b8c8"
SRC_URI[sha256sum] = "5127b5cbc258d5a881c9261e9e6b29dd3e22860bdfc8cdee24aa8fcb31087117"
