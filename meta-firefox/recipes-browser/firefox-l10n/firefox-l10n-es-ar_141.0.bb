# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8cbef103f0a34f1d937a6e87fa33a80f"
SRC_URI[sha256sum] = "8c3aa4e809c224069d0f5fa5d176d492893cd4f7574a0ade0e880f6928c1b20b"
