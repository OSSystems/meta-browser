# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2312c5b0b9a9ac0d563cec03c99b197f"
SRC_URI[sha256sum] = "57208c3cc55d4f091ec55a78a0d62e8b44a1002cca1c092f479786656072dea5"
