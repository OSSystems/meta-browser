# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6cea63fe2c0366161d23dcd2c9a30c30"
SRC_URI[sha256sum] = "2c4bda448b6664e753ec80edb1b1997c7f22fab81ae9b3ad0f27f546d732ee01"
