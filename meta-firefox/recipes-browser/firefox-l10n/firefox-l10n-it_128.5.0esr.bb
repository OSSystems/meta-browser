# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "55e74a14710d61267cfb604c9b0d1f57"
SRC_URI[sha256sum] = "45ba80f9fac66402664933d76fd2212cb44551918cd1a2308e141fd429f4bc4c"
