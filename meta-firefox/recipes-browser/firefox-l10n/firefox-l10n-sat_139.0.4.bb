# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2368295421c54720512b9fa35f609ffe"
SRC_URI[sha256sum] = "ef863b368903f9f4036f869d41f2b43037ae2ee20fba86d4a9d6e6e977ce11ba"
