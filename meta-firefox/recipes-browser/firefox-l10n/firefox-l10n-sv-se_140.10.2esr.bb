# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3f5c1d70646100ab78c32b45776a26fe9e6478418e42d91e79f40538f0b4493c"
