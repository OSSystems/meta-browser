# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b4de021e3b92b7df19766f5bbcfd2e45"
SRC_URI[sha256sum] = "30437771cb94ec9f21adf16bd11fec95fcba6c524ee429aac24c4b802ff6d95d"
