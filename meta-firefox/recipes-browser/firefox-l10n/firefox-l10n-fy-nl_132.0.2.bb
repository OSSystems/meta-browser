# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f0c283b9b2946f8bf8e797ab191b32e9"
SRC_URI[sha256sum] = "dbb777d8f66aa169e41cc8c14d800ed5efb7e5dadb269ac410da39cbedd88e39"
