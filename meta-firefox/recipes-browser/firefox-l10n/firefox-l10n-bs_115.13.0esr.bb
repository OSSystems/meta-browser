# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1e2a2c639672f87f572ec771e3192cb8"
SRC_URI[sha256sum] = "e819b116cd3c219a6d3f0dff515055930b3bb00170381e291e400c29c10b3822"
