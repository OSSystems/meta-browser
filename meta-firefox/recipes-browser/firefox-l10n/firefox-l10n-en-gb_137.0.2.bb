# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "26ec9f570df9dd99d29a825cbe0e15b5"
SRC_URI[sha256sum] = "bd4f81f26e7a5a9919fb97b2f357579b1f9e81aa9b2c1dc3908f2bdf3edc510b"
