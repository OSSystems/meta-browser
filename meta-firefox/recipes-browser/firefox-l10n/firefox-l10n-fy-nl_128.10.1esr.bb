# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aea0166cbf6316beb081725dfc86c71b"
SRC_URI[sha256sum] = "3c63ae281471810e3bff2cdef95a8e886d3f684a56c5831cb2522255fea2f19e"
