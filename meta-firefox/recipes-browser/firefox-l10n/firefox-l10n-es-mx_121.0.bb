# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "02d1a0458b3a0d9cf1d7511af70bf0f0"
SRC_URI[sha256sum] = "3edc7d7eafd4c13cd0f7b621c7b610aa505fa453527b9f68eae4d8002618490c"
