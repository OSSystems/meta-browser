# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fc5ad4bc38b9d73f4a7fd2ab3f13b0cc"
SRC_URI[sha256sum] = "47aa9f5fc8bd9a27b38b5d1c4ec960fed85809c4601bf93698d0f6c2fe51fcee"
