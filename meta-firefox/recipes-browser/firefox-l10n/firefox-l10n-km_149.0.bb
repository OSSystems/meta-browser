# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c33e2dac785e0395097b2d1226c2288d"
SRC_URI[sha256sum] = "b57502580842446b366668481de267578b4df56e00f84dd46c6d96e85b502776"
