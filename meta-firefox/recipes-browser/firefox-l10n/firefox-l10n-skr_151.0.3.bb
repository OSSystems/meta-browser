# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "671e7bd1f70ffff8157dbf09e6e6f5cec3f89471ad55b38819541161de2c7fed"
