# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ac6cd0e88b64a9f1c3077638be0ab492"
SRC_URI[sha256sum] = "e7f96f5de5b13a8e52fb016735ecd62633f9e1d91a8fc536eeba1f4941a1ccae"
