# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c67d2ef30972920c4fa2c939144901d7"
SRC_URI[sha256sum] = "c784038d97c3413e6fae10458dd68444d27ee11dba3118221bc99289788aad9a"
