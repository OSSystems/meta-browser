# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9eb0a1c7eaa12bb31177f59f0c123276"
SRC_URI[sha256sum] = "fb33820b7f1289a6c2ab01aa774b6d2d5080efc5745ff062e6212001bb8535b2"
