# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d2b835560fe27318dc1fdc26adc0c1c8"
SRC_URI[sha256sum] = "a6237fd528a67af2d457ca6f8704dba1524735594f8a44eb59de2696d84a3d92"
