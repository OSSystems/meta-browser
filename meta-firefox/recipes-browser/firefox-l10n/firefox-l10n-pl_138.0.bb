# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0e2323c673558a28fa28cf04550dcf7e"
SRC_URI[sha256sum] = "582901fb7ce121ed8b56e31eae64f132f31f54d5afcd2102ef4dea6de1c60587"
