# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0fccc359b6e599077d83a8b68eb1c924"
SRC_URI[sha256sum] = "85d40be053794d2329f74cb128c44222b1d0d302afa35a4426d1aad458e990b6"
