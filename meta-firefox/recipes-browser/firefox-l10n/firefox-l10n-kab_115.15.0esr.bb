# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d8ff653e11642b4625062e630a1805b4"
SRC_URI[sha256sum] = "90dd4e25be1ddb337b2b30928fc9e48f59d6ab2b1e0bd3ce9c072816702f8cb7"
