# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c79b1167f477471096731efb34ced2ea"
SRC_URI[sha256sum] = "b2eb62e0339aba733df4e2bfc225bcd74650f29544c8943218af98bf1d41b4b1"
