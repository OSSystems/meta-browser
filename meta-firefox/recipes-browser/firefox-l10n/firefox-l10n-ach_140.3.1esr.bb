# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d2605882b27bf97b515069f10f9162ad"
SRC_URI[sha256sum] = "093c736eb47c8d28f5b5989b0f637b59c76310e831b70f779e093fa8b8886348"
