# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e8d9500d0fbed7ae1bfa0dba1ce7173b"
SRC_URI[sha256sum] = "3ff2e2008168056f12a7fbc9680335846e7060c419bd0054f59c6c4113dd9218"
