# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "02f5c2fc2a4b8982b33a197911f686ab"
SRC_URI[sha256sum] = "65e340576c096824f2d4d140443e44b232474e07e97c6aaf258abebee7f2808c"
