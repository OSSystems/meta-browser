# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a796f458ca268d813f56e13937bc6fe3"
SRC_URI[sha256sum] = "c075ba98e32952c135739764c443bb2ae3ff2fc828b1457818a1f70d3ab00e82"
