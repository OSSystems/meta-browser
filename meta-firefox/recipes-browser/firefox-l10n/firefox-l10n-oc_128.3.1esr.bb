# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c27a0e3949e6cf64f8c0c8c4a498630"
SRC_URI[sha256sum] = "85dd2f11339c001f5baac066bfd24208542d58eb19e1fbc3154e0def0b1e6ef4"
