# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2d8c6e045e42a7e0a46ffdbcf37e5897"
SRC_URI[sha256sum] = "4afda8c7ca1b28fd1d58e629162a5c6d3a1c029bbaeaf398d51e467ffd55d4c0"
