# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "67368f1b514198693dfbc49686684355"
SRC_URI[sha256sum] = "9c0fed216f4a4eb529a28999861b3c8bd6ac9ddf88920741359d52be1f327ce9"
