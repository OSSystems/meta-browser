# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "de842fbf399d19be19f4ae6a16035ce0"
SRC_URI[sha256sum] = "baffd3f7daef3bbfa0a5f18f8f3fac024ff41365de558d4ad59a819fb0ced08e"
