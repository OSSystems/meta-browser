# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7618e4eb0a2e412f98106ab013712110"
SRC_URI[sha256sum] = "e32a9fd39e14ed88d83b3fafe3d756469c4e3b4aacb05156fd1b5f5c7ee3094d"
