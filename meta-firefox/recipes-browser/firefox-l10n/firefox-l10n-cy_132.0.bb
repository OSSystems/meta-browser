# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3a4c881b486314246d7f210df237e331"
SRC_URI[sha256sum] = "97287bfdb27f865f917b93daa62425f57e44df14c30df865abee42e75895e78a"
