# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ba3630a649bff2e63542b419d31988ed"
SRC_URI[sha256sum] = "a870730635d7e6770ad42ff5bd6c4acefc5dc86d131352408e1aeb320f680a95"
