# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "667cf5f64ad3a7a0e07d9fddba032469"
SRC_URI[sha256sum] = "50bc599008a9366a963cbc5a9554fa50f21e37029c56d94cde468997465c2f8c"
