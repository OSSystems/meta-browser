# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "80df8d09f0725976ac1a68a4b99f06ed"
SRC_URI[sha256sum] = "9cb14cf688664d8bfbbb425f7d4be22cd42c3438e4f5d0b82ee03cdf2a47bebe"
