# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8a318b15c5b00cad4bf9829fe7f10bf7"
SRC_URI[sha256sum] = "a11c2cce01e20cf22cb758ac48f04e13443015562e6b8425150524407dd17f4b"
