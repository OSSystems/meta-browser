# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "17be2ea8438bd1b34958a1b0944909ab"
SRC_URI[sha256sum] = "4b56f400a9091bf5baa77f01181299e2925ebc94728af7e9ecc7e559bab898e0"
