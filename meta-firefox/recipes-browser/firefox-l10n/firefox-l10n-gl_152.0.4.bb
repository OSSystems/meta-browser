# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3cbc0377f32a76e67196f95dd701d7f7a1fcd80d565b41177bfd2cc438674ee0"
