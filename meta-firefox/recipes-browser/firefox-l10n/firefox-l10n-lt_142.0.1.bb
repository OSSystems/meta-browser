# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ee9d50de2c3ea77f07371937399b7956"
SRC_URI[sha256sum] = "f43df56066ea2955b525fdd0f9a2ba59fd553e8053847fbdc95a7833240bf995"
