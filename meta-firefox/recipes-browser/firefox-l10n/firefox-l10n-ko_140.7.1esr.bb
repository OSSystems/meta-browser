# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "207dda00582d390b5ee5b93fdc140b08"
SRC_URI[sha256sum] = "7a5e02bed18b7fd6c0e4a55130521d032e43b03615c112b55bf424f251e96cac"
