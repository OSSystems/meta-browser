# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c4159887c835cd5a6b7e5f51c8b6b389"
SRC_URI[sha256sum] = "affe60d6944b29dca9dec193736ebc3f392b589857e72d900199a4336d54431c"
