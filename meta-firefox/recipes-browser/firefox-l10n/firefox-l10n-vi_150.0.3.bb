# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7afec5a0c5397700f5fb822a26e2e9d43e9894324d725cfec7286abfdd499454"
