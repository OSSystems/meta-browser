# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a4e76b72e551e3c28fd76225d7c1952c"
SRC_URI[sha256sum] = "f032233806d794ec925032568d3286e0d5a83889ec6cad644b3db0961a7082b7"
