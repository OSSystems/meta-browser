# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "06b71a9a0e133464b4963362bf14f32d"
SRC_URI[sha256sum] = "160590f19afaeb2cd1bcd2f112d42026b579246e6db99d9ca9a434e1cd150e92"
