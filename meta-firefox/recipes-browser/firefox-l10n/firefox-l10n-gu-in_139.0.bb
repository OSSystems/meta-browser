# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f54e6e5b259a3e5a640b2f13a8201ce0"
SRC_URI[sha256sum] = "6e1f9ee761c722e6d84fb2f91939e4366b6c6bf3b2ff8756a42273fb2e04db4c"
