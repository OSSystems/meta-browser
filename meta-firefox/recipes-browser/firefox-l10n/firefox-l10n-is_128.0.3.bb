# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "62a44ac33e5fe40918a3ae0c79f62c33"
SRC_URI[sha256sum] = "1167fdf91f92c3ed61af7e2bbe39c9f1976f062e2c33b0ab15be5f765151e470"
