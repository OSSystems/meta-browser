# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c3eeec2d18b16cabbd4e30411dc2d279"
SRC_URI[sha256sum] = "039d465ce4939335b8a45688d88cc0757e56520e29110372f54311f5ae4b4364"
