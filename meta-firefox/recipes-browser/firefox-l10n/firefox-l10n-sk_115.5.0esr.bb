# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5e6f4da499eb4432e8023c3f7d8a4d79"
SRC_URI[sha256sum] = "d2fa76a53940608f8842247536eba5c549ae519130b758d2f0ce09a56fb7c7c4"
