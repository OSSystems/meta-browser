# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "13bd4ccd24b9bd8b301b69435b7fc625"
SRC_URI[sha256sum] = "17e569140b8180d2cc44daf11e01a58f7609ab6501d45f0d6f6d3dcfb7bd1b9c"
