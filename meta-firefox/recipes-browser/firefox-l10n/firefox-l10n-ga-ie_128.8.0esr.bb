# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a21b5ed5f038932cf0553f9b50dfdb13"
SRC_URI[sha256sum] = "eea53bde0fd0746c4c4c5f87d8d2a1a6882cb2bcfedc2c52116f0496388c6131"
