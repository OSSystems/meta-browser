# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1d654f6dbd16178a60ee491e9f05e98f"
SRC_URI[sha256sum] = "9bf2d68515615b2467e1f43f514120c0fb4cae64231b9cd5a1f075cc51a443b2"
