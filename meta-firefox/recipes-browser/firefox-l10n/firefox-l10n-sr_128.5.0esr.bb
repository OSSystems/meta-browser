# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8874e640847671878b78638034e126a3"
SRC_URI[sha256sum] = "abf05f02cadc5bca8906bec21177cfbb05931d66477b4cdf0f67c7e0e9362be7"
