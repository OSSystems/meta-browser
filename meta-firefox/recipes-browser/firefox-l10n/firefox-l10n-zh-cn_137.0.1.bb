# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c95f5b264a286bf2eafd9f82e40e2916"
SRC_URI[sha256sum] = "9a7bfefb0898ff9717dff35098f9ecc5ec2430dd9fbbf5434ab3dcd76e443fe6"
