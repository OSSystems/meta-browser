# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4e68fcc5c7f0bbb674f970682a1ae99e"
SRC_URI[sha256sum] = "042e34d04c0b5be657db3f0cf5b8c6d22e4ee6aeb61cfb2ec4084dde013babe6"
