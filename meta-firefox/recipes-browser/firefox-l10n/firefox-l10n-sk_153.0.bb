# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "1ee0e72653b27b7f67765c594cbf0bf8fc2f6623f947f6d0035774f2dbb44019"
