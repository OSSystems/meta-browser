# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7d436b74073a816641a2a12e2ee10041"
SRC_URI[sha256sum] = "ab49bc0930a93eea29daf8e78e0fd53ec535cdb03e67ce4e7a7a34af84203d25"
