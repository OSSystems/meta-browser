# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0fbd61053bc5c59c3a37460037e337ad"
SRC_URI[sha256sum] = "f5be1d5d003e5fa62970897794e3c079ea4231607c9ad3fd8588e980e689aa0e"
