# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bb0f90b48a8cfc3014de4c21bdbe0bcf"
SRC_URI[sha256sum] = "ba45b3bd3282dfb13ccc68fdeb86f90db883a656cde45976355141627edaf900"
