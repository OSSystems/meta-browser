# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "89fba8815f6b41ae338398962fe6abc3"
SRC_URI[sha256sum] = "f5141fbe3a3130bc0cdac9dcfa3ad966a040d6fb81c78b1ca00c38ba07aa84a7"
