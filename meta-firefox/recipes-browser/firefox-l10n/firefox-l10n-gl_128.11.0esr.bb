# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d8c387f98725dd29bac0183d4b8d488c"
SRC_URI[sha256sum] = "e2e77bef60c5546c6a42f49dd4604e5a90b2b3d2a9af5fb1f512ef40cb00170a"
