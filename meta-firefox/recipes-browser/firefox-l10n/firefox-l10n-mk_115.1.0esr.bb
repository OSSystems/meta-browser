# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "48e7ca5dcde7d69745bd9ce77147018f"
SRC_URI[sha256sum] = "011bc63c1df7fe064b97c39fbccacb4a2017e70304e1c73975d723bb616366d3"
