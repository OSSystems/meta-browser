# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dc44bf1038dea3015e9222feebb555a6"
SRC_URI[sha256sum] = "7ba12e39d2361c3115ca23cdb0d5f43f34df3da0662a3b9fa07b32c96978cd20"
