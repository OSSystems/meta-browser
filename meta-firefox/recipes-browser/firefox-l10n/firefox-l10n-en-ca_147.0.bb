# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c5f6c40f2970ba9160aeaa134e1b68cb"
SRC_URI[sha256sum] = "625fa0db359285dd67acb6694910abdfe0d5762e9963d59a3ac7cefaafa3e3d5"
