# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f1b01c038e90dee61baaa3004ba874c3"
SRC_URI[sha256sum] = "6219fa56ed6c3dab20c0e7ffcc20d14ef2a9079a171c5a25430c125b2630601c"
