# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d00011f258efe31f0c7d6c0e86124ef0"
SRC_URI[sha256sum] = "622711c7413d64d1707a63df395137f167c63a80553509cf3dbf8cd1511eaa5c"
