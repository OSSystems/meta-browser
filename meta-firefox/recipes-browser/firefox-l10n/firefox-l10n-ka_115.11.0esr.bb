# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e3ce57c44f9fa2ad963a0b03d4e68ac4"
SRC_URI[sha256sum] = "951595d568207197fe7add74f7af9bcc661b8a1ab75e991171de0b4996d74b92"
