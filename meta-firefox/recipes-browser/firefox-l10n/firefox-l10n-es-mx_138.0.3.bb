# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5e1b5db7cd5e59aaf04731b22671fdec"
SRC_URI[sha256sum] = "bfa723c963b26cbcae4ba0e6f214d363a46640b7236666ff671debb8bda52de3"
