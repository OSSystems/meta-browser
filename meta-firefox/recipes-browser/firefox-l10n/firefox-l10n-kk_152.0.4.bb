# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "fa44603b1a9021c3d749967fc629c8a720967d16786d72bcbe40302008545e8e"
