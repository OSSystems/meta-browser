# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "691c432ba23374b030aa44d6e2203c85"
SRC_URI[sha256sum] = "63d39e81caac19c2bd01936584b2b428681afe13573855629b3a7d21ba364316"
