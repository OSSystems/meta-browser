# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fc3df1630aa7ef48d1da4f805f1ce17c"
SRC_URI[sha256sum] = "55e310e27c2087525572690a6e4a85447bcf8a6fa53ad42594279f83c1acc7b8"
