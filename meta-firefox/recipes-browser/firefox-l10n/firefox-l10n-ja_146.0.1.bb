# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dbdd9c907924a62da1fc943df041ea9e"
SRC_URI[sha256sum] = "931a02e203f97f0de76ad9043890418a801c35b5933db3517d412e7df4cb0a7a"
