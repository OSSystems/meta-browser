# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d9c8cc582c096b77e131d8bf55713f07"
SRC_URI[sha256sum] = "a126744983ee54d7bbd4dfb5aae9f03ce1d73a9d4ad4d7b91b7e37dc1f5e3e41"
