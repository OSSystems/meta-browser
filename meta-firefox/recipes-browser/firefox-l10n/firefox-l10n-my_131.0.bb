# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ed6232bb864ccf02725974107a1be9f1"
SRC_URI[sha256sum] = "707a2708f3b9ec3b6427df0846353f97d642564fc3f37e887cbae3612ab24c94"
