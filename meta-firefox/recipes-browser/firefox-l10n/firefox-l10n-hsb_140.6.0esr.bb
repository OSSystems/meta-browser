# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2d3932bfd24b9a972dfea0017f09efa3"
SRC_URI[sha256sum] = "6488cbe9122ab9cfc5b087d0d9e4e6171ad79538fb18c78e32b2598ec06cb9dd"
