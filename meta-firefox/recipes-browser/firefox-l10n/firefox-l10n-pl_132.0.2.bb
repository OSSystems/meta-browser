# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fb6441ea836e9995e8ec6657d804952d"
SRC_URI[sha256sum] = "90557f0b9f24e9a8173c647834f8ca87fc69238d7793377cad711ce88a0ddf32"
