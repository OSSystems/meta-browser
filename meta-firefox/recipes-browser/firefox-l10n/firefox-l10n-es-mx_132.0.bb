# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e2392cb4730a9617c0d344ce88ceea30"
SRC_URI[sha256sum] = "e7a5774a22d5c8b0f59a16211c2ed8d588f47fd9bb6e33d17489e1aa3a65340d"
