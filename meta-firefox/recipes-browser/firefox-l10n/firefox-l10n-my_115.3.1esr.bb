# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c12f589c611585f2ebd51907699b379"
SRC_URI[sha256sum] = "02f86b6f0787f2d200f215de574b8930f10e12357ea9de9d45f327ccecd4b0cc"
