# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d9c12f9b6eef4c08d0dfdb1613ef6a46fee2bc448c9f334f6fd79f580f011324"
