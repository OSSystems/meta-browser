# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f8e2d26e7e2e80628051096705ee75a6"
SRC_URI[sha256sum] = "7a943149cc6b600e7766c2e8f6fd51bd620fb4f5cf343b36acf3a99838c12fba"
