# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6b6db743015479a216227c0a37ae4db0"
SRC_URI[sha256sum] = "0ed1d2be05b6c00171c222bfeb55e51489b57d3bda25b0a0523cf81090fd8688"
