# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "96b7f269f5a2e9c0dafe6046b53f79072a1f0712b5e46daaf7c7743a7193f638"
