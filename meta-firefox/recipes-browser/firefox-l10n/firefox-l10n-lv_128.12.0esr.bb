# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "260682aa9b9ac4af952ce01b26627ca0"
SRC_URI[sha256sum] = "6c8aec6bf7d00a027a0d30776d2e1ded77d64c6d1b9a2a3f087184c50d1679b6"
