# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "430d8019f6b26d8658877f9b17a2d27f"
SRC_URI[sha256sum] = "747eb88b5c16c92ea9b32e524a865c2ddcc368e1ee1e921714f0a5580aaa7d4a"
