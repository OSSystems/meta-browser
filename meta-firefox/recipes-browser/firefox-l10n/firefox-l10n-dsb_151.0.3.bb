# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "de5e2d811b6cc5988eaf2abef415dfa2203e134a86a817956f1e7528cab7b822"
