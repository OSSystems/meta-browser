# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3668315cec22d1e26abdccbdf549b0b3"
SRC_URI[sha256sum] = "51ad0edb1f46663dac715e33d4fe7d5e51408a94357a0c588d75ad5abe1347af"
