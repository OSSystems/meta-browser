# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "efceb4158d42bff8733b012c2e534cb8"
SRC_URI[sha256sum] = "b1ae2a1a57bd40cd49a90d853f973add1385d0806188a3e0ec1261f38994b20d"
