# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "115a3ec25212596da8b71d059f12725c"
SRC_URI[sha256sum] = "3b8673ee4bcbe47c69965492f01be10ddf21659f4acb737d53c793e4a0160722"
