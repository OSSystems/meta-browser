# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a0d340eb567b4e8f62e500f22f5e62ff"
SRC_URI[sha256sum] = "3975f7467d5129402d3d3ef5ae78001d7e76bf3b468409a10d6e2f7464ee9389"
