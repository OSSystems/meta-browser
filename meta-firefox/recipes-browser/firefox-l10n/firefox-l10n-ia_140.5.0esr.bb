# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e5137aa5d2cff11a58d7d26b4701f662"
SRC_URI[sha256sum] = "da84f9960af5be1023aa6c15cf00342d48ec42cbca89f019fa8a235ab45a225d"
