# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c6001112245cf6ae0915067ae9a4ad28"
SRC_URI[sha256sum] = "6d394a44dad03538530813c3689ce9c21bc680547fba5e20607db57025492e3a"
