# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a26facf7f7a6c30dc5792198a5a79d00"
SRC_URI[sha256sum] = "a608b9259fe6064e12ef11b4ead4330fdb11729c1a24d7403d237c08383e15d4"
