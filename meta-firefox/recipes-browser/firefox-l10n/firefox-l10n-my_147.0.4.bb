# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0ac26ca058705c4b177ac1e3e5c3b022"
SRC_URI[sha256sum] = "bbfeab47b5f3eab75d3ba25cca5df58b6308850afe3ead9ed395250bb47c0573"
