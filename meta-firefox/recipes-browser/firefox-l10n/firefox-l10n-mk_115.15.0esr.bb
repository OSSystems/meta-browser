# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "13983249a4a41e2a8009f9c4dcee2be5"
SRC_URI[sha256sum] = "7d6997e8341ea55cc86934c5eb5819cece29516bd02930d3f7bf0a5f53dc5403"
