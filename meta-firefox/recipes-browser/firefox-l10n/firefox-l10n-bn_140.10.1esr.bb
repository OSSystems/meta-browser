# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "4880711d4c46f95f6a61ca5b5ea4f182a98c8789e213d1a8f19757577eeff0ae"
