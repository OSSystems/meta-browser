# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0a314b53a69687f39791561d0ef30174"
SRC_URI[sha256sum] = "bbcb1ca23d0719aab9d2dc184ee354d65525fd78e8672ab3f0ca69ce5d65391f"
