# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ff7f27b34dd01de9f6b203568ac029201458a38af896fe0fd59959bd85116f63"
