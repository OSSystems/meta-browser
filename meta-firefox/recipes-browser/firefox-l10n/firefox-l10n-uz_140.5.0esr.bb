# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "28a862263b9bdeceaea96d6bd05404eb"
SRC_URI[sha256sum] = "b75d61e91420c6faa9b00a511e0ee7ce48300c8752f524e4374ecaea98d1fa09"
