# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0824b66d89688281cd1216473150727c"
SRC_URI[sha256sum] = "79f43e3fe2d30d5592722dd0094c7ef48eb7e4b2179c34d16d63b66ae6813ed0"
