# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eaf1c9470624ff9ab099157e4648c5e7"
SRC_URI[sha256sum] = "cf14855fd00453122f71c8632d4b3ef3a19945a08eaccdb1c95a1c215fdea68c"
