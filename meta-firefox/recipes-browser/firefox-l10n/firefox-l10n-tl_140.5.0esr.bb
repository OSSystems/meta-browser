# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3e2fbe0693c6e163f92000f323278eb1"
SRC_URI[sha256sum] = "37fcae0d2507f18897db36604e0c8b2f1c4a6862245b72bbff81f11e7bfa201f"
