# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d4689fd2a8b955867fb6c5be97dfcd8b"
SRC_URI[sha256sum] = "d92749f1d076bf4ca3b34f7715ca531c08f1afa3efc3d9f086be7ff19cb1ec5f"
