# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3c408013613ec208b91ec961394070eb"
SRC_URI[sha256sum] = "a562a32d54fa13dfdd7eb57ad5959a5cfd88802daff563261ba3e1bf0984224b"
