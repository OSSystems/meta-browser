# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "828b8923a7c34c60ef05ddfdde213000"
SRC_URI[sha256sum] = "8f433e6c068967f66879ef3bdeb63c1d1770f198f3e8b7c92be8a04ffa63ba8d"
