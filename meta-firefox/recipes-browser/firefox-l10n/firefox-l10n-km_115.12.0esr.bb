# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f535cdb0265f9718684815bdbd5c0012"
SRC_URI[sha256sum] = "cb398fd6678eccbbaa7e083c3ee457a32af19d871b15b9b1d66c96dff1c8a014"
