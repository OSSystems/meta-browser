# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2ea8cfadcdc6b79b124f2e4a2da5d82d"
SRC_URI[sha256sum] = "095883315793fa7d2a92c5221cb51afdea23e6dd3cfb5bb21cc477306b2bd9b1"
