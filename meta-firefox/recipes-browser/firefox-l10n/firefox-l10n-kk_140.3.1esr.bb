# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "50f25fe69cbc0b94294d9d8f9c9082bc"
SRC_URI[sha256sum] = "70cedf4fb1e6a4f75281b4a0940108f25ba41cb596840b209c6d6c5cc49209d7"
