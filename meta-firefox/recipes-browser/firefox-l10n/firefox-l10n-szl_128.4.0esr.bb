# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f68485834a5c5de7536fee63a0f6d623"
SRC_URI[sha256sum] = "62536a48c3bdfc7a9818507eb5a5cddca176721cb6778316b78aeb07e08c2fba"
