# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "acfcbfb29879e06abcc5bb4f3c57b169"
SRC_URI[sha256sum] = "22cceb0d0dffe8972bfcec01a3de60a2eac08bdac7a040754793d30829265d91"
