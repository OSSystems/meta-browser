# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5af8d3593dc0ce47f7935efe67388359"
SRC_URI[sha256sum] = "50b66c9f315ced8413e712a74f5fb4a11a1736af51898fedf7a889486bf31a13"
