# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "86114dc11512d348052732f3e53f23cf3ae8546eb2a0d5817107757a3c89b06d"
