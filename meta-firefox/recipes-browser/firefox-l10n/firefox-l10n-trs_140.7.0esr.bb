# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c11e9c07ba765ee4173decef9a6213fe"
SRC_URI[sha256sum] = "de39f19c139db4fbf465d0b14a27ed8fa2efc30a57bfe7bbaa2e1ab73e30560b"
