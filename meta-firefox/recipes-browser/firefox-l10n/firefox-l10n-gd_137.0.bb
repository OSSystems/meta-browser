# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f5ace0b970fe361e730f2a0c8c0dc9d5"
SRC_URI[sha256sum] = "d491be9fe0e6fcc8f8a27a0a0f727798ff78886e2454cd80f8c78390ff4e798e"
