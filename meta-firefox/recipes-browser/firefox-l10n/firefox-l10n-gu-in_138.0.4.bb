# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cf9664eea52f1f8876c0abf74e417bf0"
SRC_URI[sha256sum] = "6ba806ea6bcab339102de9925ce149b2180876fcee9c8d765e33632ae7eef7d1"
