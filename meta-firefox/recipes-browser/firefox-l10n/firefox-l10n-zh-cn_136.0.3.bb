# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "97e9186e05e35172376732158e6d2822"
SRC_URI[sha256sum] = "41ab6a83c242300780e80e7077e880b247f030b6a300d44f9c115b7c6585382b"
