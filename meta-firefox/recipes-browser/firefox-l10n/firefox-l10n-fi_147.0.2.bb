# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "54053e71d87ea6d623acff2d6838a5a7"
SRC_URI[sha256sum] = "e9ebd4bd5f8a38ae2ee9101439d6538e4e145c16ef6bbf19406bd1b7a963dbab"
