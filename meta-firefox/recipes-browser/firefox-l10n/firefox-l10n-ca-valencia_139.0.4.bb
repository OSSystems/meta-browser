# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e9b017f3de05bc65542a825171766a49"
SRC_URI[sha256sum] = "ba53d72b7ff1722982b814a2caacef8f3d224ba7ef62633af41e5353b2f301d4"
