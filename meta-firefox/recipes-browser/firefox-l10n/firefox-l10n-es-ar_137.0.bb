# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c032f00e133c6d45d07580c3289290d6"
SRC_URI[sha256sum] = "4d1511b17435ba2b0eb1f23fb06996b3a8dc92885221d5bf36380825f2ba428a"
