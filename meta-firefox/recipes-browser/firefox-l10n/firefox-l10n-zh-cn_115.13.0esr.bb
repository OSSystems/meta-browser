# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8a45ee5fb4c9705f61deb5ad36070787"
SRC_URI[sha256sum] = "ca5b7e5148106453f1bc843f56eedd0458e589a47a29f7e1bbed27360b727833"
