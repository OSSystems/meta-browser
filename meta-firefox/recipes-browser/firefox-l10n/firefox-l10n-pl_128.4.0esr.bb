# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f3bc546e16f2fbc5547813142bb9e621"
SRC_URI[sha256sum] = "9e9bd6e766042a45510ae04a8b3cf69fdfd6111e9acabd915808245c5679ced9"
