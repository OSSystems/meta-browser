# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bbb0259cecc1af20235f65fb06bc1493"
SRC_URI[sha256sum] = "6b08d0da94bc732a2f10d4698d90ca3e3695383f076ae7a5fa74c715d469838d"
