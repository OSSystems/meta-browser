# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ee86ded705b34d3186a0f0999319d311"
SRC_URI[sha256sum] = "cee5709086ecfe86929eaa6f1a18adfd6aeadca8a6552e4051c00fa20e1c37e1"
