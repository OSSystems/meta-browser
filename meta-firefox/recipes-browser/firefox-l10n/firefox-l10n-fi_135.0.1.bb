# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5ec3055aa488e78967ad0eacb7138ce7"
SRC_URI[sha256sum] = "578da1adbcbc98d8983d4d707570c3297e33b7206c03bcc8596150e7af18b66a"
