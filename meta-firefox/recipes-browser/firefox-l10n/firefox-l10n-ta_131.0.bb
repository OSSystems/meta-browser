# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1502e0473b8df38b75f13158847c025e"
SRC_URI[sha256sum] = "9128528adddb0f1288422ae7986c5002a53e117c031f47e4ec6b1f410cd04c1f"
