# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e62fb6ff08a4f243278418fa5474c6e5"
SRC_URI[sha256sum] = "97b74bb136bc59dbca6a10c59f7565c1069266a77812bcb50a67d578b92c41d0"
