# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c7e990b89ea722f2c47b74eeeb47ecf0"
SRC_URI[sha256sum] = "c750c3ae0be4ff96b3982739002793ce032f1392ae00cd6f5956139ea35d816c"
