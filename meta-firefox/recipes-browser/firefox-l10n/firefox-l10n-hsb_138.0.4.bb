# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0ca2c38005d398880b25d525822f352a"
SRC_URI[sha256sum] = "cd648f6aabd1e5ba8ffc66a034d6c48ee384099ceab41f521ea421f727db1ef3"
