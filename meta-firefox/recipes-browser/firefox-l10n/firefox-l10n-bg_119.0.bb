# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "39b1c846697874623c8d9a7e72b08a3a"
SRC_URI[sha256sum] = "26c53266a7b40b71b3a40ff5379ccb1ccd9239ffc39bc22948bf9c4c74d05aac"
