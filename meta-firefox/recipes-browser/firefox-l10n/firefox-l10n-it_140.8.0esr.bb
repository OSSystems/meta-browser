# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "50080e30c9c9b2acff74a41d1706dc49"
SRC_URI[sha256sum] = "9bb273364a63c513e2506b2538b288dcf79a59eafcccb1fa71690144b66bb238"
