# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9e714e154f8e8f5e841dc4c2ff98770c"
SRC_URI[sha256sum] = "5e90d527dfe3de29d0b64f65356cfbab9b7e8877ab82d314320f32fccfdb1a12"
