# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b305a70efc530fc8bd0eff17fa8b4d3e"
SRC_URI[sha256sum] = "0db7e123ada612bf3fa7a63e403c3f5524390dcde056c285f75a321eec8e42e2"
