# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "119ebbf6f3e67c475deb4c9d600e24a0"
SRC_URI[sha256sum] = "d879a6633177228de4e84ae8b827116a0851f5686ae6ba71dd45ebb8ff905ffb"
