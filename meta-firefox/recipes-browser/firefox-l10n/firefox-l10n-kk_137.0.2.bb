# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "776dd1ef76da46c175c8ba82680e8d9c"
SRC_URI[sha256sum] = "db19a5253eb9a9a971caacbf6e89bf6721da12b6707ef8e49519bc17fe62cac1"
