# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fe933d1faba98a37a0d51aa1206ca481"
SRC_URI[sha256sum] = "d8b4ddf5cf96da2a5627a52dc60d9cf6e8566bbcc2d4fc86b65983e6f57d74b7"
