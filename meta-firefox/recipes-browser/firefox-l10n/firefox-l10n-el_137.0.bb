# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "95b4d6ec76187bb623a2fdfcc9dba7cd"
SRC_URI[sha256sum] = "81797dbb80160ab42577a708604b4cc9f51a7875097f17c2b4eda49283a3d445"
