# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1647f1dc1af7eae433573e36a2d8ab62"
SRC_URI[sha256sum] = "c0fec6d4442fae8af938cf98015fb1d70a701dd778a027f040e76e927fc8b09b"
