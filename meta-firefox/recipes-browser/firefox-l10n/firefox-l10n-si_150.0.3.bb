# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "cb08aed4964ad45a9cdeb8d3966e66e912c98eafdfafc62512262e1d64bc770b"
