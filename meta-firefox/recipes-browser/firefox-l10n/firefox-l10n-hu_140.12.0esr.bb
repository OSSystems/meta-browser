# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "21ef583c10b710a6c95adc54eb669faba7defea8c64f476e78a6eaddcfb31d5b"
