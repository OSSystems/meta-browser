# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "5c1968a1dc562ec3be1aee5f367fe92bf500a70614441399638c857c9b3d4e20"
