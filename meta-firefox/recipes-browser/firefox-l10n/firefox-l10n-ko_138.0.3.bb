# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0027c1130f141c1d8da5307369b3716c"
SRC_URI[sha256sum] = "d8ee0fc7e172f0a7fa94ef3fa647d1c4171df249d5e8d7e325e3f442fdf052af"
