# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f43a44bdcac32fffc6e116c7747d3ca1"
SRC_URI[sha256sum] = "13d56ed4ec1cbaf9f10d4f113eb3a867b821b92f99ed622f6a2a36ebf719f753"
