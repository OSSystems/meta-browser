# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8919f7262976d963fae9ac9ec7a493c6"
SRC_URI[sha256sum] = "b226a4ecd4f9c67025f6068fbad5be6d12380e56143198bb2a29d3b08484c4aa"
