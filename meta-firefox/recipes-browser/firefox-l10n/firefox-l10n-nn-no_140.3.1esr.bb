# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "80366bb299b001cd4c667af3b8cc3769"
SRC_URI[sha256sum] = "396b8fe521c56c316cd1dcb0cebee783f2e8eb4029aa39295459c8699143b9e4"
