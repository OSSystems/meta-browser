# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "784f656bc660b644131f54a71091324e"
SRC_URI[sha256sum] = "62320023f75afee205cb760ad1e983779d428d7eef585c50fde33cfbe5ad5780"
