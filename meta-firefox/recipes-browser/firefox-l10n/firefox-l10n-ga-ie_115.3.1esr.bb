# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "da5051d6fa7ac2e1e49a57a11ee587f9"
SRC_URI[sha256sum] = "8142644a7bf7b6ec5f54f6fc9c2c3763155f29fc2e1c72279abbf6db8a602910"
