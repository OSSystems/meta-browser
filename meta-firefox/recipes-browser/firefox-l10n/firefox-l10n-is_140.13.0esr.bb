# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "f84b58445c76392eba85c3c76872354215b989e86a8c74b9a8f828a6bfe5d9b4"
