# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "11d1be429146db23adf1e4443a0035c8"
SRC_URI[sha256sum] = "c3361587e318e7010069050a5d5ca27107237ad948e3b17d976ca687ddf9a3ca"
