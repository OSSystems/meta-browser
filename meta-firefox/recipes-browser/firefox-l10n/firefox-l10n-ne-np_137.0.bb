# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "da36380b3433c058622e23560d4cb974"
SRC_URI[sha256sum] = "cc3518655722bf93c069a0f1b2d481830935fc37938cf21f69ebf0c578fd0a8a"
