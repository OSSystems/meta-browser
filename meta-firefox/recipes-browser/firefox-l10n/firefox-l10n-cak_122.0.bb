# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f78121ee88dc1af4ac11c91c88a2441c"
SRC_URI[sha256sum] = "228596f4677edaa0547283b9aced056bf9fd87e95acf678a40ec57ab59943081"
