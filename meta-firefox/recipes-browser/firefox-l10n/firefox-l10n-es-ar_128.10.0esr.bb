# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "36aa82cda4f47c112cc7c93dba847881"
SRC_URI[sha256sum] = "9578b4343d0d77e1bdd88ea408c472b8a5a7f6ce8c4b416149adc0e64a2b5763"
