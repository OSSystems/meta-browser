# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ac7fcfb0da20bf65926ebeef10b29612"
SRC_URI[sha256sum] = "ba38c8d5b99137e57aa3ae66db6c9656f8edbd2a062f7155dc3d6ce71aa0ab32"
