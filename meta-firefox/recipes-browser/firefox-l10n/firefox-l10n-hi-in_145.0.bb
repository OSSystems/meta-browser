# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d39fd365b9c5cb096cd7d92a40072c34"
SRC_URI[sha256sum] = "978f8cc27da240da1d1535853fbf17ec8522adf23f0150ddcf2415123e6138e0"
