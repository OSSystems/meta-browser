# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "847505c3343a31b0a048cd1965e5831c"
SRC_URI[sha256sum] = "8864027b60016b9bfcabfe20bedeca6c3e31ebd9b65be888612fedeae5d1d7e9"
