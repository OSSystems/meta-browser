# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "af419eddc975efe1208f24a83f7d1a35"
SRC_URI[sha256sum] = "2b4f86ab9b7f8fa39b290913ff7b98d966f00005fc81b4a8f836320edbf16680"
