# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e1e7403f42f44e637d855de1df036f40"
SRC_URI[sha256sum] = "8ba9b29cb295351205b41555965a68a2c15b50fcc26ac315f13c31a441b486b6"
