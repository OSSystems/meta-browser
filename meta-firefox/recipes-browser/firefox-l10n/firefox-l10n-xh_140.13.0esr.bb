# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "adab67ffc7391876b00eaf980f0bb48fa9f41b77e8444804a5b3c082220821e2"
