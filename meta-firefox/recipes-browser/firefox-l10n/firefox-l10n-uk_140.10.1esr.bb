# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c0ea5a7fa48f4a826ca515820a689aa6588efdbf9073eb4b8cea4d32d885c09a"
