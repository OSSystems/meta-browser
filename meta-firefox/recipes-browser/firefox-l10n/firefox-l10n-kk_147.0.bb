# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8b464034018680844937ea4a79ad4bd5"
SRC_URI[sha256sum] = "830776ce9ea089aabbb99d4f41248e1a9c6fbcda6f2308099a18851d670d7beb"
