# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fd386b7907e93d3e3858fde5c6a11916"
SRC_URI[sha256sum] = "48e5a33d8a179248a9a529e0393bf38e0be38184f1aee4d570094f7bc2409a8f"
