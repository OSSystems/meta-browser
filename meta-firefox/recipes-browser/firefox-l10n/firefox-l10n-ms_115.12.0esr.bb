# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3b1b3a913c844b55fae2d24e571cb238"
SRC_URI[sha256sum] = "4537c2a335b0c0c55f0ed9c56b37c1e4173017dbca19bdea836a20e45cd44d31"
