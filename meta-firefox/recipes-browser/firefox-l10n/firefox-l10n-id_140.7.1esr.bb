# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b825baf38f4f3669a4526e29938cda90"
SRC_URI[sha256sum] = "ab3509c0b37e35485d221b2fa4851a574f4c7df0b3d41a2d7873185a8cad36db"
