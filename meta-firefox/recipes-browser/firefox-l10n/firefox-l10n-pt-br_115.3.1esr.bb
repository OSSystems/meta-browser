# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "70b42484ed2747180b7639ab188c898b"
SRC_URI[sha256sum] = "ecdfc2be093372c8f1364c34234382c056d22773c5b0e4345db84f8536802949"
