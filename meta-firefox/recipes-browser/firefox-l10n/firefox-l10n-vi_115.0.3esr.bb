# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cb87ba1ecab590f21204ceef4657f46e"
SRC_URI[sha256sum] = "7f47a48d1abbd45c2a3984410a688fd22abbc8f6ea1379783fb84182d80c3f2c"
