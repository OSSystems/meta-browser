# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "af541b61b6b53a0d6925876a2ca79be30f80fbdd577065a14ce31ba1a2b185fe"
