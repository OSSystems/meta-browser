# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c2e18823fe76e52f68054d1450d0022b"
SRC_URI[sha256sum] = "0ca274d7e1e7aa9895bac9095167cc18b83514528deaf8bb96c060583db3c474"
