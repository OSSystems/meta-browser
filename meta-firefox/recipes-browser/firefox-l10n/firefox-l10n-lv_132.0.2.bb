# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b4aaca937d20c5f44a6d54cab00e3df1"
SRC_URI[sha256sum] = "17ca33e2b1db07725a821a4ee55483ae68808af8c8c0631650e1fea769be2b7a"
