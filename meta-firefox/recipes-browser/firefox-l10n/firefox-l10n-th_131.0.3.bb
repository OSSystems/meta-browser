# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aeddcf3f5a67001c0adb4909c7a604a0"
SRC_URI[sha256sum] = "89deabc59c5fb007f82116d1fe9af2fe0ff5340512e93e6ca5277300a016ff42"
