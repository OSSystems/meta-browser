# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "0bc74c0f9bcfdc4e2796ec6cb53ee4d46294fac97d59372450bbc0189d6eaef2"
