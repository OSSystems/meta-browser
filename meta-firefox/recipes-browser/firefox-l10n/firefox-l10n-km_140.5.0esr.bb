# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ce3d4622a335e7ffdfc23f3f0f650345"
SRC_URI[sha256sum] = "06afa419374f05a3c0d068dd6d8bd41930911b769144328e662eb9040f95a2ac"
