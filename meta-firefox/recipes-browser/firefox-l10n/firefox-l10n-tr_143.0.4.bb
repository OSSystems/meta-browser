# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "da35581b91309c7ed1d969fbedd1609c"
SRC_URI[sha256sum] = "6cd297216412dc3101e1d3e729ff249a1f2a83773aca100014cbb9f80eb983e6"
