# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c749310b30d8abb2ce652ac69d6dc8436b2ba67766be77fb8d5e4b3bbf304825"
