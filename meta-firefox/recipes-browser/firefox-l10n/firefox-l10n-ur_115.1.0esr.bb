# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "951a87d7aa1d07d4b9fd4445736d1764"
SRC_URI[sha256sum] = "3ebf528e4244c43a603944352a57e940d668e53e10463f48e9d65a6f70717b49"
