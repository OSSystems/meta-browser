# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "288a5a14db23c38dccafcbdd7fd4dd6d27d2a71cd8fdc6322df0f89c9524b9d7"
