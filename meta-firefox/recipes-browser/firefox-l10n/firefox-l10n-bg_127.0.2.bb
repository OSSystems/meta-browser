# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4ebc49820261467a1328bdfa958e49ff"
SRC_URI[sha256sum] = "e7637a4c49b1bbff28de48b12f910f4ef25fc11a6e0307327873ad087730714e"
