# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3396ed35ac1ab7113f2a319665273384"
SRC_URI[sha256sum] = "5f6c6d69329f0fed4b3c3285d119b8ff2fe92917ae3e438ce536479471363d36"
