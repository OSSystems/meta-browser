# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "73358e7a5d9f85306c88de31e6fa27e0"
SRC_URI[sha256sum] = "e57c6e3430faf1b6ca030b6404a1d53a7bd2c1956f89b41386107a028250bb55"
