# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "951b0bd428838227821401ca8adf0455"
SRC_URI[sha256sum] = "5483caad82e86c21f11caf0b258f056c11b8b4a50973b33034847aa114364c92"
