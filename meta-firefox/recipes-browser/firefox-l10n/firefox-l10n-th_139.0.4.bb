# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e6f7dd0f846c7e9b39c2c027a93af793"
SRC_URI[sha256sum] = "738ec5bffc93f434bd0c15b0ccce6d1ad5914cd586269e0ddc5907d5ba080a48"
