# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "64ae3892a1a192707d6d3d5cf949e414"
SRC_URI[sha256sum] = "39753b53d5ed91c5c908a4162652db225dece6aec457b3bd03a8f231913d057b"
