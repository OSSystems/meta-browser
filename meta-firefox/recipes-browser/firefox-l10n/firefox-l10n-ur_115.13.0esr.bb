# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "18075781bbe9ee9b0e69d74b9e603d4f"
SRC_URI[sha256sum] = "878472dbd48490aa0ebf179680d828ef08b0764d1e2b93d02532639f70e0669a"
