# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4e81a8a434f7d53c8a0db6db3685571e"
SRC_URI[sha256sum] = "1c8e0697324cf6f3ac88ce8005a0134789319b72219d80fc7397949dfb18a11c"
