# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "825c03b97daf2815e4b5b2137255baab"
SRC_URI[sha256sum] = "3a3e92a92fadcd00d33388cd0d90902bde9e08164bcb857e1859ec48c9a12c01"
