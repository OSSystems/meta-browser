# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c05b3634094b4456cad975f9ca238e60"
SRC_URI[sha256sum] = "a798ff3d036652dfa5f082856061fc633fc647ed6ecfb233b76b9682bf4172ac"
