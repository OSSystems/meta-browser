# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eaf9ba46ca34dcb981a56c7303ac33bd"
SRC_URI[sha256sum] = "b75ca0909286c944b3a3ddbe032f51f96f245c722928a76773c2ad80b6d9e41a"
