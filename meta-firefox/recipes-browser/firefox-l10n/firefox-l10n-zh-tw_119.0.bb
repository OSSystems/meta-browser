# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "76e5d6e4ede2cb67b51c1b6224e80f05"
SRC_URI[sha256sum] = "a711c4d7f8547c66ab23fc60dfb7356912cbd4c24ec87624790ee70b12c5f6c1"
