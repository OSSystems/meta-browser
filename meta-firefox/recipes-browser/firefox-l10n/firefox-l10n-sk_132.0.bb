# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "385228c7d393b8958f3f79e94f694d51"
SRC_URI[sha256sum] = "07159e9a5c87cf212a6e24efdbda75efe102b61e0f099047394da576bc28a95e"
