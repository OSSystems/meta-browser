# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "cb83806dad98afd15c80e91679a0fc154c16f3859ecd90b31142eb4eae59b3de"
