# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "553bb896eb4b6ac98f549bca7fef991f"
SRC_URI[sha256sum] = "e6bb7f7b6c812a068526d81bcf942b144c7594cee2ef10c360b1dd762e3cd69c"
