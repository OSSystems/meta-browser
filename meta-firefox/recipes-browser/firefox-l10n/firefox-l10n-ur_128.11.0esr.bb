# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0e4188a8e040fbc19a87023bc6d0f881"
SRC_URI[sha256sum] = "0b49d34ad4fdf361510c85429d57e0e28a1688d05e7c5360d9f467d89a0caa2e"
