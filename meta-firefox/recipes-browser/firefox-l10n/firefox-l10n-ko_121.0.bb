# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "79390dc15c4cfdaa1d471bdca26ca2df"
SRC_URI[sha256sum] = "32bdb19e99bbb074be39551b051323f4510d074eda29adfceb4698890620f670"
