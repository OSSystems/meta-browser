# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "37649c9a66fc08ab3b18b98ed3e3a9d2"
SRC_URI[sha256sum] = "eb04bc03d58c304cd0b2c5d9ad083f1cefac6e7a2f38eacdf4689f54232b6517"
