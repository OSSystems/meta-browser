# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e57a6bfd140c56b9005c2d0dba23ba42"
SRC_URI[sha256sum] = "115c6214773de149eaac8ce27fbe6d0d932e193737cf86731336f99030c9e634"
