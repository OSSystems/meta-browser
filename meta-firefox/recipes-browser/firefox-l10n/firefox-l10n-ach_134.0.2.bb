# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "11c7ff93e045f1593c75e6d7d6cbe439"
SRC_URI[sha256sum] = "442265cfd074a9feeae05e5bdf6d0d771ac32fe928f3a87ff152f79305d48a09"
