# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7318bb6ada558e516981e901c21365fc"
SRC_URI[sha256sum] = "1b3e711672a6583aae23a0fd2da53f88405b6edbb4b81b7835f5e9e32f1ab9c5"
