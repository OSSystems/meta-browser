# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2056a4ba170b7f160bc86de7d2b1f6a8"
SRC_URI[sha256sum] = "ef1e9bc961723d59a144476355f500cb7343a40978c1a21178590f6dbeed82b5"
