# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "674b45d6e2eb6d321561769a5a507352"
SRC_URI[sha256sum] = "79c4f52e85f20588c8ca45a79971e6152da683d4aec9beade2cf3b04ffeb4a8a"
