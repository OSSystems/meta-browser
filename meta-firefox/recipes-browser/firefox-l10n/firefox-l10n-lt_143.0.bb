# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "50207a561829f30b9e57de7efd226358"
SRC_URI[sha256sum] = "71ea09de705ddad77b67134bc8613b2192c4d20f2f3916b682f66776a0ee5098"
