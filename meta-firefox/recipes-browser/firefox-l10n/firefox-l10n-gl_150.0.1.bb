# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "059f12897a56d558544ee85dc41810581f0165114fb4e9b05d06c02cceb9537e"
