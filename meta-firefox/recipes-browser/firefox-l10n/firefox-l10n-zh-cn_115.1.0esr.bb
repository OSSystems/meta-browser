# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a03c92636cbf0ce1c2250c3c3e2b3db6"
SRC_URI[sha256sum] = "f9746a9bf592ee87ce82f056efc154c79b464325564df6145f4a096c0805d02a"
