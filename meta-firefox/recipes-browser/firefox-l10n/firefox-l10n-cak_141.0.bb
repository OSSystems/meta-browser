# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7aa1e86d81b8ac591310e35c4a06487b"
SRC_URI[sha256sum] = "7f42e46457442d9d4e8d7b7bf74c889a308a8448aaebf75f556b5ca4c73fb13e"
