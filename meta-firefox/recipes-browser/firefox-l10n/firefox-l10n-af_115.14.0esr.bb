# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1b74ade15cec6661f34b0750220f443d"
SRC_URI[sha256sum] = "f24ebaed2be15d3ad1a762ed1b8e9089dac4a095d3effdbb2709ebb4175fef50"
