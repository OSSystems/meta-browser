# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "8f4638efdc7bad7881cbe5f812839aace03f001f7611ea57edd9585f11c8b85c"
