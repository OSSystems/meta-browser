# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "60250009181e4bba4610e626b50ad393"
SRC_URI[sha256sum] = "2fd77d3d06cd82ca32fd54fe541108ab62100230306d894bec6668b4cc5533db"
