# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "774a8cf20470a67e1e30a5dd614c60ef"
SRC_URI[sha256sum] = "a4350429a08416c5897c5f2e882838334bdfcf47e5473bef77577fe7ea4f8a44"
