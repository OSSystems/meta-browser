# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "36b6ad32010de3a2127bfecedeb68f48"
SRC_URI[sha256sum] = "aff7a94958bd8d950cc8b49d4d5903197101449bc3a4a4f272ee608c2e623733"
