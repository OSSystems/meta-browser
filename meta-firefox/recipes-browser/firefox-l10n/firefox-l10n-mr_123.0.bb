# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7d3216e1aec52d0ced9de3500dfa0d87"
SRC_URI[sha256sum] = "7abdc7154cace37e24009bd4f79dfd332dc64dec5641caa8d6e464736c165f05"
