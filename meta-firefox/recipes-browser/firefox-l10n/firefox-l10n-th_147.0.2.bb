# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4b4058a328234ca0308c821b0a38ab4d"
SRC_URI[sha256sum] = "9cc8fb220d74354938d912963a0d2ed56e4ad9010f601130749cdcb1235b4232"
