# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2c930acb5a428d1dba34ad348bcb63cd4f48ffb2c0556c91edf6f19f32e73d5d"
