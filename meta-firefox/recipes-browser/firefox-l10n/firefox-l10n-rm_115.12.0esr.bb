# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3d37e2e68896261b5404c655178c7207"
SRC_URI[sha256sum] = "aa14f9b4a1161acf6ec3a32d61929cdc1bdb66f6f97ef3c39964c39a34829c71"
