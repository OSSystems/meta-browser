# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e521baa629a18f6134efab320e5dd82a"
SRC_URI[sha256sum] = "307fb68a1672f187b97d1f5a2ad055858dde2f93825b0930705e3a477bb7c8ec"
