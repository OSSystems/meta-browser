# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "96e2b41ee1c9965c7918bdb96f5cac68"
SRC_URI[sha256sum] = "b33a082f7d74dfa423d6d84ec5b6c64f25b6901c83846055dc5afca340ef11b2"
