# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e1df094b55ab21c818c18d8f4cf601eb"
SRC_URI[sha256sum] = "0ae436bca7a7e00f10c210a27fd7a003460a591baeb3da340385ee31fc59e2d5"
