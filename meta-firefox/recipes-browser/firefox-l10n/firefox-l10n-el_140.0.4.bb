# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6974fbb960a2c3017734a575fc6a9223"
SRC_URI[sha256sum] = "5cfb71f522f4059263e75200ca1201c3784f43a6f1253717981f89285e8f7155"
