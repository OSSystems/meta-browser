# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c449d7e4df985cad3008e0561159cad3"
SRC_URI[sha256sum] = "d84095522bcea03b990bfd2bb061491130ae1ec04758a6a968db1bbb643fc174"
