# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8ed7353a4cb1b7ff71cd902786b0543f"
SRC_URI[sha256sum] = "c74c907357661e8c2a50cbbea36a351e8e731560e1b4e8e469b893d75f1f622a"
