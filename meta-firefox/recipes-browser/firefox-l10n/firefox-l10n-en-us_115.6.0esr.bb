# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "14f38bd73f87a48bddcf4b9280299c07"
SRC_URI[sha256sum] = "8831b735e06e34f89ea5c1fdd8b4f6249bc7bc98c057952cac19486d81a7f045"
