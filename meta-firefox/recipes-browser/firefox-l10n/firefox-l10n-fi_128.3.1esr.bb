# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "57e6515043965215ba20bd9926d0f626"
SRC_URI[sha256sum] = "05a2164c9c0ec0c87bba8e32625ee7d6a32c352bf8e156246fd03b4664a0db24"
