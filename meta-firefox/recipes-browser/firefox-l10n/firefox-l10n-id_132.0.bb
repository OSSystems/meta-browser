# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a5a6e18618e74c91afb68145a8479aa7"
SRC_URI[sha256sum] = "3c332696bc700a9fd6b90ff6b5062459b3d64edb06ac912aa598142dd3b5a7ef"
