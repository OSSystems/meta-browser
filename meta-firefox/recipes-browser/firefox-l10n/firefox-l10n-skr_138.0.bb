# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e0c1d7ba6541f7ebb37a253000f233c8"
SRC_URI[sha256sum] = "133923426b81d553ec6cc80ac144f0dfaecb2d49274fd6706e6191a19e3cb861"
