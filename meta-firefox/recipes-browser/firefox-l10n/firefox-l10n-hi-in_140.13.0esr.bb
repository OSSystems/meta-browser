# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e59bf9ba074dde4427b2523b7030aab5ee70daeca719d6e7ca26e8c6c99aae13"
