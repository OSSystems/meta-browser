# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f04770d1aa1559540d6f63fe8e8ca334"
SRC_URI[sha256sum] = "caf9c6812051b6edd00abd4a0b858376b900fca2ca4b6ba68a262eef1506d9e4"
