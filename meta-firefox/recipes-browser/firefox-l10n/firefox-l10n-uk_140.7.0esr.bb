# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b974da8aa224af8959945c880b8681bd"
SRC_URI[sha256sum] = "873782d313b71a1620e448606e584536c35bd010e1926d7d2d250e07c9329a6c"
