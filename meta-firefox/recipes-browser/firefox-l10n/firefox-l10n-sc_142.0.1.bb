# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ec5b70966f4df373e3fe1859d64904da"
SRC_URI[sha256sum] = "f16e0386c43e83061b3400f638b759554ab7a24b768480dc7c89f7d2755f00ad"
