# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eab40530d549f48219b4a1f6ae385222"
SRC_URI[sha256sum] = "d991c20823f40ff1a70b36be897d40dc5fb7b827efc618b23971aec06465328b"
