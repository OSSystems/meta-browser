# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ed8b0704d276b518f14f579d75805beb"
SRC_URI[sha256sum] = "c9369808e86528cf51b9490fe5bd12c6408c6fcaeb6ae027500878abde2b1296"
