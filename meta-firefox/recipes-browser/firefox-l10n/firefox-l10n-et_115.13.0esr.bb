# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cdd9751fd10f8d640836925b88144aff"
SRC_URI[sha256sum] = "17c093ecfcca7b4e2a92a58ea381e7756c5f363bab66dc720075d5662174f96e"
