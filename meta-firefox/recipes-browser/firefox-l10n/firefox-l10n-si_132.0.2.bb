# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0df6b8cc20fc5001c90c31e8658d3571"
SRC_URI[sha256sum] = "c22122d7035340b4ee7dd1f7770a88b5c6c8d40dba5f6f911c4b62c9d150cf3f"
