# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "64b3e65f3d75ff202d834d92d6b4b474"
SRC_URI[sha256sum] = "80e61d0f95fbeb72a4304839f044ec434417c8a7b899fabd7e6f3ea5c3fcc68f"
