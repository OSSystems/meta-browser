# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7d305b5351fcc5d14d03b6f0abead98e"
SRC_URI[sha256sum] = "b0cc1176ef38c02856089d98cab8cb8e7aa03c8ee3eb49efcbd437ca31551b96"
