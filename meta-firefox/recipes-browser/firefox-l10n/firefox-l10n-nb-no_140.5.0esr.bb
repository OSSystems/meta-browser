# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "62c38931a618fe182f27a68aed49c0f7"
SRC_URI[sha256sum] = "d6a39e63ba2f18555734892feda5921b50ccae61b23ed3c92e171a37d276ccb3"
