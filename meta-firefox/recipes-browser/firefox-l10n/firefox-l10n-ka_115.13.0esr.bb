# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aea6bba380d23207b471796290f9d251"
SRC_URI[sha256sum] = "2cb878b5f57582a4ce00451b33c20b162ad9ecc129e9a58b6282e6f8c61ef6c2"
