# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "94149f314e8e156115b838da3118763b"
SRC_URI[sha256sum] = "83a3958a55ee7d577381194745849e5ba2d1c0595b2755374102eb6e604f9a48"
