# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "68b54c1a6886285fc88db2edb7b44770"
SRC_URI[sha256sum] = "d6d90252d4d33842339199003a39d79ccb7cfb9d840afcf86a10805996b47c03"
