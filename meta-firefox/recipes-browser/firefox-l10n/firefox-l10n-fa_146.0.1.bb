# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "869de03afa814d40bc0da3195aac960e"
SRC_URI[sha256sum] = "2652d594c94fdbc4b72127a87c5dc37b4fd4b058b08c66de6f64ec0204b39869"
