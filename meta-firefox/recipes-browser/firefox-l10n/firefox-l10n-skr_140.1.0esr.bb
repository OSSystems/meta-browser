# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c77a2a98686e4e171b8289001d8eec98"
SRC_URI[sha256sum] = "bc9c2fe395d01a8833244e5eb62b265c8458d70b15fc67de0713a85b96e69c9f"
