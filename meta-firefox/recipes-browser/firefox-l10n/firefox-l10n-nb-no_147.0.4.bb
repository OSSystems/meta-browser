# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5ea7b9ba1d52a88e69cf5dce357eccd5"
SRC_URI[sha256sum] = "533f8bb0dfc35ba171c463dc24dd5ae5ee86e527026433a889f7e616a735b4cc"
