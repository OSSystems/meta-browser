# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7076b0b60ba0fe37dd7297073fd3cbd2"
SRC_URI[sha256sum] = "6b0ffb74dc6e8ba2751e041b0635022eda66616d74bf70e62c13bb5e1df0a890"
