# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "05fc632e802ce6d99dd416c035c4c95d"
SRC_URI[sha256sum] = "61ea02445e1c2898c2460b7455febcba64bdde9794b9dbce1188fb8c67be6483"
