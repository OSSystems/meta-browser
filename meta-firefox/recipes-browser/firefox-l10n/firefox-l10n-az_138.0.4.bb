# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5a250d4c95089a46dd0f14059e23b6eb"
SRC_URI[sha256sum] = "2802425c1724605025681cd79146681845959786bda12fdfe4a5f3a3d4172da5"
