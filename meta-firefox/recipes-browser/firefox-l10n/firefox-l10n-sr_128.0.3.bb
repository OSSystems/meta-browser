# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3a8df4ac36f4d7518625a1d3527c051e"
SRC_URI[sha256sum] = "f99503872164e1bcfff0a8785a0a4de5b50037cb8d4e6d83bbcc2b894c2c7efc"
