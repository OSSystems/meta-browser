# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5203d88880cf3ec705dc510784b9bcf5"
SRC_URI[sha256sum] = "9b919ab3c7d484585e6278a6674c96e8a883bd67de7627757e0959be49fc8f3b"
