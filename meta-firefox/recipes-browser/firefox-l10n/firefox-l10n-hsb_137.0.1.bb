# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f9577fed2dc5b21c0621b024cc58fbf2"
SRC_URI[sha256sum] = "60f7fd22d56ea61c194fa8bc6c4722e0099a36cac350278110a101b9b70787a0"
