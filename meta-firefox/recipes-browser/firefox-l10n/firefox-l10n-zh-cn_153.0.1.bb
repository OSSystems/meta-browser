# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "240e6d403fabd7adad19aefb4503e4851329f11491c823bef4946b3c5619f6ac"
