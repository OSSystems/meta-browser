# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "721caad75c97444e61880099650f0b0b"
SRC_URI[sha256sum] = "a3bdd24fd4c88b2f7f3ac57ac8e3ed56be190361771b338324d468f5b60535e2"
