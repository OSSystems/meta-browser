# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "705e4e6c3a049c8ae71a077df4b0542bd9d7f289e4274e8a080ae2c19a60fa66"
