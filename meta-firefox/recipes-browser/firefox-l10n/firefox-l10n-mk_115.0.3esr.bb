# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1203f4d1ee46707c3405ad2f8c746a5b"
SRC_URI[sha256sum] = "362cb3826cb4740336d3a1f90123c8cf9c8b4e71b153382a8a5017ad670d64e4"
