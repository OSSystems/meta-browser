# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e2192b95cdf04a9316c629594a3eac3f"
SRC_URI[sha256sum] = "43f312af73644163fbda0abf6bf8f56bd105f4ca4eb4b968d68f9f559c6139a5"
