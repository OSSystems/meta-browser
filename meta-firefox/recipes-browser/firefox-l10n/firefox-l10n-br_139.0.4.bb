# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ce5d830509f1c464d8b0181d640f32d0"
SRC_URI[sha256sum] = "7c471befda9a700957eff50d1eff648be0837c14472d322247f98488ca542503"
