# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "10d703f6e5588a9fb7f0925569523a7a"
SRC_URI[sha256sum] = "fcdde687f7017ed9e3d3c834cd2e6d19e573cf27544761895165084fbd1b7a9d"
