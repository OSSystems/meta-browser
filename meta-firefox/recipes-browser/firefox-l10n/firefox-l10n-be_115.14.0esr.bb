# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dc2af32c8bfdc359f3ff0732648812f8"
SRC_URI[sha256sum] = "1159c8a93031b7e55234b8857c6328eeb35fa176233bd6038a098e0bdacd0653"
