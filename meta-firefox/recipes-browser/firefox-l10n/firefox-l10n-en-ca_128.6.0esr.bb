# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c97aff43f4e2747205bf5d80e403b17b"
SRC_URI[sha256sum] = "b160c9b2a89e45bfecbb8a871c7df816180fc4f87118364181975eedfed6b467"
