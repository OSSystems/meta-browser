# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8392b9a52ff795edbd124147d274dd13"
SRC_URI[sha256sum] = "73fb6b335cd7c9bb1e6b6741429855cc249e7e14661bc0ccaff0c06eef975509"
