# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "cd6543cf810640ef1283483c94d4d50538c21b379991e8af0f40734ebac14856"
