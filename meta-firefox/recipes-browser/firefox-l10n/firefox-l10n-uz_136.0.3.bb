# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "644c05289e942e9658fdce5c88cae90c"
SRC_URI[sha256sum] = "95072702f5bb940c16de47ed4a2149e039afe823fcff27a5ca8de9c03b105ea8"
