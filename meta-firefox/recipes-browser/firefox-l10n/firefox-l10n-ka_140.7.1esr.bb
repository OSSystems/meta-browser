# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1f27c7ce2272709f26d3bad125fd9770"
SRC_URI[sha256sum] = "0ac12a441761beb1349d398d91a2e064dc97bca1f813aeb33835209a85ad78ce"
