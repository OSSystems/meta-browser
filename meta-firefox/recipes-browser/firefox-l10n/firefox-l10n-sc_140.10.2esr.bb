# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "bcfaf106331412681eadaf541b0bce000d3a71636e37c5b91c297e382427ad65"
