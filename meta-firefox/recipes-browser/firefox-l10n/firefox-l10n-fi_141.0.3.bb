# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "df8ad681e02e0a28c36fd4027b0d8e9a"
SRC_URI[sha256sum] = "8fe1e862b15aa29296c5b472ba67035e297d928c263e6508c3b6fa4612c2d0a9"
