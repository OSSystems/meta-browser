# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a96b37aedaf6374d80044c48aca9a901"
SRC_URI[sha256sum] = "d77d545768bbbe8e2bbba250a1447ece7f82d8f1fc53f473260002882a1f40af"
