# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "af1c127b199cf264972328d32f910274"
SRC_URI[sha256sum] = "1716cc2fa4b56a22ce39bd491fb7a755ed7b30db5f7e082f0e2d3cc82636093f"
