# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aa1c4028fcd02bdda90e940acd22d247"
SRC_URI[sha256sum] = "3774f23fd83dd8eca708ae87d733607b6ab88476a786438a66faf2cd4fc2fc5c"
