# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ad662122b5d3b3eb89528d90c180d71c"
SRC_URI[sha256sum] = "879133c4258d1f741128ae707c33c74dc0b0c62520bf74e31b30e6d24b5c187f"
