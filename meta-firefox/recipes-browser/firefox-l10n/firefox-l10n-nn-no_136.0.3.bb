# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ab3a15b6716c124c312bd2a7907b7159"
SRC_URI[sha256sum] = "e1833a7d9c52ae494c4cb97f9f812ed775535d23bb2bec0253bb57a8ec454f3f"
