# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8c2b831501154e6ab5d1b3cd775ca03b"
SRC_URI[sha256sum] = "aa34afefc25f72e19abae3b49e0f46473a6a0a0fd35f14a2f77fd972c9d6d2dd"
