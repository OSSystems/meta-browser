# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8906356a2c065d89c0435f9b391eefd3"
SRC_URI[sha256sum] = "1f129e9330c0faa91d329c859fdfce2da7b9a8267a39ef392d8dbddcae6619b6"
