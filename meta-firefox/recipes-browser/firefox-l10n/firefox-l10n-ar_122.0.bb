# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "abe32b614bad4a7a285ae63a71ba7898"
SRC_URI[sha256sum] = "24210b1d7f52d86257f809b6b901353750434ccd6dcb781606e934d6e464257c"
