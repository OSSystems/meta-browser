# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2e24e75532570015d7933b8d27423bb8"
SRC_URI[sha256sum] = "be0ca63ae53639487d601b0302424f5d2373531f885beca1446046500ccd54d3"
