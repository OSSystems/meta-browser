# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7373bd34d7d89213310be6257cdae723"
SRC_URI[sha256sum] = "5aa12d535984e8dc35c97a625b8eb309cefc0b889c109e923e142c808ff32af9"
