# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2d03a5fce34a0295ab113eb278b209b4"
SRC_URI[sha256sum] = "5c9a8574aa9fdc15b5e356d8a3b29f58718e7a5a32499d07c9e99cbff8aaa932"
