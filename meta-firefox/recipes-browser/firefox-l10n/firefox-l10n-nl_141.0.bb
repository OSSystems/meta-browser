# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3b819b1d5576fd352fa862a4b4dae3a0"
SRC_URI[sha256sum] = "3afae01dc0304a78980fe388e429a7b416220d3215fc190974dc72d2c5691af0"
