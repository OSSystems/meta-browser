# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2e0ec14f94d4649f8cbe4d02d137854bead682474470ee200f977c7c41349860"
