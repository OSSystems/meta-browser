# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f323ddacfc97999aa5275c43b7b41d94"
SRC_URI[sha256sum] = "19150793bd649d1484159d84c9ae457f5b01de423c9911916d7d23da2b0f112d"
