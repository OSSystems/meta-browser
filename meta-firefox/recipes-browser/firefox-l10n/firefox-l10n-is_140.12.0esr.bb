# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e66e11a8025f509891db4a3d4dd40dbfbc880a9cac9ac3ec7f9dea39b5c82d6e"
