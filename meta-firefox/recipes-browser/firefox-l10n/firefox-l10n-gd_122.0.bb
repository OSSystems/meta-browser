# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "14e363ae0dbd0fd394f003e029df27d2"
SRC_URI[sha256sum] = "a09928565b5206269c921366b62252aab661c147367bfa24a7bdf8e57c25c4f6"
