# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5de90e32f1cadec62ca2e1179c8a7261"
SRC_URI[sha256sum] = "166d42c95335e56fdb67745ab0a674ee2511a937e72a5f8f3a7febd3ccabf37b"
