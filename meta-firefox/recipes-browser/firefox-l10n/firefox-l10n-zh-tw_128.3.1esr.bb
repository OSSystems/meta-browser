# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "02445953ceb027f0a4f31aa6ce4bc487"
SRC_URI[sha256sum] = "ed8529f673a2f88b308f3d7e053fc3b5efa396782458b02bb4e458beda42f8f5"
