# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "36f637659ed72e3072624a646862272a"
SRC_URI[sha256sum] = "3b0d61064c732172e52c863578315e49e14945aae757d747294f6a3ee24c39a5"
