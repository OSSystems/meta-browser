# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1d12cfa1c0af3ca04a60815a4df0cc33"
SRC_URI[sha256sum] = "7217fbfdf8912258c77e6d7007abc05fec9d4b6699bfee0b965dfe5901609b57"
