# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2ca23b99ec8e451fbb0504051b45b7cd120fc7e978577a39e4d3a425b2acde2a"
