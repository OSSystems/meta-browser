# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7ea8434ec68568ed1d37330650a29fce"
SRC_URI[sha256sum] = "c4b214e4962ab7d1cc1ae6d57634652d0789728b292ecfa64bd2ff2d1d056db7"
