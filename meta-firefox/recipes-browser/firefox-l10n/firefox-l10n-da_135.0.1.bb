# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4963e6caff9b1b32fa1f9a0397ba5bcd"
SRC_URI[sha256sum] = "2e433cb5a36be02b55d777f52660ca167b5d35e1cabc1a7f86e2c77ee4dd7ff4"
