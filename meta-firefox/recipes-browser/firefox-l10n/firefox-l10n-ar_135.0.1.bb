# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "796a8b48a3d739f941ab8bf190119748"
SRC_URI[sha256sum] = "48d3c56a3ead667a7b4e31789c5944244201e790ca69af384dfc1af291e60b9b"
