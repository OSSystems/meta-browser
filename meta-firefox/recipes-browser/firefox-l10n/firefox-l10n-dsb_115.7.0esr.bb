# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "802df23d491eb41c5e8638f25f73b1ab"
SRC_URI[sha256sum] = "6f37fe4ddb8637c8f849461bf56b85337314a45611e243d4d67a5f6ef9bca24f"
