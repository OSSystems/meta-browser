# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "32e6e409773b771d7d73733409f0a256"
SRC_URI[sha256sum] = "6043afb7981db9f02aac15c0e39df19e75f69b3727863626a96377fadd93c8c2"
