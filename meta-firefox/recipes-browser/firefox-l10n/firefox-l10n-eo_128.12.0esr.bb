# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1bdb23cb83c456cd9671f08c1e3f7a1e"
SRC_URI[sha256sum] = "e27b1d3d522420f0aee2ecd16135036cfe8c82d933cdc6ac80a726c28ccfb2a6"
