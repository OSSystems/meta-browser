# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d20e80a671c1550ea38e80d96585c3bb"
SRC_URI[sha256sum] = "84b56a17ee8d354dd34212d1c68335368ad6168008c6eccf1268ecb935ee0c6a"
