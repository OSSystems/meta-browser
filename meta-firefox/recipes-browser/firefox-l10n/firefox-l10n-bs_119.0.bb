# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1808b283bef216352ee4118ca390d9f0"
SRC_URI[sha256sum] = "2d632f7eb9e7b4aa69538145e129346137b0c5a6647fc264b48aa8f4617502a1"
