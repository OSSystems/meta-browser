# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "094ddb1e95f866afaa0373abb206d143"
SRC_URI[sha256sum] = "0dbac20b4ccc793d1c0ae84f330eff5496f62c26dc68fe3e05aac53067a15199"
