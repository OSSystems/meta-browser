# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5be4538092cb3bfaf00bc583466c3b65"
SRC_URI[sha256sum] = "a345dcceb1c064f560f9edab61b87fa048da8a8d5779e90aa8bf226634dafac6"
