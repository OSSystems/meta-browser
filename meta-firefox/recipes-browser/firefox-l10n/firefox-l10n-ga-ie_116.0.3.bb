# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "14c562f6ee2fcd1e57a78f52d73604aa"
SRC_URI[sha256sum] = "9621a47e9a5cf6ff17f9107436f73b696fa9e39afeb63a3ffba23e097992f237"
