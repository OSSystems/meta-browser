# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "49c155fc4eaf08054bf0d7b4f8570fc8"
SRC_URI[sha256sum] = "00d68d4be05c66b589680336332f6fee1eeb8435abbd2065bec6e56fc30fa299"
