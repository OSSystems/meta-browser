# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "39b28b04b6f8ae1801278d51e0da3b78"
SRC_URI[sha256sum] = "18341764e314770a793db225d28549ea0ddc665e90a0df979975af7011bae9a5"
