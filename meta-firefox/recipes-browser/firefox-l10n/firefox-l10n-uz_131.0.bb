# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3a4c8bfaac12ec05cc2e8ad638c41401"
SRC_URI[sha256sum] = "25e48226aa815c2e0496d305eaf218a2608819459e5e5473fba12072e8b42dc6"
