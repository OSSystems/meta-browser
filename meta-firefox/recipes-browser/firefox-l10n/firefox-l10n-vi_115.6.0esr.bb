# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "43661cc698e8cd78fb796dbde3ebbfbe"
SRC_URI[sha256sum] = "f4f331cddc36913906bcc25610d96c8a340d40188630407c4f98a7189fc21402"
