# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c21c31d786ce90468c11ffd359b20dcf"
SRC_URI[sha256sum] = "c5b9f9d7dd75b80bbb41f8ffb648ee2ef38349c9046e7f051c6ae3bb688369e0"
