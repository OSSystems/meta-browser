# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "362475c772277b3d864b3fb022226289"
SRC_URI[sha256sum] = "2d7b568648b53eb33d3ff707a7fda107e8e896136946df9244c25b4c2e521a3c"
