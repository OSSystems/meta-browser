# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "56c331ef0102b7d49744062d68ee5fe49de76d5fad123f0e8f11f0934927a2bb"
