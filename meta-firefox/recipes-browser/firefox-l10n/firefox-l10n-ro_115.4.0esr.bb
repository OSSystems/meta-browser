# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "676dff5f49a7c4f8f4f289695c63b1b4"
SRC_URI[sha256sum] = "cc65fe35e36e2d2678b5bafe4d74f459866797c2430ef08ce9a72476cb55c9d2"
