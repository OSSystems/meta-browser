# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2337e2988be5104e7c6a881758903902"
SRC_URI[sha256sum] = "21df34a678d7332518aaf600e5b888bf75d139b26d8c6488311f0c2fd7559596"
