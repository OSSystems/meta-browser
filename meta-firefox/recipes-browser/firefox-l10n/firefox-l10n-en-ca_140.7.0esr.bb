# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a39f35039249b9b93f43cfb041660818"
SRC_URI[sha256sum] = "d56cb9aef410cb20a1f890188f8693a67c9fff8e7bf03601587f4466613877e3"
