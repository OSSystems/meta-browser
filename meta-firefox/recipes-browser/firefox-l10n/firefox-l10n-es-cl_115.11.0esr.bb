# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f71d9b621ae2f1d5a34caa133bc3401e"
SRC_URI[sha256sum] = "d335a4ef7b6e717f61f5812698e3493b29bcb11947bf92e3b736dd634e24a0d7"
