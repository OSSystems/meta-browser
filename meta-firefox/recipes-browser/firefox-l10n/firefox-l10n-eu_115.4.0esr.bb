# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "70b77e8e9ec4ee65130edf1966b023f0"
SRC_URI[sha256sum] = "ea41c5e80c51c1ae0557ddcf50c1046ca9e1f5346d5d57ceabc5e98553aa13d2"
