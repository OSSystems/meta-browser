# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "af82caaaa8bdee2d1fab6efce642cdbd"
SRC_URI[sha256sum] = "4765a8bb991be532d2194cf9dcde4dcb0b2918874f36ddaaa4bffe260c500cc9"
