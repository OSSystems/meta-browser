# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fd552a18301ea010ca7bfd320148821d"
SRC_URI[sha256sum] = "0538414732c0871b27e72ea7c71274979116fd81f94c93b94886512cd2be9ae2"
