# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "69eff5b4f5a404dc4190c7ec5cebab28"
SRC_URI[sha256sum] = "9321a85b746c94c9e2b7c8741dca162b6bfeefc1541d5384f14b951e77598c42"
