# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "859859929d905470371d4dd6dd3ed1bdef7db420b2ac6e99fc63bd48df059514"
