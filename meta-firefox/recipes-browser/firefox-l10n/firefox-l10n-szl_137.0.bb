# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d69ebfc1aa62a9fefcc9e0b29f613a23"
SRC_URI[sha256sum] = "6189f4c326e7f758cb15dc27b98543e7f399c59861874a564ccc1baccb36d347"
