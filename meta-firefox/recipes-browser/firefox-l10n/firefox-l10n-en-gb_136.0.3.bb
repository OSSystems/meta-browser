# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5bce14c6bc74a77856f095a06b3b3a11"
SRC_URI[sha256sum] = "c017dc1f75252b900fdf77a59b4eb34dc9a4b0d4099cba8e7ff39cc9ef548650"
