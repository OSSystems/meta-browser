# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6f05770305ee7e012e3b8ea6b5705be8"
SRC_URI[sha256sum] = "58e5e2e455667e1bb549f1ed3c76c920a8ec3bdec86c2df51a5dcba1a7a372f5"
