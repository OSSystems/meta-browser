# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6bb77c0827e3ed7081e749321cda3c45"
SRC_URI[sha256sum] = "1106b1b9cfda89bc6ba435f44ed3b10788e81cbe1b83c638a31d0aa8b009d41b"
