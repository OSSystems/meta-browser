# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6ecdd411af16e4d4d4323303e343cc10"
SRC_URI[sha256sum] = "96d66fc6f0ae9a5544c3774f884f04d3a682aa73c7098228aef204e4f5bfc58c"
