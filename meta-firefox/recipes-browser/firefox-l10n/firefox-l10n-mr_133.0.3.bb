# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "970908bbe0ab780c8ac8f4a8d8fc3a33"
SRC_URI[sha256sum] = "ccc162a567ec9225ff415b8f86f969749f5f1ca83b52567866072f87c0de890b"
