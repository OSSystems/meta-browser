# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1ec5ffe191634885c621c46e73ce2b74"
SRC_URI[sha256sum] = "6a23186f911b7c83230e300faff9bb7b1e9f44b4ffc5144259047dcf113878cc"
