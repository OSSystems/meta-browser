# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c4b8340dd0c16c5a5cb061d81a3b734b"
SRC_URI[sha256sum] = "8c0ac9f6ae12d2f833ac93eb7481fca434a97a4522aff0cc216e58992dcbf797"
