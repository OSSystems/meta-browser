# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6e6f037d112bcbbda343e0a7871e43cf"
SRC_URI[sha256sum] = "1f6d987591b4e8b9c3edb3066177d0fbfff87ccfdd46c10fd8881720615098a0"
