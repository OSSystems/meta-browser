# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8d97b3fa25334c6d4a42030ee9eea330"
SRC_URI[sha256sum] = "33661a5f6d3e107b76fcbe36290987969bfc25eb20f9420f30d0458037ac9115"
