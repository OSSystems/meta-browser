# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3c69be3e9e2d255da917970f36fc8e2fec2ea425bc7af4553142238a2785f684"
