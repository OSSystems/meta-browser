# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "263904ad558f47eca463e0473686c59e2e99dbf3c814ead91b753e014b2a82c4"
