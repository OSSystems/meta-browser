# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0baed78e08a104e5d1ef67c3610441c6"
SRC_URI[sha256sum] = "686ab6d859c771ebfd109948a93c32ac2436e694b383d51faa48b41a4e2cf45e"
