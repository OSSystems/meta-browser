# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fee7fe4e57748d911b8337c043e905a9"
SRC_URI[sha256sum] = "48f7767f524cd9e00202c9b54360e9ef6fe98b8c08086397373fdfa0a30e1914"
