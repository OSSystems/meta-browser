# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "43e10cb0116e69c456221bab59fc96e3"
SRC_URI[sha256sum] = "7300db845f0b15b408f34b4791a5808a122e4bc7f8e9fc90dce16d87e2bd5546"
