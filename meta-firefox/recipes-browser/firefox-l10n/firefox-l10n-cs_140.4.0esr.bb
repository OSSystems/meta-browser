# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "567be765052c300a6acbdbb2db8eb4e7"
SRC_URI[sha256sum] = "95e7aed853529f48620359942e8385a128f052d48efa53f9827d15425712a106"
