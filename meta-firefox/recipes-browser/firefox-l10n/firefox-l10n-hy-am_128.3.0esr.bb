# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b03d686d9a99b755e58b893627dc8636"
SRC_URI[sha256sum] = "fff69c11ecbfc3c13b7062432685486bd4f4e7294718b48f1a2046bed7d65b57"
