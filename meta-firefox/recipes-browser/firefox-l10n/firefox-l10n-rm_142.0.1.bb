# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f4f39fd286fdbd27b860e3276ff41fac"
SRC_URI[sha256sum] = "5af5428b784818f1ba996c33d1f589e0f2a08805896e8199ae4397b616dbf270"
