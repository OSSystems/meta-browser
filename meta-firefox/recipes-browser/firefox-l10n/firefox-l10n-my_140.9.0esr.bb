# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b2aae8c1600d42bcc80fb7be22a00b9e"
SRC_URI[sha256sum] = "31f9ca31ef2b471d3379a92e765d70813e465f5364e7279ae5e9b85e9b67ab66"
