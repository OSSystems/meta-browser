# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ebd2fff7df141e2891dda0813e16f483"
SRC_URI[sha256sum] = "c121ad9c42a19eeadccc8b0e5ca7cbf0660f96344d385537778a8394a2f8bb33"
