# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9121de098627d6e2a75eb54f0c1d9d14"
SRC_URI[sha256sum] = "43003fee4d747dd68ea6394a3465028795c361786ab5d54b359bd215dbb9df22"
