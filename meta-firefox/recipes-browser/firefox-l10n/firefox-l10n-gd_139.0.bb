# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f33038371e852869d3acc2889652de74"
SRC_URI[sha256sum] = "30a102ab9aca78bd609d3f1ae9d0f9ee3e38a4f28b3e053987ed0d313f897595"
