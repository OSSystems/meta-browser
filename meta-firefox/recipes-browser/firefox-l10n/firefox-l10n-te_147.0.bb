# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "27c7afc46d1d55452c03b23d580a7f3b"
SRC_URI[sha256sum] = "3e991f14f8e0994a7ad9dc72875a72ef57b706f4599b82d062bd124944b0cbd9"
