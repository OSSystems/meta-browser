# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "263c5bb44cb02b8a8e724f636297a337"
SRC_URI[sha256sum] = "62590ffeebfa09e33fa9678d88fdd4c31cc2e05b74bc953bf1a1b65957fe3486"
