# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f5b07a979c3c070281eed098fb36069d"
SRC_URI[sha256sum] = "4a0fb38970af118b1047f29306427da6d69432c62d61aed6303a3de51dbc088d"
