# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3c171b413160ee74d869941bcd45e59c"
SRC_URI[sha256sum] = "e2afd8029c26edf133ac83b679e68973d88bc608b8f3b384ad03f3757307cfd2"
