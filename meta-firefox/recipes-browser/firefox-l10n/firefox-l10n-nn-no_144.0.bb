# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b15521009f1b1d44ba469fcd3569a8c3"
SRC_URI[sha256sum] = "30a75acb3ca5f9f7f6cfe149a112462c216f564622a910c169953139e56012d9"
