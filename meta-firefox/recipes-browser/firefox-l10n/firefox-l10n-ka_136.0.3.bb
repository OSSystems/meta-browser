# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c0fa34add30bcb5d7f0ef59ceef94397"
SRC_URI[sha256sum] = "bf1f69dceb373164ace81ee27c9b76e583666ce53a3872ca381a9836af123799"
