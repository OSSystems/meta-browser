# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "afe4df27d487eac573d924fa41f74bf5"
SRC_URI[sha256sum] = "7e392a179ce60ed60895db858ad3997bcdb0c3b3a7fa1177973d9b9fe00511c5"
