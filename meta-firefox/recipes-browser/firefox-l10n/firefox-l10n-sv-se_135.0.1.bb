# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1f2d412991414753219be6e070806795"
SRC_URI[sha256sum] = "6a682e0444b48727fe0bef4144e3106167108422391efc26a0205dad5dd04aee"
