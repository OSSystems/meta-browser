# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "93b674468c876c2dc7bf9424cc91e22f"
SRC_URI[sha256sum] = "7039cbd6a26e84fc6c01359420d3506991705dad6c2e3d627b6dbc20fdeae6aa"
