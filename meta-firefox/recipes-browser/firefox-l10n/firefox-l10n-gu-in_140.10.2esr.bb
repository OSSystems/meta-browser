# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "f72d55acdebca5762527d090eda0b4be05925a9fda61d8843bc16c573f3aeb3a"
