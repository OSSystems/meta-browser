# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0402e00244cfe2c9b696a6f6ee154552"
SRC_URI[sha256sum] = "0a19e8ce8944db5757086e445cb225363ea2f0786a942e7dd0d7d2b0932eca5d"
