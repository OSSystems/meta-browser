# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "00db5bd92ef6f3997df79aa5b4724518"
SRC_URI[sha256sum] = "c5d06638c1378d3c087274a26b2f0d411d2d7b3f98f3ecf718632a04aab16c69"
