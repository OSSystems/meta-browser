# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e72fdfb7e4dec673d1481b5a6c2c29992d3d80d449d8ccbc83a63cf3e6987044"
