# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "15ae9219b8549d9a7968b4d1bb291ed408809ce203c0e5c9acc316f5e11ea760"
