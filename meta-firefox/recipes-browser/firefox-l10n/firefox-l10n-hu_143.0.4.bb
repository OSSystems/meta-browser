# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "52d6687b3c644483de5e36e0853464f4"
SRC_URI[sha256sum] = "e3e77e416a97c7b98b54a444bf86079d34a32a68e3b59880de620166b172fb3c"
