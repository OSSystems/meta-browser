# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "72224611dd3fdd0beadec615e5bb0521"
SRC_URI[sha256sum] = "be7c2fa911c94f15e6487d26bce31879058c53a73224025d3678bce96e678a94"
