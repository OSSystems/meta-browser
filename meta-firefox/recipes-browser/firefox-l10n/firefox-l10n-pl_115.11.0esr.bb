# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5b1cf1ddeb8f46ee384ee348c22507fa"
SRC_URI[sha256sum] = "67f086b99ade9634f8bdfd96287244f404ee5d51a5b4c5efe1bb68d62f2c2997"
