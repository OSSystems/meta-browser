# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "84d951c4c9addaafe7c25f0c0c7e70fd3088cfc4d2a19c6ec3b68cd759a4dfbe"
