# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eb35b6fc7ceb164ee54a38868508f33a"
SRC_URI[sha256sum] = "8bd8b792009241dea4557e8659e6a9ab07000c70b0cec6c70046ff9114732f17"
