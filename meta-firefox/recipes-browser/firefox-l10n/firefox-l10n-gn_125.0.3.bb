# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "30525919533f2df55d087f28536bbc17"
SRC_URI[sha256sum] = "04ab5249ffe78a6f6e51f72e589abcede264b052a63c36b62a97542f5b295c21"
