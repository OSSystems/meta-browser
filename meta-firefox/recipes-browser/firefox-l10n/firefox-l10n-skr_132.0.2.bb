# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "639ea36bcf3228eb748ed9e0ae1fcf89"
SRC_URI[sha256sum] = "64f67229a02e94b1190dff809a101aab10d9d67e535939f86b043da10dca3022"
