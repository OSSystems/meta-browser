# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6383dc4ab276cd68884033548a62f91a"
SRC_URI[sha256sum] = "3e1ca1571a6d89dbdf143ddb24040ab7fe6aa1159096dfe932b294bc81ea25c8"
