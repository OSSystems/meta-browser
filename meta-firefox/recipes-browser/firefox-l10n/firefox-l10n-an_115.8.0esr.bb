# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "02483a9d435d13fb3b8d2ec61cef291e"
SRC_URI[sha256sum] = "5ebe3d4f6c6c38a9433cda691f23ac1662912fd14261a558b0c0e4c9fe383a92"
