# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a57e66d3110ca6baffd57e2743cfe3fa"
SRC_URI[sha256sum] = "f4bffb20ad1f30e36a2e283f76297a8dbd194f96b90818e49079a509d74a493b"
