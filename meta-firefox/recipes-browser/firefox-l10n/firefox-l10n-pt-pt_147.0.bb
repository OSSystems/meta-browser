# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fe8a722535bc2d2d01fee10b8f5ee217"
SRC_URI[sha256sum] = "a7f0983ac07c64764e3d8a9ef705feae698658511cbfe9e7c57724e0a181d3e1"
