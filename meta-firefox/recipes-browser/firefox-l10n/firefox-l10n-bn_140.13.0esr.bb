# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c92eb250365f5edcf9cbd22dc5e1b72eabb88b70d4df674d693c98b24ddbe918"
