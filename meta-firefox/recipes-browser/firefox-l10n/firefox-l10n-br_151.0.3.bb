# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2eb695e5f5c2086351d9b0f1d542f946ed9157754bd2265ad530ded9da4ef1a2"
