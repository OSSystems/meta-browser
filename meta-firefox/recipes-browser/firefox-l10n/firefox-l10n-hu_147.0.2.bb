# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a6dcdc4042cdb92eb38a527721a986ff"
SRC_URI[sha256sum] = "63611b716ff48786a64a76a6e342ceb32dbf8f147509d68e7b106f9fc5638839"
