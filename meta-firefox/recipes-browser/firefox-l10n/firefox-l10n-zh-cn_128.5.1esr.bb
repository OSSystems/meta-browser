# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9a01d0da8ac8481d9a65747fce580c1b"
SRC_URI[sha256sum] = "bae641d73b670e9dc3f120eb40948bde650e204e64e44c488d2c287e5e51534d"
