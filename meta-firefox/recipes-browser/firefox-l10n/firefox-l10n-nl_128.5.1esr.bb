# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "83f77c1e67849f5397b3a4d5c498a7e7"
SRC_URI[sha256sum] = "4c9777ec46430b3abe990cbf02f0e4365d89235e330af52818ee6a0071a2c989"
