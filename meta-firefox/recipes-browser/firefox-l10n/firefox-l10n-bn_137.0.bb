# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3bc5029bd05ec5c68e6127b43ffedfd1"
SRC_URI[sha256sum] = "30f1ad7683588c69abdde442c7bd638439afff79a05a099d6446604e928d02ca"
