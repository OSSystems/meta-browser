# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c18a0126b1e0b2fabbaa3800523f81e7"
SRC_URI[sha256sum] = "52ecccd2cadd4a6485377a0eac355faa820c06cf25377591788ce39eedd592c3"
