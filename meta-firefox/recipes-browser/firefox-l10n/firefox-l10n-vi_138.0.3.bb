# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e0e7bd941fed7d0b33780ca05cf27775"
SRC_URI[sha256sum] = "ebc891fba448a1265075bbb3b4fe4f21c847e19f7ec0c1356f0b3c2ddcf3fe35"
