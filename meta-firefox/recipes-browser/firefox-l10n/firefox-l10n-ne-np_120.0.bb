# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b71eadec02eca038d5618ecbd3763b57"
SRC_URI[sha256sum] = "3e80ce2bf8f9a1d87a84b2eb4af1f00a6525986063c7edaa976bd8b1343bee9d"
