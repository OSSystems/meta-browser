# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "b0056daf0aa005b62e93d8d6a55555028b52db055c8907adb5885be6fc0f651c"
