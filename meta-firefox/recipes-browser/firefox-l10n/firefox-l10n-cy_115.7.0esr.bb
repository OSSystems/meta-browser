# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "73b203dc163fc4bf0921bce107d9dca4"
SRC_URI[sha256sum] = "ce518d0a42008f3af0c75f016d6c638fc6184fc90d58fcfcf306d3570baf800f"
