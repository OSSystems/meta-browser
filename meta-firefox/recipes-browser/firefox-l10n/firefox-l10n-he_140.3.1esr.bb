# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a612752e7be3bb2ba7617009383e05f2"
SRC_URI[sha256sum] = "a9a6e317bcedd970313935fc34bfcecdc4e3a76e8722fa279c1d64708677bab2"
