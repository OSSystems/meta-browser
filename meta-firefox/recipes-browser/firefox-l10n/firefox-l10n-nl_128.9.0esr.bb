# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "306c86fbf57c06dd9637278a67b70a56"
SRC_URI[sha256sum] = "eeb5ae443abb61308955422e839798ee9f730b9ad1a65bca4af2280155067f50"
