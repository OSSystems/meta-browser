# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c93667f6e557a9ac573e45bdfc3bba36"
SRC_URI[sha256sum] = "0ecc92eaa77430a1656d1f608b2ecb2fd79a81f5c1a078c9a287391ed24f5dcf"
