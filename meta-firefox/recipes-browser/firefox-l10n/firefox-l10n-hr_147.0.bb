# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4e83ac9016d22b590538ac3e0924f091"
SRC_URI[sha256sum] = "5b0d391f63759c17f158660e693f662cf3a38b76da7c5d06008e8523964e1dc6"
