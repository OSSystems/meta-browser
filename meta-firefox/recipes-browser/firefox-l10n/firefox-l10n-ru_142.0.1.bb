# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bb895c90a09d87f6bc56d81a66f48fd6"
SRC_URI[sha256sum] = "a441886d46f0af79e631482911fcacc661a4724afdf171ce22d27389b7a403fa"
