# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c91aa8374bc9b8318ef90ac50bd91b47"
SRC_URI[sha256sum] = "398be825a541d275516a0268ee847aa7320d3f5ff3d72bbf49bc8bb919646dbf"
