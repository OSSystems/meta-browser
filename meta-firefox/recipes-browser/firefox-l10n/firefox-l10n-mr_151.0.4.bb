# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d10ae26211e64ab3c4fe272dfcb3811bf1106103a0136412e69230286bf20798"
