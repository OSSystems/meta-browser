# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d44256fc7ca6ca2c34fb272316262bac"
SRC_URI[sha256sum] = "9b634222075b8e5c824717e096f6f9d5329ec06fc4ece313f2e3bb07059ca06a"
