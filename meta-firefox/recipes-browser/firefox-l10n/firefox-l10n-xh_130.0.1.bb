# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5793b6c6b7061d890cbfeb8c7bf0a55f"
SRC_URI[sha256sum] = "2ea9bbc2a509a7e969d452d3685730c0e09cc950febf6a8ba14391a9cfabcb25"
