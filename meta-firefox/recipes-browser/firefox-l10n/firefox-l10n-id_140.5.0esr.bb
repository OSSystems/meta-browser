# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3ba6e88fbc96fb3e703ebd5a7dae3994"
SRC_URI[sha256sum] = "1d605f1b57fb3f0b13d802af87d7a9f6d2c101d076a09a4d3e0daef99aac2b06"
