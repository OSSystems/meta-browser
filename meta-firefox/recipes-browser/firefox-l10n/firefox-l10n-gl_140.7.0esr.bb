# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8122654b4e61dfb89d21b95a94b0f68a"
SRC_URI[sha256sum] = "68d919171127b030c7449477e25e4c7d3bca2aeb9a9a0cc2137a66342d82c5c3"
