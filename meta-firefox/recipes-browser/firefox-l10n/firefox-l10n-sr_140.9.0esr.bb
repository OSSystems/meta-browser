# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e226cec77ababe265513975c6e389c7f"
SRC_URI[sha256sum] = "84aa04e98381db004fe73206507e79f39f5824d66830c19005e1be2e7ab15372"
