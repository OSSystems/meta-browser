# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4136ffcc09e3cafbf67c655c0f81e494"
SRC_URI[sha256sum] = "e9a36f3ab2556bdb97a0310f73000aa1a68dee7f70358eb4c780606b86af6b52"
