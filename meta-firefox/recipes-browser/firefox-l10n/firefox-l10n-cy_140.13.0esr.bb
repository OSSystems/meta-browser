# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "10e37019fa1449aa672b501aa8e3a149d866eac9ac7a3d05d049a47768d1a5b6"
