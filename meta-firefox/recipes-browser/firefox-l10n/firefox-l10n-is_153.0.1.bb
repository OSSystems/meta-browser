# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "db9d7250986dd883806d0faa8fb2a013dc81f0cf3bd84a9811acae9bc27f1b82"
