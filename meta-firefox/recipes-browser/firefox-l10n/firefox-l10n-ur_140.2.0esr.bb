# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ed206cf98ec9244ce8b14fb745760f5a"
SRC_URI[sha256sum] = "6934a14bf44353f526560fc7ce4e74dda25fd2a741e5431dbd928df1d0d9cf74"
