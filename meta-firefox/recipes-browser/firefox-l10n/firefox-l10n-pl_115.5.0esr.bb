# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "232017ab9c7e4f3bd046a38790f0ee58"
SRC_URI[sha256sum] = "a49fc6caf644dfe4f7441b2b9684bad2912873b3e870b92e32c763e4d658647d"
