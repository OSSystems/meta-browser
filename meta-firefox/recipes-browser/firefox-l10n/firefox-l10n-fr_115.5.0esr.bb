# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4417877838cfc7ed35a7a2f1bfd4b986"
SRC_URI[sha256sum] = "5c18bfb3604314bd0595f8913d4f70c13c86408fce341ad9f5c01f8b2d2d26a9"
