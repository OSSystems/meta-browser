# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d68ce86c6748933c75584d2a50e23eeb"
SRC_URI[sha256sum] = "e56a63e64950325fe4a7e128478fba743d7ffe2d2708ba9db971388160b8dd0f"
