# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7ff7f499e3608660a0672ac2fb959cb1"
SRC_URI[sha256sum] = "223f24810c7325caff71be87c5f82b92ad1351c35af99b00815f57ae898f3b46"
