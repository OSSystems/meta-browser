# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e218bd7d11e3f151b3d2f07a452d87a5e9cb0a2316ce102b0bbb01f3e5a80afd"
