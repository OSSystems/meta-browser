# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bf00037e3a061324bcfa5f69cd04ae75"
SRC_URI[sha256sum] = "681ab7241af1e386d458a55da76b3f16d486761b7fb3fa15b52ba3a179540d0d"
