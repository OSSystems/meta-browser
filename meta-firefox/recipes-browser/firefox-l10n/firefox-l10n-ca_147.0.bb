# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2ee9389c816ec818104949ec9d107030"
SRC_URI[sha256sum] = "d82d0419657d0df4b83c6c6e6c4276d5e62b5315965aeb9e255bf93e621173ca"
