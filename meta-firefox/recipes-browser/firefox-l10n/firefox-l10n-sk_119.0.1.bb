# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "199ddf042604b0285825151cdd504439"
SRC_URI[sha256sum] = "6387e9c2669f1310f14a0a7e154cb39e60b68c6e8e1b54aa476645eed20447c2"
