# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "44de40b949cff29fced79702a541f644"
SRC_URI[sha256sum] = "1ba95e6ee244b044860cb49f86b8a83b00cdbd04bdd0bb273c690225b476d969"
