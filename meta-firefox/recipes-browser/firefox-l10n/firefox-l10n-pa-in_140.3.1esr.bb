# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d32c4a732657975d448631009d035815"
SRC_URI[sha256sum] = "8484f0b787af02876ad484459c009041603e356b099f821a4c7436e3c4adb050"
