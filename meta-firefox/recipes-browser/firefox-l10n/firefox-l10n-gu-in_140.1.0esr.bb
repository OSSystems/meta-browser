# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2da4cde166d888ce46b18802b55d8e1b"
SRC_URI[sha256sum] = "a11676b3a251704f32942fe5dac3dfd97dcec8a30c7824e011ddffff9b6e7cb1"
