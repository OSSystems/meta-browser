# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "abf4b3788f1c839584d4ec5bd4c25914b8a8ccd356b76483b930f7b2ef5c2e57"
