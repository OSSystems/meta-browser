# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0ef96e6f72e63f9da8c6496b268cd908"
SRC_URI[sha256sum] = "afe7cbc58f0705929ea36724e7fb677c6b5ad4d692649e1352dce9fe064d7976"
