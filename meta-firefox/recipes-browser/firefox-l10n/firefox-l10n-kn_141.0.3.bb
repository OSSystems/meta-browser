# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aa8731eb836e88b150d4cd55aac0f879"
SRC_URI[sha256sum] = "675472b8e3c4ae335a934e49d281aa48c9664b850a590ad78be40dd3e05b6140"
