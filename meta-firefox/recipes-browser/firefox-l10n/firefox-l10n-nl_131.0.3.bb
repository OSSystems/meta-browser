# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4acfd889775b50ce0f74c5ea46983844"
SRC_URI[sha256sum] = "af616eeb9209e06370b4e7fb1a27eec11fa358be7893a08be00e0979724d7cd2"
