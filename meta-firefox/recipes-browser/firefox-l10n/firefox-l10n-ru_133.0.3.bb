# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6f70a9a0401b830d566d02ee168b9778"
SRC_URI[sha256sum] = "dc78abee94f7d9653e23400aa931f61ff3f781138ce9380c66da303220cd4117"
