# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5ce6ebdbac9d6101970a9ef2c2921912"
SRC_URI[sha256sum] = "ddca6e47a9ac6757ea3fc37d6b347a89d37f076886fc2a9bebcb5e14e57909df"
