# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f397b7384f9dc03dee7273202efccc76"
SRC_URI[sha256sum] = "3bc302ecf7a10a7063da9beba02937e6bbd6a8bb162a7bd342ac97465f88d380"
