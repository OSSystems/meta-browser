# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "069d3746c130a3e995b12d0b60d5e479"
SRC_URI[sha256sum] = "2a94a97d39bc37d7f16b5af5a45f451a99c733fab71207172dc32f039a8eb921"
