# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a2eb298f4cd6041dd5f5b048c0243c3e"
SRC_URI[sha256sum] = "4255f4cf8a0fd355364831146920cf7104151863081f926ebbb8623fdbefac24"
