# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fae1ee3c72f8c6cd2dadcdd8a9972fe7"
SRC_URI[sha256sum] = "45ed84aed88c6a3156d43ceccd4e76f4b9627e59599adac11b2957dc2c3e3292"
