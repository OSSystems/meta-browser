# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "86c5d6ac692bb3d81979b1c7e0390aa8c72358a0d38f4a0f63677cbc34d76db2"
