# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "06407b2712f649d2c470ec014c0c6ad1e829953c32e8332a66fbc797e5f831ef"
