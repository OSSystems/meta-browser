# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9f59ba7140d5dad586306ff601b82293"
SRC_URI[sha256sum] = "01fcb25448acc8c3feee494866e26c80ba8eeb413bbf96ffcbecc60276853f5d"
