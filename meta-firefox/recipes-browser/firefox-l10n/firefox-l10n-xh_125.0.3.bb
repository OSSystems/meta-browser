# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b8891b820b6b29955f9ff626809e55c4"
SRC_URI[sha256sum] = "3973b9d3623bc7e276e7728c5b31a6c7e1cb7c589f0a45c843279166b22f94c2"
