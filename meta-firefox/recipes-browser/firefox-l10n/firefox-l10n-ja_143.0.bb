# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d9e365caec9f455dcb6f4fc302cd2d53"
SRC_URI[sha256sum] = "5f9b36d3faf155ba4ff626c2e2b8dca7f98667e556c24856f8fb14e1b34f60ae"
