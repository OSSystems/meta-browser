# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "23467102bda8e9af7898b72c5cba6f09"
SRC_URI[sha256sum] = "5f7583221f2ff493c691d75cd2b17cd3dffd7eecc9b3a960f9ce8c2d3aa6665f"
