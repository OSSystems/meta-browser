# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "63deecb1bbeccb92e48666014d05fc7b"
SRC_URI[sha256sum] = "57b0488ec605cdf4930c44a089cbeb87487070e663d685aad9eb49fab6d52dd1"
