# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a7e033cc9745f7d9e3821799c3bf13e2"
SRC_URI[sha256sum] = "113a4fc970d0334a3cb39a834841c15ef2d844e37e6bb1435b3a13315ad708eb"
