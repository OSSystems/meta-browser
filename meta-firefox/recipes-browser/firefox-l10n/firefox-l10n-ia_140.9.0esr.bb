# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b37a07e7ff79ea5b9148b3033d223ce9"
SRC_URI[sha256sum] = "b0dcef7376931087d61ae86cf22877b48078dfb7c2846d50f9f1bc627b9a6f17"
