# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5bd8c0a2c74c57bab798e65dc5245a02"
SRC_URI[sha256sum] = "3548ea8e334774bdd86f088208e59d5a783939668edcb1529aa14dc036f5bac4"
