# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8de9f247bf2b8039942f83f7199558c3"
SRC_URI[sha256sum] = "774440320314bd246efff0f459f66ca3852a2d3b7175f5a9117a2fc3e0b8bb22"
