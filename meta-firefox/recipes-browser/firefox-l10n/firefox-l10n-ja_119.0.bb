# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cc498b8080c1e0fddd5b7552bdeb398c"
SRC_URI[sha256sum] = "f50208c88e1c96bf3d86ca6fe6819839d66ad04cd460f52a7f3f265d96f79a67"
