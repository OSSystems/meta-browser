# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5af15295166859c16bf118a3f6b2d269"
SRC_URI[sha256sum] = "488821579ca430b450712f0b0c7326b062ca0b0c0ab91e9a1ef2bcf60a457be3"
