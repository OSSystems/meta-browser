# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2025d7441ae862ebf2853a6a4dc23162"
SRC_URI[sha256sum] = "c89c850a255e180d453ff2331dea3e2b8c18f23dd5d23f7a8cbdf6297284efb4"
