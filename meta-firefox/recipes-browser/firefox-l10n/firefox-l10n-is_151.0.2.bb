# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2db2550c4c34222c403c6324024119809a3ab7434191d522e51af7b565c6e3fa"
