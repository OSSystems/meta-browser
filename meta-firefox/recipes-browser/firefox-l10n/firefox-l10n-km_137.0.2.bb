# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e40a11f96ff3383aca22b01da3742cb5"
SRC_URI[sha256sum] = "df1f531e60a888625b884809133b317a1ab473919e1add768f15280b98e9c5a3"
