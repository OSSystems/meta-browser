# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "61114de92ec501b0cbb5e5fdca87ed3c"
SRC_URI[sha256sum] = "b4ed02625c30b35d1da78f2a3617eace6b1b582804944048bd263114a9229290"
