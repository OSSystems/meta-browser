# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "88a8fb3024732b19ccaba021cd4d263e"
SRC_URI[sha256sum] = "0ed08a631b9b0ab6896c9e7d2cb6dfb166d3e46d381d075ba1a120f061d85b46"
