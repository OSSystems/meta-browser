# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "69405cd24fe0b59d8d97190d0aabb3f3"
SRC_URI[sha256sum] = "53613bb689f3902cf0e65bf0568e55f16600df40f515fb36f6033bb989d558a3"
