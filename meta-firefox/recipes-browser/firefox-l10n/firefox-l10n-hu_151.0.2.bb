# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "feadde43362b9b458b2e21b710d0679a84be08a1daf41e937bc3084c87f4538a"
