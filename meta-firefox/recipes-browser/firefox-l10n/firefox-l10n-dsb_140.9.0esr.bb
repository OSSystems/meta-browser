# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c837c9f372704e1bd1c9cf388af4e4a6"
SRC_URI[sha256sum] = "facd74c99772c29f1f08b4d3e081bb3160b65b9bd1e01b45a50434b1bed75827"
