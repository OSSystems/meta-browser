# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f4f447a518259b69a5c1ef0ac8f57fdf"
SRC_URI[sha256sum] = "b1e3bd1c3f14c3d8a768837edcb96f5e2028d9d0180f91e3a6f27898a65d6d6d"
