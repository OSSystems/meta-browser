# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "acc146a35d415e0f9d57d2e764b97c94"
SRC_URI[sha256sum] = "5ec1c8db8d2c6e3c729419d1d52857dceb10082682201dc47558bf0b6dd0f292"
