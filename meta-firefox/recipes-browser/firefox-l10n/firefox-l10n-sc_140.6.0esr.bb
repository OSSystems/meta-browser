# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6d671369c145052796b904a3cf97b967"
SRC_URI[sha256sum] = "f36d978acda7949e82df2ac4fcd4a815a65e0684a426dacdf2cf37e2aa5dec28"
