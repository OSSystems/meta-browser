# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5a2f97e4e9b4ede2b7e201eff2a91025"
SRC_URI[sha256sum] = "1651c351b5b154653fc4dd6d846dcbccb0979209800278ecee0a59f72e65ac28"
