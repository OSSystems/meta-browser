# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "111e196f98b029d112daabf1a6003d63"
SRC_URI[sha256sum] = "497dcc805e466ceb623ab86241f743eed8803a5d04c428e4ff27726a04d69868"
