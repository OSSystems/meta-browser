# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7041c4648eebb8aa69e03937d98fdec2acc520413383a1b09dbfe30eb0a9f3d8"
