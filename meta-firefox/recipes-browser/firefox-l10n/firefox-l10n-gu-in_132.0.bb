# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e3e9134b670a1695fb201d3189970d74"
SRC_URI[sha256sum] = "70d93ca45cff40bf553686704cae87a46ae421b0f183d93964f16c9807506f3e"
