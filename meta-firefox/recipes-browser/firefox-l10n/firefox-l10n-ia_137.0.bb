# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "98766bb89b9bff6547e800f136bd407b"
SRC_URI[sha256sum] = "3842413baaa3e56cdeaebfc94dab80a5f90e819ba6678203171cb1fda2890d72"
