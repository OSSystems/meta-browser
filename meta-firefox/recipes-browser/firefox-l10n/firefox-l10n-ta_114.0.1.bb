# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9e9c671a38ca344e9b4097be162be74d"
SRC_URI[sha256sum] = "44ddfe330c2592fc763adb71450e186de6837e99021b633e0699b5de6590bc92"
