# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "afc73816f5f555dddabe7ae2d511ba1f"
SRC_URI[sha256sum] = "99d7f3ff76ca25c30016b67fbf796596e74edb787e619626e734d0808619f91e"
