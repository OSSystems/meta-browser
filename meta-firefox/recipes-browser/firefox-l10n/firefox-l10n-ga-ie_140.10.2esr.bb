# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "b5ca7687ffb9b5f34bad9402d2cabb91daf7aa9e3169f8155096b74f1b5d1987"
