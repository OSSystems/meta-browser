# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "06efe911b416f0fa33b02f982d375b69"
SRC_URI[sha256sum] = "7bf670e11b18deadf0a3a637057e980c435973628b3ac209fe559d3c22ec7127"
