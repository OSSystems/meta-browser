# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d25c286472d105704ae370c0593b1d14"
SRC_URI[sha256sum] = "28375fc67fb133322c8aa95142fec3dc846b44e20170d37923091b33f1a10fb9"
