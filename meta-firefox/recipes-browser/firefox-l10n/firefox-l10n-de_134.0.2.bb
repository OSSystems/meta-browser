# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2f43fa4bba1c6a2c28d6449c5e0dcb84"
SRC_URI[sha256sum] = "60d1e9e52dbaf4213e9dbfe1670eb74bc984a88d200623fa1a566d970baf7f10"
