# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "967cee176a1cef83e47fe616ff8873fa"
SRC_URI[sha256sum] = "fa01eaf90a07ec2db203784a35146b82bdff4f413f4a513bf11ffd0e6e905a0d"
