# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c4f349622d684fa69802023c7757cabd"
SRC_URI[sha256sum] = "dfa4e141b86edfa301b0438aaadb1233100e5bca5149491fd63a88878416627d"
