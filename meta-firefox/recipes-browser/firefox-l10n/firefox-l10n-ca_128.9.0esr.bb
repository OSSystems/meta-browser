# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a8c66b41af7264adf0e833a917363d11"
SRC_URI[sha256sum] = "8d4efe5679c718e63df1b4b0d21246db7ab2b36a0e10f3ca1ddf11e7f6e987ea"
