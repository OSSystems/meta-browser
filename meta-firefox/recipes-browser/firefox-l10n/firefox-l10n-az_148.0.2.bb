# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db6f412ee094863bf72185e542e6e148"
SRC_URI[sha256sum] = "ab943cdefb97efba87ce578970aabe294e28196db4bcfc5c617c8085e54c95c6"
