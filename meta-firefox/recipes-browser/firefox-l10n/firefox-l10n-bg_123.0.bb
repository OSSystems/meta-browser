# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "954654a21ea19b079da8ed5778ac8027"
SRC_URI[sha256sum] = "4e66d284ece290e1aae876225a297afe01561c0b150b2db6c5d7efbfbe21ddfd"
