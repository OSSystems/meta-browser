# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2f334fedc6ba57d4d82968a03382fa15"
SRC_URI[sha256sum] = "5541b873bac7770504f9f397ec0cfb1d2cf144a0aaea2e8b0dd178075bb1e2e8"
