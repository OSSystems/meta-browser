# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "5f44119b7bf0da87b54c9493eaac426b507408b2647baf4d4bebf48a6f5b296b"
