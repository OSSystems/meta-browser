# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9beb0db778da77080ba038880ee8d9ba"
SRC_URI[sha256sum] = "49936c0309a62df2efc8d417fb8b813fd429aa59a8678c70e3cb1cb1f80fc1f1"
