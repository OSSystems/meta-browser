# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7d49d3f266c59899baf8fc457fe3c143"
SRC_URI[sha256sum] = "668498f7da439028f6f8662a1b761df28065063e19c06fab403eba0c70fafe05"
