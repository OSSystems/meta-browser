# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a2686ab2eedadc23c99a3acde4d56671"
SRC_URI[sha256sum] = "93aa0126647640e57673ca344f4e7b8f85b1a7bd78ec407788b8c2b31ee35354"
