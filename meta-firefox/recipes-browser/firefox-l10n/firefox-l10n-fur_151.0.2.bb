# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "326c3d8c936c6ffc74a9e49f3fcdcda57e0ddd6fff4d2527c299500dabdf751a"
