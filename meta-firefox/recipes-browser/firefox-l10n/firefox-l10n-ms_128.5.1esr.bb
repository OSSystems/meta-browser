# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "da54c6ec8d7976356fd0829924c0cd46"
SRC_URI[sha256sum] = "c336998b1e8767c2b6521079e566ec7187d6591e15783cdaf90abf0711765d8f"
