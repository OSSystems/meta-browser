# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "69031d79a7471f8bfbf6e1288ae8c4af"
SRC_URI[sha256sum] = "6556d77749e9344ff7c73b41790562c44ae9772b9f16a575e84c5742bc91de60"
