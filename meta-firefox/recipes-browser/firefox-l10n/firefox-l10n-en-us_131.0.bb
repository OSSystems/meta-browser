# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "91ee1b01acec84ba8ba79bca226d9caa"
SRC_URI[sha256sum] = "1fcbb39033a2af0ef05f38f9ed4d0b50f8cc63a23b4d2da26ea3049dcda60571"
