# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "dede120decb2ce5067ada2d979dfc1e76b29084d4305bd4dab47bb5c3dc55c3c"
