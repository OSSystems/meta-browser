# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3cd64baf8c6bba60b593ef60eaad38d0f1e6208641efa9823061f4f793da5a00"
