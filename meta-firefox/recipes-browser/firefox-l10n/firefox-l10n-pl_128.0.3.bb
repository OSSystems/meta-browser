# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cb7f2108fee4ad5eacddeafc5969a6c6"
SRC_URI[sha256sum] = "10f8bd757eb3bab351930ff3e1e408fac99f174c61d44d021645ea500cb5fc98"
