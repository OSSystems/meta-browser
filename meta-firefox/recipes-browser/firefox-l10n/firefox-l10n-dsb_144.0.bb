# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "60e21eef77e639f5c23c00f5c679b263"
SRC_URI[sha256sum] = "2c4db5fef46dd4008c4de4abb5db747e974a1929c6ae7f931a017a01c161e9e3"
