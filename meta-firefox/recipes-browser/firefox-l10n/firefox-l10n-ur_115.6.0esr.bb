# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fd8b26342d5ae8066796fab7056188b7"
SRC_URI[sha256sum] = "eda50283b39e27b0eca1c0395ae9923f3e48b58887cb692c3788495540a15dbe"
