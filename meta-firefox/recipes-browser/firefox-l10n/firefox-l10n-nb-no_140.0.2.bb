# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4ae33c0f1038a9ca9a1b41a329a847ed"
SRC_URI[sha256sum] = "9e168a466ade99d1f8d6b36bb388bf8f56417d439299a6e36922d708b2e701e5"
