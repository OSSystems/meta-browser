# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a48a11e21a99ec8769a51d908ae0ebf3"
SRC_URI[sha256sum] = "b3d2ab2a04c2d1a60581f240dd995ecc5dac4164e49fef155f57d2022b8fbebf"
