# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "acc1cc8c6ae63be485737b153466d543"
SRC_URI[sha256sum] = "c3f66d4540a9e18ddf17ebf9cbe0c091a4b77948c8546d643087a865e20a4127"
