# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "5bf6a26fffe17dfba2b4d3678babe04b5e954bbd52c2bacc45311c9cc2b62610"
