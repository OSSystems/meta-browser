# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "277b14ea0a0adb0991c4d1a0f93c5d82dfb514c7fccd5ec5c176bb9ecd4f60ee"
