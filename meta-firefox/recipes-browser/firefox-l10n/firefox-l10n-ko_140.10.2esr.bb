# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "8de7fd7e264d11e3b9dcf77b4d32c15a5dc8993853ccf82f4de0d18a325377d9"
