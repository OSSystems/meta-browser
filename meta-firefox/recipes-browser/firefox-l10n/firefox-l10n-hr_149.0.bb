# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bdb7beca7740941229f680083c2b1b37"
SRC_URI[sha256sum] = "7145e01259b916e6a97c05d5e4b28eadaec35f60153e00dd6c6d1c2f3ae619f1"
