# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "5c47b45dbc8568c6070b9b635c0a03aaad4178502c336f6fef342a13426f3368"
