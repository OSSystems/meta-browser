# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e750889a735e7ab56e166d9429c265d63e63406f3ad8cc4ef686a9798b3b4dfd"
