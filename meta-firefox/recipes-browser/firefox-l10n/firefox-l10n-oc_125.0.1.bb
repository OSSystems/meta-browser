# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ecdc6c9fc968c3877449e6b67a40c73a"
SRC_URI[sha256sum] = "5db2ec3bad04046177945ac0c9fc63d446df50e59b19a71db4352fd611234461"
