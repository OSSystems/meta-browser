# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "52d46bd32272e3a71b6b0879aaf7357a285698fb83e232865456e21a58eafacb"
