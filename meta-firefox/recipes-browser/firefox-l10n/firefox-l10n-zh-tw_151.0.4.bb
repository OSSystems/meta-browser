# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ce8afacbdf12fda6263a82792ecab10a47bf2ebf35473dd1112d6051f73e1575"
