# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "be76a8ef19dc4a4b2cf2a39105e529d8"
SRC_URI[sha256sum] = "77431e96b9393bfb49ffd3f492a02cb993549f2ed82272062e5cd6bd2815f3bf"
