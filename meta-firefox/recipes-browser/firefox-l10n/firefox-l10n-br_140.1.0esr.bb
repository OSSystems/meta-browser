# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "84c08e7904f6436d90d0094a01f5d143"
SRC_URI[sha256sum] = "31e7029a864cfa135340b291d2566087ae92281ac835b65b0d340f5047da63cc"
