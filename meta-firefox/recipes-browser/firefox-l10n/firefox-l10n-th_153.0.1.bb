# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "dc36f0e2c153f3b9b3c6ea00af11b89c9523712279d86703f7a41a3ca6c4ecb9"
