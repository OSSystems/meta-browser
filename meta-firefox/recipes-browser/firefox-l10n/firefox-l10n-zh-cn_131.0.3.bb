# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e901e4f56bcf8313d159a570c0a57bfa"
SRC_URI[sha256sum] = "fb59225b47118530f7a7e48bd811a1a26f34a3497a13f359a6f74fa8e57c5066"
