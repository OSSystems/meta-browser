# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3f810e0a879501ff74c736afb5f2a3be"
SRC_URI[sha256sum] = "e9755360da9492907f2d2259692e0e63fb23e7eab314adb44076a9a6527cf3b0"
