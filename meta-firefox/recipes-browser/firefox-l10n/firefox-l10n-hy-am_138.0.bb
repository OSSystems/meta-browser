# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9555fd4290e06da94294132c3974605d"
SRC_URI[sha256sum] = "11e382f6f41d89bf737689e129428636bef923cbe5c98c99a669c9c094424da8"
