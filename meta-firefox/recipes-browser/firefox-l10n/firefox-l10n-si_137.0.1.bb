# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5a33d14d5c4761a8512a1ee86d9d9e83"
SRC_URI[sha256sum] = "c80bca54bfc639bce684611d2b9d4868b122e5a7f69970ab83a07b04f302e2b5"
