# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "846698ff2ce17f9baad448002c4cd19c"
SRC_URI[sha256sum] = "0c41d1045c9b4e40a022029901191eceb7682b7a2d80ee5f5dae56eb32bc53b0"
