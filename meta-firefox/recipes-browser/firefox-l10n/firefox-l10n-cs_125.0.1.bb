# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "090b9cb71610c4ab8c1d8bbf61d5c270"
SRC_URI[sha256sum] = "d5ec4847182f1450ed1bd51b9b8eb95edcd74ff28132fc6816071acfb6d98f11"
