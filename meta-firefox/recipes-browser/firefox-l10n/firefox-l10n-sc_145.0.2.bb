# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "94a958696c848037e93015e6ac176845"
SRC_URI[sha256sum] = "3534cb61cc85868b815befa83091c53a4dfa7a80c4a7f18f5d32bb9df874872b"
