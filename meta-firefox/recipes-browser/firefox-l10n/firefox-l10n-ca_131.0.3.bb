# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1e288ee1e94ff792c45cb81af6ea65d5"
SRC_URI[sha256sum] = "0d7d9941755c0714e512a9376d6971bb31873ef7e76db928eb4e3bfd65981d4b"
