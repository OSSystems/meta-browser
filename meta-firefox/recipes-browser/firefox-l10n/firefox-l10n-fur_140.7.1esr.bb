# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5644b612400050fc45aab4f7f4bd689e"
SRC_URI[sha256sum] = "f7f43ad41076c028aac4f9070cf0725723c03f01525c774b58b10fc2b6c8bb15"
