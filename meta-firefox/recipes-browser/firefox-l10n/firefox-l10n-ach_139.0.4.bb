# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "38638fb8705e301d53c18ba43df49306"
SRC_URI[sha256sum] = "111ed530f4ac007c7d706a298b8f3d269375b41a88a4730a3e07f17b6700ac86"
