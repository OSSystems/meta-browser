# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b79bb719ab1d15b9d187d03188c51608"
SRC_URI[sha256sum] = "7740e72ab988d49352b5f933dc16c6d58f5fa1135e6051b1aa8942d89f244c3f"
