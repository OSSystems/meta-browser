# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3733827f5b4e43fa919675b2fff3987b"
SRC_URI[sha256sum] = "21a913b5af68fba775b530301de360073b5c7be21fee80ca15cdece74d368816"
