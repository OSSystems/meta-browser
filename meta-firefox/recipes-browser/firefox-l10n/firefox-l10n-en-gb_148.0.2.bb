# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4fdb4650400c2efc2eca2d51c75d932a"
SRC_URI[sha256sum] = "93842269adeb4c62ae32baa53d5d8dddd757e8d2a54b9047c4a3c971cb442c33"
