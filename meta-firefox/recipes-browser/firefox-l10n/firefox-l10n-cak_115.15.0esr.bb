# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "966b6e18945f6583bfc549fff274d0dc"
SRC_URI[sha256sum] = "a90a9bfd191bc2efa456ac70dad95be6553c033c0279f54f095b9bfd124ab33d"
