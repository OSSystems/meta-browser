# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1a204ae030a42d8fe2d2342e99f4dcad"
SRC_URI[sha256sum] = "936bf1d572c7922323a54cd81972fd19c2979b138732d02dd23a15b2f9cdc520"
