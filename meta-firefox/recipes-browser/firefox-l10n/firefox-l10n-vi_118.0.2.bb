# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "08ea747d0bd8219a0c5415277204622f"
SRC_URI[sha256sum] = "1917eb8d003656eb3164ae96022a814dad1a2fa6528eef5eb579f5c7e101e658"
