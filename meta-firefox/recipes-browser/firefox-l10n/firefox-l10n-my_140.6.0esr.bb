# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bda7f6c0a67253a203efce074cffbc53"
SRC_URI[sha256sum] = "5a834e45f1123eccef1a82a4b72b05698a3d9a6dd82148495c702c67bced683c"
