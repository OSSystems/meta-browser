# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f69089af92a71dddc02ad86f77b2277c"
SRC_URI[sha256sum] = "a5fccff255bc61669782a580411e415a7f7c1949e58683970eccd4dadc353711"
