# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "941b700673ebaa6e4b9016c4d23dcf5b"
SRC_URI[sha256sum] = "6af77cf51f91960a574e1249ba7586f641d8b136d77b53f7e525a8d00d0cb27a"
