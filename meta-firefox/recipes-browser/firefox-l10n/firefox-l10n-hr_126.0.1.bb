# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "95d27434f195d1542352a6ab4715b0be"
SRC_URI[sha256sum] = "0156b5dae47d8bd646aa7315a02bc27ee7d8d9be066787bc34ef6f120dbce022"
