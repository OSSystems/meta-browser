# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2d0e2a04ceb2a589c36ad86be411c8c5"
SRC_URI[sha256sum] = "7227f9e0ecf15ad3733c51c1761ef8d40075217c5a961b50fe086ce33c61df09"
