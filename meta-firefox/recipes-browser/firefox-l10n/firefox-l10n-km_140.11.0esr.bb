# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "433f37b05eeb37894d1fc7dfe585dbe1b93e9c0445e89b765df6e651fb1835fc"
