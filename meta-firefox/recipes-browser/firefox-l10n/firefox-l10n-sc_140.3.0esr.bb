# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "30b1ab73498948c93d17ee82695a27f6"
SRC_URI[sha256sum] = "6a0ddf692fd68a64f57815b9cc2f276b7f69327e16f832fd8b1ec1fb64f8504a"
