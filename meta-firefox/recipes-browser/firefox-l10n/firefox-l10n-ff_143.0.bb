# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "305cef22a380245d2b98aa263adfbfb9"
SRC_URI[sha256sum] = "e939a6cb36023ceb780d1ae5f9fa2c561925119ebc0759aec64e99f0859337be"
