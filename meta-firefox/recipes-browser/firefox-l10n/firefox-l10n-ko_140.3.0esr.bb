# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "110ae384faad52cf56783a106628755a"
SRC_URI[sha256sum] = "1155d338f923e2ae7ede3f556ff034ff532af3a89d1921e514f5b8649c257816"
