# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b4daaebb25e1ca3a572ff2bbd71b7b63"
SRC_URI[sha256sum] = "bcb94d33ea91bbe4261854e960142292f168ca9823a7a46249845f33dcee6576"
