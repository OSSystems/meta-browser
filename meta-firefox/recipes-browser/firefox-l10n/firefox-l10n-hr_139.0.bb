# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "14d29f8719e76b05d1f127d3a3782d1a"
SRC_URI[sha256sum] = "bbde169b2c7ecb95631eca09e8274cf1ac6073c5eb44128397e20933e4162358"
