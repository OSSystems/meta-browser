# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1db7a5111ac84284849d8649c75bfb37"
SRC_URI[sha256sum] = "b143d1c00fec7394112ab6c05a6256dbba86e7e6c5a95c6975330485df0d3948"
