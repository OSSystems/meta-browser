# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f5c08907f80163553b3ad9ed7b4e65b7"
SRC_URI[sha256sum] = "46c249771adfb1dca793f5b7e8ec4880e1910146a45ff086e265eaa0308d14ce"
