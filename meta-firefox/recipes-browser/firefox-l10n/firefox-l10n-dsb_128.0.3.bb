# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fe6a36e31ad7d2b2102abbb5d5f2564c"
SRC_URI[sha256sum] = "e6b81b6b22f47fccd13357985aa4856c2f83f739c6f3a122758ce5887af5a5ff"
