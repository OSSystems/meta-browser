# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "4b1c21481bc57ce2e24f67866612aabe602f00319063ac92e5cc2d39e445d479"
