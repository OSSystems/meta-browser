# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "f74f348d53c3be3b10fb42a696983e6600243d2f75d2ba88e328b32f09fa659d"
