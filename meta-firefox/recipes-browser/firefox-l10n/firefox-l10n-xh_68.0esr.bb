# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a0826b6a8201b0d3089d013264ef421b"
SRC_URI[sha256sum] = "4e25455515434f0822f8fd732cd0f949c079e8fe457d4f04c6a3c3a39ffaa3a2"
