# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c3588f865be9d467b9a36128a568ab5e"
SRC_URI[sha256sum] = "2f1f14ec706b41bd9b2c6c99de730eefa287f204405e5849cb9fbf714530cc74"
