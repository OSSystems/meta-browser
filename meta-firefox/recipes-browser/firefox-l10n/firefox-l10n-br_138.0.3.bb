# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4820b991c894885d8ffdd125b364276f"
SRC_URI[sha256sum] = "9a0741d2fe39aaaf4330d34df5f643f8f554bdba9f0ec708fe93faf47bca83a2"
