# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7f4ff2d8c3604eb65d0fd5d71254ab79eaa9be2baea0ba5569599eed1092a817"
