# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8cc1a6d02db2bc43934503bc0b587453"
SRC_URI[sha256sum] = "5cf5e2387a03d30b39f856206a1852f26694a7a77768884470a97c32c9ce80e2"
