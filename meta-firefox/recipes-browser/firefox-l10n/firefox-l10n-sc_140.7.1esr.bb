# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3248329c8ee6d41487eb3e0b4797530a"
SRC_URI[sha256sum] = "2ccb557e22a94e9210acd8e0368e4f0514d3482952edbb303f6211cfa1715513"
