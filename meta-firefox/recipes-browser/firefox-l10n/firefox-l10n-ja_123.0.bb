# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "621ebe5191aafda901cc60af960b4cbb"
SRC_URI[sha256sum] = "c893d6e8c34046daf72628f609befa17f5c427d3aab2fe8448a7fa95fac7a2e3"
