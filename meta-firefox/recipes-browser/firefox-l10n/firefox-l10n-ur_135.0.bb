# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "557ea4cec7dcf3a1521420f296973a87"
SRC_URI[sha256sum] = "a96a82919ecb20dee0869ad9116ef793b8460ff4fe164e63dd1093521153fd5a"
