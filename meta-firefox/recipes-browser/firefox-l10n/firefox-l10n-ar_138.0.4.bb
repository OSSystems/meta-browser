# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c247221676575a72767c5e16ab25794"
SRC_URI[sha256sum] = "67c0ec884cb4227ad56065002997f89fddc5ebf63bec628bf976b024bf46daaf"
