# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "fd340f87f9cc0e2c386476cbc438946a86b1011d8903b5bf18e72bf588f5d462"
