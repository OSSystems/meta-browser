# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f369a641a96ef4b266f6dde491843fc6"
SRC_URI[sha256sum] = "dbd9477d05332cc1733558a4b3260b6316518b3f539452c6405ca8c19109dd56"
