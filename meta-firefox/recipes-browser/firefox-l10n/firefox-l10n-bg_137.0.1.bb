# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7ab093eee718563a1276b8785572b859"
SRC_URI[sha256sum] = "1f434a82a24d40addfd167ffe0c7889ee1b3e86c818de340ff8a528b79486c41"
