# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "786bc1cd2a0760daec79fb2b6cf810c3135c03605016e99d91a8055521c04f08"
