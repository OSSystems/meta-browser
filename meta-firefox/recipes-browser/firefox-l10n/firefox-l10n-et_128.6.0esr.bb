# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d38d74425b908538284b19d2736f7731"
SRC_URI[sha256sum] = "9f9454e77d27b5dccd0a0ff553e1640c86e995c8c0f363f41a658de453e1b355"
