# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e832cc2201588926e194dc1861433b55"
SRC_URI[sha256sum] = "b4a883dea0677fc9450b5521991c129cd26584e4ca757e7c4750d2b864f8e766"
