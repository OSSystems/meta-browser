# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "9c658c993bfc468a32a0597a07d17f3b32efcdf608f401e251bae5e4d06bc5c7"
