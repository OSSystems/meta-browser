# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f46bebd8d128e1fe48217f5abc56c3b8"
SRC_URI[sha256sum] = "e08f282f070014d4eb8449c44a818bc4b645d17123eb920783cc237dae370b95"
