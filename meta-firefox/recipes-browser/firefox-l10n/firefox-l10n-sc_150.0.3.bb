# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3d5e5eb9db362c4748d677f1f94fea0f545ab9b9a2287f5ba4b2c938f2d6942d"
