# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "056ae4b7f93a936321eb2b12201479d6"
SRC_URI[sha256sum] = "35487333543adfa2ac45b74d00b0568e066fa23c159cbb0b12050216c863c3cf"
