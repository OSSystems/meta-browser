# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "408bfb5802f746de3febe29ddd8220c3"
SRC_URI[sha256sum] = "bac01c1c01ce731126a1093daf00ceaa90a1feff4ee7db8c0060e934c7e6bdf4"
