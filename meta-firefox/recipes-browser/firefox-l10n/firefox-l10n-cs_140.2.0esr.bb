# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f02dcbb350cf874013f56b172a457180"
SRC_URI[sha256sum] = "8dca4468dd51d330316fae305ffb669bfa16a952e450ab57de57300d725def40"
