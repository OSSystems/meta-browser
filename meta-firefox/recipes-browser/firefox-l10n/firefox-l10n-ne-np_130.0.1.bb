# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fe94fc52da0fb2488189e4c848482912"
SRC_URI[sha256sum] = "c70716c3e7d28a10e8de8643494038f7f675dfea5969fa5586af91224b5831ef"
