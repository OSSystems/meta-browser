# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "68ad1b02f946acfb35599f3fdabd4350"
SRC_URI[sha256sum] = "902ac87c8ea89a0df7db6a406b9eeb51291187b3961d0a687fd4abd6cc1c359e"
