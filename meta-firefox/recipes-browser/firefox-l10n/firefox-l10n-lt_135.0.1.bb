# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0394c53b694aabcd48d0388704df6a3c"
SRC_URI[sha256sum] = "da86d98eef17ac4f219822e76d7a7fb998e1d4bfabf63304f73047b310b82724"
