# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "05af71d9a76be2aa78837cbc94d53a72692cde38ac07b1c7e77495031184b7df"
