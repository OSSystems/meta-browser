# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "466347c0fd9cd14a834df915b7eef825"
SRC_URI[sha256sum] = "ef5260e65ef4e63dff1572c96fc1a9c081ad2c69286ee36b1b3f66d3fcf81299"
