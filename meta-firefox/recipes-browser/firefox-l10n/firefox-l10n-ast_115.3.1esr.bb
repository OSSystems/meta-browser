# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "feca4fb00c7e6c86782b37d18bd34e0c"
SRC_URI[sha256sum] = "1ad7c13fdf3bba07bccde7522e93cd8501c4d3d341ae0d96c610dad475e34bd3"
