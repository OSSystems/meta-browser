# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5094d5185ac8581c1d76eee49aff89d7"
SRC_URI[sha256sum] = "23ca0b49dc7de7c9a758c6853f1b4bf35dfcc68527795fa422fca6b3f1e2055b"
