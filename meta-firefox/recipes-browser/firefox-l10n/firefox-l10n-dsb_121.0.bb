# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6b52ac61fe05af78267fdb18c11b0941"
SRC_URI[sha256sum] = "728de473f300511f7bce6529bc3a5784ef8eff2089caf8a64bb5f04c12f83c5f"
