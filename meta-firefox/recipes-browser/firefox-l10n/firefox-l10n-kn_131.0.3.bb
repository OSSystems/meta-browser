# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ca38fcf1db7435ba5728d42b451898ec"
SRC_URI[sha256sum] = "86966259e33035ed17033020929dbf276dd92ecc9919896e819770f1fcb2d193"
