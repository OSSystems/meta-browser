# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "67a94bfb10da6a8b7957ba1a6911e839"
SRC_URI[sha256sum] = "2140b273ec32d5b7636750b5a8fa224315ad5e6d756b247d2403b609ca37ed0b"
