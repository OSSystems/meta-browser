# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "073f08ca4cc0eae41242672e234bf911"
SRC_URI[sha256sum] = "6c9867fcddcf8e663e8e974339fb5ba3f7a4909e7316c65fdc5aa63b40ff1944"
