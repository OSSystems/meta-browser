# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5e66d8c9f26ac0a6cba6a6851ec66518"
SRC_URI[sha256sum] = "541afedc6a4ca7875dcac7c47cf8f2f507a323ae67ec176f53bffc708007dd9f"
