# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4a211d0077a63b0d82d35235c50d3b8a"
SRC_URI[sha256sum] = "a45af01232e8a3bf0d89f4ae13933b0ad537919de9ad33fbcaf639ee584982c4"
