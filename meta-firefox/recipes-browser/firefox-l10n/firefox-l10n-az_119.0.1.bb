# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2c8dfc5affeaa78269e1b8f154849bcd"
SRC_URI[sha256sum] = "c1224827e4e661ab7312eab4ed25ebde9a1b83a3082d488a09731091572b0499"
