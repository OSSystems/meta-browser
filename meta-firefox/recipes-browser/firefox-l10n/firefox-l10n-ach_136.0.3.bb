# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "195814b616066c2d0b8fc2cdfa4441f5"
SRC_URI[sha256sum] = "1fc2104b33d28b9fb7e95cfcd4f599a3b57cec52f03e1996bfb5e98adc37e22b"
