# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ccf78c693c9baa16390cb17a591e2f0"
SRC_URI[sha256sum] = "fd7e9a657ac3166230277957db116646d8a0a6e7cfbf2b8a16a01631a8afe985"
