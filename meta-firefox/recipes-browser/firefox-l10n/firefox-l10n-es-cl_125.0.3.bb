# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "26c6c165ec7d4e2446743012915150be"
SRC_URI[sha256sum] = "824a0e7d9880bc213e46a0fd33d04d1425b0b40b1455e4d009816bdd14b6f3e4"
