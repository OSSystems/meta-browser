# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "93a3e1e7d883a4b4dd4004908f292065"
SRC_URI[sha256sum] = "fad5cffa4d3738b0e2f50d7d35762ccd6d4f5e545da4aeb2e302b5803ab43110"
