# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "000217f5dd024fd3a988340736603200"
SRC_URI[sha256sum] = "004bbc1ad42e1ef8c5c1a943b2d7f0d00e0eedc9ecf21c4f8d2bd547da26237e"
