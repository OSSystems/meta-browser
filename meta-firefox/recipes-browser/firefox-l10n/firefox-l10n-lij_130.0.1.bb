# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1eb11a32957ef99d8772b5a1eb15dd98"
SRC_URI[sha256sum] = "0d545fe46247ccb0a75fcfd1c08991634bf108961c452f4c634bd9fb3cbaf692"
