# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e75150179d6075729f833f355d15d0f2"
SRC_URI[sha256sum] = "280d13601d0f1610ecbdfa670e32a0c257178a3051d6b06ef4c5f27577a087f8"
