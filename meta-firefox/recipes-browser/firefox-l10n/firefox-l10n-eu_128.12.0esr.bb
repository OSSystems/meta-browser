# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "95c7dc96eefbbe0917eda27e6c74d6ef"
SRC_URI[sha256sum] = "180c8dbeb6746d8c3968fd2cd0fbb53ff4a56c8970edde17608d14e5992eecc1"
