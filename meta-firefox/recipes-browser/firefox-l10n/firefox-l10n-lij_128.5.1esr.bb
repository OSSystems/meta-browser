# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bccf3e83b58341861e7d48edf5011256"
SRC_URI[sha256sum] = "262d7585d2d5415db6ed9219d505021d203ed0becf57241134fb49347efa2627"
