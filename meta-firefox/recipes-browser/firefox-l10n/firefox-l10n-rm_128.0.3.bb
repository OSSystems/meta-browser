# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e4e2b30c83e76c05c8de8a9839083ca2"
SRC_URI[sha256sum] = "38e334e8e982d5ca5b8b353aa42872dc373c082a34365f69bea2f70339bb0365"
