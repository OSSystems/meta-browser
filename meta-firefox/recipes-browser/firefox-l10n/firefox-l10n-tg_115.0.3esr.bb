# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e90c175f71eade047e8900dd0fd36a4b"
SRC_URI[sha256sum] = "5f8d45b2a2efbab47a1ce017164348de6d6ba6f391f5135f88450e88ef47b29c"
