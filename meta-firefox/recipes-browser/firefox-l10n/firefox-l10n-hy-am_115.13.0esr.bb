# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3f59af2595af7e8871ebba6b1ac8e708"
SRC_URI[sha256sum] = "d5f0d618904fbf4b20a8b26bf9b4805b076988b26fede6d4b44021ad856f19b6"
