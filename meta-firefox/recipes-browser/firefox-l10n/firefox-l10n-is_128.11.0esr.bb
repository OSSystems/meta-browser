# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1857a2e30e700f5402a690b1cc04195c"
SRC_URI[sha256sum] = "21f9ef64ee1f543102a97f40468df47c1f624ed12a7b26edb8f86afcd38be226"
