# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b3071195c6eec6cb26115bdba79cf9e0"
SRC_URI[sha256sum] = "a80f17695142f5d4562ddc5dbc53868539b22e87b5840c17b2c6883dbf054702"
