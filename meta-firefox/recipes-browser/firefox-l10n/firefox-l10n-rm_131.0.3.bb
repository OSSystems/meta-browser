# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5ac738afad36333d894fcee73ac6bc0b"
SRC_URI[sha256sum] = "19344185472bc05fee193553b752be7247f4c2af3c09fdcf6dbcf9703ab5ae49"
