# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "0aa0bf87bce6ff20e81903e45e40308eb2fd686b9087b345fc35b709aca6361b"
