# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4fc9fd4e29d7e9ee5633043521c058e8"
SRC_URI[sha256sum] = "16652820fb33ab77a5a6157edaa8f68c89b22e017ce8acbdf11694beb3d2b296"
