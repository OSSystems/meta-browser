# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2f23c6e202a5ac80041b9a08772d6dba"
SRC_URI[sha256sum] = "da9973e330ba11d3aed82a2d5b312c89c880611feb3a9da138b417fa5ad9c258"
