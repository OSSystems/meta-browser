# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b8c06b93ac40ffa29e360d47e3e3622d"
SRC_URI[sha256sum] = "869e858a530f56c823e6736adeef43b1cbb3a0bf8bc00f2faa3ef5f4b1bb101e"
