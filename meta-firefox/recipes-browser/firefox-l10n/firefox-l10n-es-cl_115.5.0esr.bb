# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "68ac9fb44a81311af699485a31d7de7b"
SRC_URI[sha256sum] = "32308a20710772c0f15cae3abb55979d3c43a8b0527d103960b29bf39234917e"
