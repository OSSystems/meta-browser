# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9f6c2f8cd8af5bc6112dd21204cbde47"
SRC_URI[sha256sum] = "18fbaf0507fa7958547ca00478770299aea911c0253d8bc1acf4adbe90706826"
