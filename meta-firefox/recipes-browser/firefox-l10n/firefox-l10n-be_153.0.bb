# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7d3932b0591e713c1d1c2a4689b74e380f7ae3b430a43fdeb0e7260fc07889aa"
