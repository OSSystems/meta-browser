# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "08a1ad41165fbb8a9eac9af327f828f4"
SRC_URI[sha256sum] = "d7778c7f83d53e3fc181796cdc6cb01beb557892fdb10819453b8d8b12150801"
