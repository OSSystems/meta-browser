# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3cec92734425c6cd7254787085365da0"
SRC_URI[sha256sum] = "e8d60519ebf7917973b0aedae8eedfc6f59a0d49624c4c97021b7b1ba10187a7"
