# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7b3b592aed42cd4ea3bed07afde30ce4"
SRC_URI[sha256sum] = "9bcb58ce4c102156b2cc11cd4a7e0f0b0b7f14835edf15a4e0227efe9272a194"
