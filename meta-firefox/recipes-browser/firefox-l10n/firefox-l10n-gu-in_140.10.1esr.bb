# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ee8a4f5336bb5f55b888be400dcb16953a86ec2585468b025a2581c1726c2414"
