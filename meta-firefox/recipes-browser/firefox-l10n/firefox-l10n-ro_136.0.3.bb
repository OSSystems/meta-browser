# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d5022f01ba213919934762a7ad5aa37e"
SRC_URI[sha256sum] = "db4fd1a397f17eb8867b5ec70191d3ac5d6ce6d2d33d6465b4817ae18dba3041"
