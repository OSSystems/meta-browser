# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "10c67a6bac3de865f417ca6b21953f45"
SRC_URI[sha256sum] = "4532f19378e7d486270e3355f12418090b22fcea9bcbce4919c3ea001261acb8"
