# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8dd6919178769eb48e920ef1f08a48f2"
SRC_URI[sha256sum] = "889e2e2c137abd499fe4638ee27db4296c4e3dba35cf61aec4e4be939dabf40d"
