# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e25c3d3cbe1491df40af97820b52bcb1"
SRC_URI[sha256sum] = "4e80ba18812aea443d9673aca25ce23dd31cadfea22c18a31c4088e3d586f88a"
