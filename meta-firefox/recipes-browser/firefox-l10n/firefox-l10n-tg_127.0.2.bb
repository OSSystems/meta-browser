# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6cac2f5a4b2e733d0737b162cbb18cf1"
SRC_URI[sha256sum] = "fa126fd0756b443996b8fe1b02b4cd6edd7deaa0351c8600263727aa6bc89572"
