# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5a4e7cd09c4cb4e94c88b484bc6e052a"
SRC_URI[sha256sum] = "8cced79252100c17e110d601871844d5cb065c5c25408b4d4fd13bde74843b68"
