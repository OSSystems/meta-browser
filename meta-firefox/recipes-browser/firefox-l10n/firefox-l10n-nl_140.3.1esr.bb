# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "553416dda403fd24d320d8e1b174ddd8"
SRC_URI[sha256sum] = "3f7f7cf139c949dd2f1b6156ac497f46719837cc4699f6d80b2e526c77809e9c"
