# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "92b75932f8a34730e50f2497ddeca0e3"
SRC_URI[sha256sum] = "055be814733f085c28f4edb9ab1f7499f24724f53677856196ab59362b1884b8"
