# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "12fa216e4b3f3703b66908ed576a5c0b8de73a3671504268394b2040bace3da8"
