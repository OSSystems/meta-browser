# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eeb582eee9853f19c36ca98189803970"
SRC_URI[sha256sum] = "d83469926b8daeafa3011b6bf6dedf2b224e01fc5822bbadb92fbd03fdd75d90"
