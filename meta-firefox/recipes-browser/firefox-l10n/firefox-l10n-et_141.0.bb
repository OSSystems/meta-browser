# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cf3d19a22ce8afd5ce496d8fdc01016e"
SRC_URI[sha256sum] = "f87c363519591d77e97c969c11b4eec771e6b5b9d1a693c29f2cee18505e272e"
