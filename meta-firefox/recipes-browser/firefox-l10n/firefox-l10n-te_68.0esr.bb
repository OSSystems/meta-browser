# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8046cb0b4c6b3e62b7ad80f0eef04cdc"
SRC_URI[sha256sum] = "168f4188ed33da12f76b2030c0ad84e909385c97cf12b8da4bbf241c5cc547dc"
