# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6a7c3f4c02624e7760cc6eebb10cda76"
SRC_URI[sha256sum] = "ccc85c03ab28235fff6b4c2a7d3484439f69915f9b1abdb01e10920ded1e6dc8"
