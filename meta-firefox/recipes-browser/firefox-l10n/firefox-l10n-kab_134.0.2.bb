# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "371aef8e420d4a06724be5e4cda70ed1"
SRC_URI[sha256sum] = "d9a3043d840693a3fb6ee469b9ea35a39a7d61be4840790d34aee7a1bb6d4d4b"
