# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "78401ac13b44920f19201c26c59cb5d3"
SRC_URI[sha256sum] = "809d4d6d27bca0d2360ede30d1eecd8b9721ddcbb2c1c32f1dee58aa9eac0e77"
