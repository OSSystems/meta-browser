# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9563e5ad46a89a41eb957ba1f56da038"
SRC_URI[sha256sum] = "4465f7c273e82efb23be44ad863be5c4b0818a07d34e36f05bfbaa1f77ea9cce"
