# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "95e0347bfa95b4f8d2aca9b6eb208dad"
SRC_URI[sha256sum] = "a7a664ce675140d8f8a443407191e64f860b56e808de740b60e5cff9087513e0"
