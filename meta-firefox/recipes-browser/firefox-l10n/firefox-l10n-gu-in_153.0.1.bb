# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "eb2b1839cdf7261b9d61718b9d5f48dd1a12e3e9825ae7366fa2ebc073ffea7b"
