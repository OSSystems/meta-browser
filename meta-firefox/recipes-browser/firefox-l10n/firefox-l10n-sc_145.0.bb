# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "187dfc5def73ee4c304f601906596bd2"
SRC_URI[sha256sum] = "85783b73e7a42816af5f8a5a15a0b49b81d03177b3390a338432ee63823722c6"
