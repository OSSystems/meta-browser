# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "069141203160964e3a1ca9c3db932a92"
SRC_URI[sha256sum] = "c4ec93ee0d2ead5488c9f6b3bf2b95318370610bcc2f9d2f7d5bcfc7d91060be"
