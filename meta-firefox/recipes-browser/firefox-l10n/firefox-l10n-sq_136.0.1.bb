# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "26802066661d4bfa71506609c2f66bc3"
SRC_URI[sha256sum] = "3805afac8a9c59df2efa25ffeaab684b8ed30ad39ea04c7e6cb6551970ac113e"
