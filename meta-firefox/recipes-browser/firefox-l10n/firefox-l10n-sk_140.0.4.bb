# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1296f6d3d323bd3532317a9ddb98b77a"
SRC_URI[sha256sum] = "5f243fd27500dfa7aefb00d2dd5b9567c0a0647e1c39a91d774a71d2c6b82931"
