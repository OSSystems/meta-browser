# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9646164f387b2a93f360a9198a8b4c30"
SRC_URI[sha256sum] = "864f87b79eaf8e08841348964b4d816374683950b5c94e726ee43a288879d4e1"
