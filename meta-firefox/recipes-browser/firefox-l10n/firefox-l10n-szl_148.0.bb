# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "31d7a92653eaa2e63f8e3bec6837f80f"
SRC_URI[sha256sum] = "8c1754e6c9f0d807cfb70891f111d96d18292ea8371deac051db2ebd0118e206"
