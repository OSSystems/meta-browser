# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "39457d6fee1bdf51a6f1dca2860fdbe4"
SRC_URI[sha256sum] = "222d5d5282b35bcdf37023fe05a374d3de31721ad74cb3d841edb2df45a38553"
