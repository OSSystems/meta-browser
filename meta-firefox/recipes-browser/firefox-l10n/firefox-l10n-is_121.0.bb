# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f9cbf1a130e8dc1e4fc77b77ad03f6ae"
SRC_URI[sha256sum] = "26c3a26bc435673bdbfcff23877d65f84c28e5a92389cf53884689c245bfbb07"
