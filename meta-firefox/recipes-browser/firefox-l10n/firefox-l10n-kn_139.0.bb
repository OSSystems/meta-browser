# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "18f95811269a25adb9022ccf967b1e5c"
SRC_URI[sha256sum] = "57556399e9f003cfb916689b9031f63f07235aa1e9b531d237f9d2db47c191d4"
