# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d0097e3403c1fc2e46382655bd3b0af8"
SRC_URI[sha256sum] = "f404dc75cd74b2cdd91a783bfc0be1c6a7c51df40bd4c5181b366a63db81ef07"
