# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1ecb5918b7c9c39021fd032196573d87"
SRC_URI[sha256sum] = "38f2efab36186ed9df203d6ad30617fffbbe69c61a0d2fac05375af9f479e096"
