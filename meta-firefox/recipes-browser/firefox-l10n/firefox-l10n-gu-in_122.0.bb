# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d7d9641dfc8c5674bb2286d2e2bfa4e0"
SRC_URI[sha256sum] = "d6325321e8205e86231201af5dd5fd2dfc4cf8cc6446530d61189dcd44dbad68"
