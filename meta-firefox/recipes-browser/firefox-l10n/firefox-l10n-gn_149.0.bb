# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "28328442d42423e7522ae026c0439b49"
SRC_URI[sha256sum] = "e76afb5bdb4f5c16820b8bc8adaf1fdb3a2b2a5106439a3680644cb6d77aba6d"
