# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "46b44d649a8493cb5ab24a04686d7bdb"
SRC_URI[sha256sum] = "d8b7200916f661bd7a7c5e1538ec9062c59e2b8475379434404f3fbf67675d34"
