# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b69863d8de8fe1e260084236d24d03f4"
SRC_URI[sha256sum] = "d0d03785bbb684d4c50bf20fbb243e3b5b68194e69be6edf80cf1d5238e6045e"
