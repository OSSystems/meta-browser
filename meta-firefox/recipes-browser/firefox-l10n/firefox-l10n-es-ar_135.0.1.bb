# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1f27171a7e4f2a879728944959ca24c9"
SRC_URI[sha256sum] = "099cf4f2eecffb78fab05bbe62d35da8bff4da618463398bc6c000a0b956d39e"
