# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "393724b1991087511df27281df900661f6067c6a0a5b4e2e6fb8244e019da4a6"
