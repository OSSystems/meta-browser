# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "39e328cd37cf5d7d2509aefe2fb46ee3"
SRC_URI[sha256sum] = "6720f3d6970d2404da74898d0f0b1646e0ee5d23059b881c06bc290b50f27309"
