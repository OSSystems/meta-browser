# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "6b0bd6472d1e5be31ea0c6a7c6ef086c3abfc6570fdc25abc3c89117c1871cae"
