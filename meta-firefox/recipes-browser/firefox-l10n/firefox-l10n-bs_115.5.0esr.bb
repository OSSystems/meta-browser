# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "81a2cafda765ca5a7ef3086b1ef7ef65"
SRC_URI[sha256sum] = "ebdd591fe51305ab8b48bc7d312281c78a8a63d2a8d6f9627c81c07b874987b5"
