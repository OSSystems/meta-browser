# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "34a6346adb76fd7afb3c5c77fcce78c9"
SRC_URI[sha256sum] = "7239bf09ef59364f879419112f858213774d94aad07cfd1a8c67294999cb3805"
