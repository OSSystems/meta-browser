# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "f6d8de9a2f227d597c7948809d619bcad2dd867cc8afa17e2e51d54606376a33"
