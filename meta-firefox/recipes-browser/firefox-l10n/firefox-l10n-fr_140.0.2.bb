# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "096de7dc5be0772aecce7b21bc9a5937"
SRC_URI[sha256sum] = "9176d92e70a2f8bb805dfa007a3af4be1e5cb5c2db9e63a3f4d5cf5c7f4fa0b9"
