# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6b510fca4463c17da75e2653e4313667"
SRC_URI[sha256sum] = "82906ba9f6ce2294c39eeb3f1d49e583784953937591f923d5dd2328ec50bf79"
