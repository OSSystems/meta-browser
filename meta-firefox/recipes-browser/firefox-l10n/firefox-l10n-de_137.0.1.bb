# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5cf4c8725437a39f53c4cc36219cc41e"
SRC_URI[sha256sum] = "fd6a4ecfa8abc30135b208c13fb1175232d6b10149aebd6f4617f96b861ada5c"
