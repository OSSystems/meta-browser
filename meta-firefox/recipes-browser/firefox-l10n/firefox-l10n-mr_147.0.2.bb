# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b1fb3eea78508f7673066a55c1d6fc53"
SRC_URI[sha256sum] = "674bf186ebbd0d3536da79a3a2a8f0977a88b2d0c55e9cb07577b8f216da66f8"
