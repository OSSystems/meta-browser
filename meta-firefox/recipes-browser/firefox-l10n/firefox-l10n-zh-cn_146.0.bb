# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "19d2c92b8c29de1813a28a13e6f04c25"
SRC_URI[sha256sum] = "b00edf1bc25dd2879f5426d2a137517043199e79ca80a260f0dd1c572bb502dd"
