# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ac81acba9bb47a71f67776e4132a43f"
SRC_URI[sha256sum] = "3ffec8cdf57cdf92cb1d6770d31332936cb2021dca23929e316a3109acdec460"
