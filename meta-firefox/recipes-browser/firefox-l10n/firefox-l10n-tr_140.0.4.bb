# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "241525bc63923508c4642c8ab04b0781"
SRC_URI[sha256sum] = "bf520d73588f38d2b1e8896fe814ef07bc57656044510637b3ad8d827ad83eaa"
