# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "86e3fe673f8b0bec37c6f87c9f5f4059ac4b95869985881fb2f983d8c43e9594"
