# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "05f8c5b87b84fa08a282c9553dba8b46"
SRC_URI[sha256sum] = "91cbf9c79414fba10b848865737946b03dc8dde3bc587bb7e6a60526e7ed4f33"
