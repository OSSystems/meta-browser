# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "57b60a9fb6a3d4165cc0e02105ff3dc8"
SRC_URI[sha256sum] = "6664685451df9ac9fe4c93a096ca45985c7a32a5a2766e8757e3e734dbf3f892"
