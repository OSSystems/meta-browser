# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "438b46953ea9619102edc9885c44b66d"
SRC_URI[sha256sum] = "9a192e1ebc84be4118c3fb7ef3ee712bf5860ac63e28e7ec85bd2f4c01ce8a39"
