# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "8a384acf4a498a8cc1fad00894d7cf6cc06a0417a362ca91f85b895bc6cfc62e"
