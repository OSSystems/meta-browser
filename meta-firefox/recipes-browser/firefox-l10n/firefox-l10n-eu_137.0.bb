# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "93bec468069dffeb4443701cc37f421c"
SRC_URI[sha256sum] = "6a9224f800ca51ab98b62e59bce55be4109cbbb2d420d818466fde4ecb2aa36f"
