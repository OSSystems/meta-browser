# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3d140a2e1b671402b1d8064ff9a6ff92"
SRC_URI[sha256sum] = "67f99452e9e4cde2cec6ca87620f199244e5323fde9f9c43306bcd3e0068c67a"
