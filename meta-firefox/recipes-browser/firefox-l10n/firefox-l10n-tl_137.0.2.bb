# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d22fc5d2369692405ab942b4bba745c4"
SRC_URI[sha256sum] = "d953167ba374ae8c70b7bbd2c6c4da5e19888de1ec1d26318151b0964dc4c6cb"
