# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e5b0832cc96ce589dc471485472638fc"
SRC_URI[sha256sum] = "a3b7a8eea31cf355cddc229843cfff4c7be0208796faa66b237d2f7d670ae2b2"
