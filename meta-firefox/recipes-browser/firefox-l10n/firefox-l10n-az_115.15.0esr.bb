# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "56bf853203131f92e35ea6d0fb62c9ad"
SRC_URI[sha256sum] = "790c2f3451063cb7bc84668716464893571dbe72897d5a65b61b632c0089fc62"
