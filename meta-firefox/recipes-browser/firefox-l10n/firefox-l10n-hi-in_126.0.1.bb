# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2b49dc194cfc1448f557c52434f03f06"
SRC_URI[sha256sum] = "08af222a2a79da410ca932051957e850d6f471eb3c636dfc25efdc82dcae7aae"
