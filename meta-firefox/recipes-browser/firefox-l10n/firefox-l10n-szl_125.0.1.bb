# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b2dbd0b0ab0f526a1ef6031b676abe79"
SRC_URI[sha256sum] = "9d89568afd64cc092e5743a1ab9d48e82955e5d7b60d6361f7e35df10eca6ad2"
