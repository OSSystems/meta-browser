# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2bda3c929e9cd279baed42138ddab988"
SRC_URI[sha256sum] = "c94fb7c5aa5b8e3331499bc9e0eebb822500d9d146d5f1e91c9a8d0844d32ef5"
