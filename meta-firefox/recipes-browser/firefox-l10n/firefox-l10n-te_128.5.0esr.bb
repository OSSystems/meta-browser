# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "69a49bf4b11f414d49d7fade8773baf1"
SRC_URI[sha256sum] = "86e1c9097876d0ca1be5bb429448b773c6c8f3237d298741cf03d41c0d9ccbb0"
