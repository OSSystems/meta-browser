# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f5d9894dfee7edd6b157069bb8846f25"
SRC_URI[sha256sum] = "0f04537dc362f85322f24f56216bafe4ec362d74281d956528c0707baf22c3b7"
