# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a5b77baf83596c4602f807c1accbafc8"
SRC_URI[sha256sum] = "9e85ce875d0dac720a7c52c8ca4d12a42d5080697b63e46407c96f9fd2951457"
