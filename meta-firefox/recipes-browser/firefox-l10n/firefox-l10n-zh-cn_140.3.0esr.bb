# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c74b1e13917b6482b02308dcc1de8a80"
SRC_URI[sha256sum] = "4d9f61aec3933df87e4c97fda09d9c728d50d97e9d16120aa0c49f20955b59fe"
