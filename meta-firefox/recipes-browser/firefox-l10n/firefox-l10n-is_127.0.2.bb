# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c83504a5a7e1961bc95ff164b1698203"
SRC_URI[sha256sum] = "03240840728939075c997a0edd74edf71ccab20b4a4860510a84fc1e5d6add1f"
