# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7b42e30d9e9d78b492aaf6833149ee1757c36839bdd1d5ead80f79c76d19540f"
