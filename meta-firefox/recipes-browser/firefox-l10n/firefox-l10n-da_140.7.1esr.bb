# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f7655bab2b11b3615fe1dc3e8995240e"
SRC_URI[sha256sum] = "de0b72f8798921e371cf334143e610243f5dead31220896669cdeb30d3329de1"
