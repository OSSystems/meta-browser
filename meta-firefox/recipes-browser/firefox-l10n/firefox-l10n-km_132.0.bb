# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "070fd31a4f1040aeb0691b81bee8a49c"
SRC_URI[sha256sum] = "942cb22d1872923c4b8e5206d572deebacb686c9e9360234c828dd51aadcaf72"
