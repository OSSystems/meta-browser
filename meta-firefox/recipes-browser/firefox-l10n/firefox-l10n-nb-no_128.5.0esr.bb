# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4971795ee17409c8696e5fb7413d886f"
SRC_URI[sha256sum] = "4855a3d884aa3af8956416a6649e77cec7d65b220997f297fe13e7c94e5e9611"
