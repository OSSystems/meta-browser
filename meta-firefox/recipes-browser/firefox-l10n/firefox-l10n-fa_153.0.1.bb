# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "91dfeb044fe44adf5bba336302d29abc58be1eb972b47c4ad30d798f86bfcb43"
