# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5f918d9b8553653a5908402d1372c1b0"
SRC_URI[sha256sum] = "f7f8595b8fd862fd8255d45aa36748de16883196ccfd1cb2c121194af310bba1"
