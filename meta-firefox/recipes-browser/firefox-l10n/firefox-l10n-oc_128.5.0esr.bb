# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1f43e1dd3d40c65a01af1b6cb3b4523a"
SRC_URI[sha256sum] = "f2c5131cd73f7815478c07665b81a96c7902a8a22fc680493195bd0396157592"
