# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "21bb89ea90b8695c5c0a2d9bb68eb9a9"
SRC_URI[sha256sum] = "55a5e1709010fe8e656ef472ed7c98b62edb41873540f8c709b3e34522dc794e"
