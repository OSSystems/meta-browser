# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b4b4f8647d268e710cb7faf5b36ad9a3"
SRC_URI[sha256sum] = "2cf9e75df52b84326af4cf88c4906b5625701386227b86adb74c0b981290f417"
