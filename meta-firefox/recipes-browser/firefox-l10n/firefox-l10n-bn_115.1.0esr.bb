# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6d9e44c15f64f31dbc21440a0e7bb4f3"
SRC_URI[sha256sum] = "d01e80b6558da5c41ffb42f3022198673fc74a9eca760a34c9495f6ef61ed72a"
