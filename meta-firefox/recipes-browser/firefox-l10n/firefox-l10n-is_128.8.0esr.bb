# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "307ea53d4fd884007b62253385f19a43"
SRC_URI[sha256sum] = "4ab069a230604bd2aa00240dcdbe878c52b6df6569bda5ea30611bac66c081bf"
