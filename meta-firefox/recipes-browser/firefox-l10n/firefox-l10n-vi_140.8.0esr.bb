# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2db2ce02aeccf5b0dd5466447cbc1758"
SRC_URI[sha256sum] = "b31031bc2dcb161db9c4cacbb17ab39cf421a0edfcff971fbcbdbe531573fcca"
