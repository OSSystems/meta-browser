# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "624921adad8b7d2c61d7c066ecbce28d"
SRC_URI[sha256sum] = "83056795d0e2ad169ced48c20e905163ac313ccee47242100cf48ccb3170fd7b"
