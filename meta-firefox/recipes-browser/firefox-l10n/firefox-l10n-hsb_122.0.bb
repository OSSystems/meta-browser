# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ae426e6bb0809bf22c4985b8789cd0ce"
SRC_URI[sha256sum] = "38d3fa07b6c2926c2d98869c7a552bdf9d64f9469cb753e5c3572b7755006561"
