# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "67c6229369cb9349a64ee62072ef3c77"
SRC_URI[sha256sum] = "8ba964944cea532ab6912096dead1b958390f078c664cb20a88d71d8f06ceccf"
