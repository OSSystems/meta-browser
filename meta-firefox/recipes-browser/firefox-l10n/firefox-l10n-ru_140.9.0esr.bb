# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f7e77a1044edac18f2f5a8dbbc366de2"
SRC_URI[sha256sum] = "cc87063e1f4d1e03acfdb0d71e7ee82b16e17bc35ccff291e1d4ac3e1925862f"
