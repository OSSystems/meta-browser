# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "18446ba65cff1f3b744996fb6efed2e2"
SRC_URI[sha256sum] = "d4aa5d5fb7dd75e1ddde93a75782ffb89e6f622dd1623ba6a40d4214f67b8215"
