# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "da5406d45058b076a86441bb5b63aec3"
SRC_URI[sha256sum] = "a7174e1af4250055b3566a746c9c9fcfac19940a73e8f0609eb81f0cb412d6c5"
