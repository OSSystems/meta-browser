# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "972da4cc0d9010ca7f1419eb225e740f"
SRC_URI[sha256sum] = "bb6139352d582ffd619e31d65d7d4d5f3d8b91452e9d0b129d02187ca779c1d5"
