# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b9a38e5452c717962fcfb2403a760614"
SRC_URI[sha256sum] = "ca606f9778dd5e744b08c61214132f71d2b670372af36b63309b21da1983c6fd"
