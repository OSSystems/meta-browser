# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a00b2e4cd35aa15b7fea66f6cc52e123"
SRC_URI[sha256sum] = "51fa2ffe53cfa6ddeb71c47c6f6cc1f1c55d3c819a663b04033532778563804f"
