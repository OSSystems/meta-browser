# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a0894de4ed483c616d2218bb62da8df2"
SRC_URI[sha256sum] = "2fb6bdef46ba2a8f7885127683676cfb56aa355ea5e1f8140bfe96fb429576d6"
