# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f98f6767d700253d3cfd44590064a6b7"
SRC_URI[sha256sum] = "dfb0626dc9a2513f5c385fb20c26553faad2117967ffe1f394f402267ec1d730"
