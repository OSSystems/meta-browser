# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d827151d82b9168c463e92044371afd1"
SRC_URI[sha256sum] = "b77695faa214004e9974956b9622b7a68f6d3a5b945769ed0bb933752ac10610"
