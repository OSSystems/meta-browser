# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ebc08d2423fadf0668d73eec188c5aab"
SRC_URI[sha256sum] = "62feab254ed4d0f19cdafa5e00b99071a57c96f244bfb26032c3420ac29dd7c6"
