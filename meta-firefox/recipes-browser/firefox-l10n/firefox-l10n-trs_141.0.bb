# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4f60afa3498fb9352e985a597f444e61"
SRC_URI[sha256sum] = "bae6727b36ac77486700d071418d0e4cc940c6c96635eb49448b5ef7dd2bfce7"
