# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ef213e77bd7042b25f2f55361d259bf8"
SRC_URI[sha256sum] = "fb10aef2f192d212b04f87d132cdd39be1cfc541ca2de9b7314be5a54c7d5b58"
