# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "115d2a445b3419a6cc1da2328b13fca4"
SRC_URI[sha256sum] = "d0ffcf23d81890c288237cce1817eec86412d22d180a3e9dffea6721e2401d69"
