# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "01f5aac77e02792fc3d857b8ef8b18a1"
SRC_URI[sha256sum] = "c30f25c5c6d926b97ba455ad8e628607a407cda9b846d7dd22c64428e51a8f9a"
