# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ae9e61e0bb4d9e95e5a05713a8e1e2b1"
SRC_URI[sha256sum] = "5f080f9245e8d277f8b2be21ecedccfc09a263e2be44183d1714dd5ce7ef4aaf"
