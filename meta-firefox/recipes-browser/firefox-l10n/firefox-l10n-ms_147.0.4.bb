# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ea33f8aecfa77e0d596f4a74272b15f9"
SRC_URI[sha256sum] = "816e6a64d607ccc7bc27cca15df0784f5f6df2c4b4309de9fa22a0a7c6e412b4"
