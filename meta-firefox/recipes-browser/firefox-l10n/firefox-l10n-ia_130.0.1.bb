# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eedc11e510b49c9e155c47a072c3a5c7"
SRC_URI[sha256sum] = "d2285f23c1290b1210edd3834120b80bb05b3604c1fa7753312b0dca3d57a2d5"
