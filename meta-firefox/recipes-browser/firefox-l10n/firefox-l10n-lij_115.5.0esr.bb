# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "af5e4f479126b433aa40cf62bf32e072"
SRC_URI[sha256sum] = "d5d4bf01833574ac78f355231e75bc2c31a5398d3c001aec72b88a7184414371"
