# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "b78135d161486b8446f992320ae22d26f8c043ceb308ab6a3950c0c2d95133db"
