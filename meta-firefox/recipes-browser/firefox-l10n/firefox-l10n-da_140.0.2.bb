# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ac0d0468746333dbbbf585ada86d25fc"
SRC_URI[sha256sum] = "967aa1c27d9d0c748897adfe4382cb6ffb1bc2345c244b41f30d7e46b423c2aa"
