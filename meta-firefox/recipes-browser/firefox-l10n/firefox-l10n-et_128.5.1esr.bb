# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9552a78ca2ca505dfb3e3957eea03106"
SRC_URI[sha256sum] = "6e3650bbbe881405a94efe1adf826f953fe44ab7977265df476c5231c943cf7b"
