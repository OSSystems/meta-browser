# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "11995ae6472b0ddeb31760c342d7ac7f"
SRC_URI[sha256sum] = "01d1f58c87dbe5d72da851a82a91e8bca6f935c94517f8f66b9dccda4c4e5b07"
