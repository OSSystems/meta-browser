# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5ac48a968b6a6de0f935aafd933f0316"
SRC_URI[sha256sum] = "1481358739a56bfbcdbd746ac9b88b9b994d7dead948e3e785b88ef0b13b8955"
