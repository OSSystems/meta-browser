# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fb3e113a623a5905a1808070e5ddf8cc"
SRC_URI[sha256sum] = "677aa8356b664328b46274a4d239ca01433686d3b7fc184e83740775d5f82ed0"
