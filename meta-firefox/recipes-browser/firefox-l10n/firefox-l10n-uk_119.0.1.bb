# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "412619fe1d8cfb53d0cd55955ad3b40a"
SRC_URI[sha256sum] = "37d6d6e17c570e4c2f79c01aab18b204208e5a97c413407535cb9baa930cd346"
