# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2603dc41ab8617a3dd0df9fc6cfc25ba"
SRC_URI[sha256sum] = "089b11502b2d835ccf8d50c22b41ecf5b823fa87911efb7bc8082eb846dca7a0"
