# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "69635b003b407dce670a56eeb6a9427f"
SRC_URI[sha256sum] = "465a1b93ee9a6b2d7457667d7b719319ce33c9d9623104ff946509389d9285cd"
