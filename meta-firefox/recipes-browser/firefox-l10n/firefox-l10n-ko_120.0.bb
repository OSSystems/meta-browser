# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7bea4f146c9ef8aed14678b3ae99ebc9"
SRC_URI[sha256sum] = "32548efafb7527c7614db18063209b4167dfb055a58c6252ddea2f06ec5fd9aa"
