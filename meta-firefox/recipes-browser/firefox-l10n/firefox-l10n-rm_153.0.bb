# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "26cbe016903d1cbe399e6c81ba843e3d8fd1020415739232404a24bb8b3adbea"
