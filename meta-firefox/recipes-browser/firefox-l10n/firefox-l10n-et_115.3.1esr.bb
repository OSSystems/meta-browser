# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "632e2227273419abe6a8eb0978b4ded7"
SRC_URI[sha256sum] = "54806b4b3aca308e5d7d244bc3763faba0240920fb1213d319dd9270fc206895"
