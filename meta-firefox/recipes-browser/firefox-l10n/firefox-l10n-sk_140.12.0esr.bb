# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "5a2adb70e86b938a283e10696f13a9cb788b88037606ae8de520a7193b976947"
