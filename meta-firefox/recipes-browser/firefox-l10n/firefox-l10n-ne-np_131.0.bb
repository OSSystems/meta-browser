# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ff5b47c0804c1bbb785594747eadc86"
SRC_URI[sha256sum] = "b40ca1b0abcae523496dc8e9b7c7ff873c412c1a75e60322eb615ef8bffbb39a"
