# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0dae6c69c1d7094ae56fa53df8458ea9"
SRC_URI[sha256sum] = "1773381658c82d984584749dcb51fa330af37afa5af68c269fb5261d61974c47"
