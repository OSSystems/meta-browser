# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "04bb973e0e854534f6f8bdc021d1d9b2"
SRC_URI[sha256sum] = "bd0359c0e83eeeb5046061786b384a57d0ab688756fb83c1faeaac54fca5d4a5"
