# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "87631919770e205915a0ce32b6a9d3b6"
SRC_URI[sha256sum] = "9152c631d65b603e6cbe23a45d6ef15089e4e923903248658ed9503b1ad0ba74"
