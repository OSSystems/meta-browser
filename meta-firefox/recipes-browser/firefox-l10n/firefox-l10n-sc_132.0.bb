# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "178fbbd784fd2442782195cf09013b29"
SRC_URI[sha256sum] = "d989944d7166baf5412cfb909ade54cd0008f580030ced82fe780ba533be8e51"
