# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7f90f6913b5f582e043f02fa4360ce25"
SRC_URI[sha256sum] = "7b2d9e02508ca81c1511f69b98281afb2b9a3a9035a738ff48895815afb9b65d"
