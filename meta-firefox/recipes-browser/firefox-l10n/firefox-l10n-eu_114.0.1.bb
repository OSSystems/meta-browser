# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "90fe2f856126c9276fa93c55c49b1814"
SRC_URI[sha256sum] = "3d7beadcb219bec0e3d5d1bc3bcee52361ce92642160dbe5ff7be35f80196c39"
