# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5087a751c1e1dc8b15e2ac808c0ce953"
SRC_URI[sha256sum] = "36c028f39c11eb564e72ce6c6592db690f9d52eedeb88808fc4f96f519703d5a"
