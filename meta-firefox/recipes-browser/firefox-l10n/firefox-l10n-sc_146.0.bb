# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f8683ac32ad4d4b551bbf42a5590ffe6"
SRC_URI[sha256sum] = "89617fda8f5984b0caff6fee47b511e15fbed13a670da3ffca320ad3d81eaa7f"
