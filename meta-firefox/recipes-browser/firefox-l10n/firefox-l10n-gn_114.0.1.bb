# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a7d42e328638025aa9aa0826584e364b"
SRC_URI[sha256sum] = "5dc556299fc6f02f6cc59c083f670f3a237ddf3a684ba00324de1aba2e779f9a"
