# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6ee643ee51e6bca42c543178a932f06b"
SRC_URI[sha256sum] = "ded1eb5bf2582f9fd975e7ed0c6a3c58eb6919cec15788ea0a61fcf416ea9ead"
