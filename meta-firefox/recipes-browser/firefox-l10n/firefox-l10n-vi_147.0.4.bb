# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3f6f67ea8553dc3e32390d9ac46bdb2c"
SRC_URI[sha256sum] = "8ef6c09cf5b87ab1d9d9a56efc90130f3245e110406f8fa1e5b43313f87cf5f9"
