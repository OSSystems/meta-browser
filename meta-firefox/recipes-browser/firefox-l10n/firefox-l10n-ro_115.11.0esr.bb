# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3ce47fa2b8e0c4fda0736fce76e22b56"
SRC_URI[sha256sum] = "020ea6e4e23bd6dcf735e62f71212d07fc2669eab54f0193146d7bcad6a79072"
