# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b081318e24762ce513ffc2537c8ee8ea"
SRC_URI[sha256sum] = "cda3a6576519fe9bcf0cf7df0485fb3d7aef36e634bfa8f6f0941c1f2dd5c485"
