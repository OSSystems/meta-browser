# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "64bb1b086284fe229efebbcb4280fc12"
SRC_URI[sha256sum] = "0220f7d631554f1c85031e151aa74639e2fe6efdfa0714d996f8891d2e115756"
