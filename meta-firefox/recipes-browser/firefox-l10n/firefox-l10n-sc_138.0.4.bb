# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "306d36e2b8227cb19b5fa0f18fe5bd19"
SRC_URI[sha256sum] = "c324db131dabe2edea057c388cb71e689afc86fb08cbd6d44363932df4b44478"
