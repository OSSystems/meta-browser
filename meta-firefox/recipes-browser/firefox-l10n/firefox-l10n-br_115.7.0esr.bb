# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fc81b8444165f30d6d2db34226869d3b"
SRC_URI[sha256sum] = "92f80a4fd6ef10b8c97288cc738ef1244d177fb640112d4cf49bc08228bcd811"
