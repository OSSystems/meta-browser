# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "100e7615493914ff4d5df0750284832b"
SRC_URI[sha256sum] = "23b89618bcbf8604dab45d3c66b9092c4e578a60557942b8c7fca5c8f3b81359"
