# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9424bbfbde2387839bfaf64ed27c2881"
SRC_URI[sha256sum] = "03881ddbb9a2f5d3c0d01062ce85df6ecf4fea502e5666c9ab32891510f0572d"
