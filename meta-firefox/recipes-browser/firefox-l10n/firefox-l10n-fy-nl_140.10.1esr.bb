# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3442113e08211e7dc143acfc111c4ac39ce2de56a1a078f6be32f080a2cbad70"
