# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c251b62f0e181114e6a7a21ba93c63a4"
SRC_URI[sha256sum] = "fe9e296ca65d4fdf2182aeebb7544484db305c79e2b7a45be4d83aa689673f38"
