# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f2510c207b3bb45a1979a7cceac7fa49"
SRC_URI[sha256sum] = "1ae55320a2df2cc5e911625b939974988edd6adec8936c5dc7de32938104c146"
