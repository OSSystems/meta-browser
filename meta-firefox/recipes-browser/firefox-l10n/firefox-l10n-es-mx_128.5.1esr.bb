# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6b5f79f404925d2c3a2d13cc7b275d1c"
SRC_URI[sha256sum] = "11bf0a077eb4415bd531ee485a94b934bd5a3c8fccd62608aad498cc848c47bc"
