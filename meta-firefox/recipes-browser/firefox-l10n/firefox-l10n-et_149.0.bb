# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "13536620e9d225f34742cf9c642a5852"
SRC_URI[sha256sum] = "1c85a5a04ef9ce15803e3c3797e4b5494f9a942fc0689af6e72800d5d6e1ec9b"
