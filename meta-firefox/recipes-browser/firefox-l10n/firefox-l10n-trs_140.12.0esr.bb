# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "5b744e72e449015ffdbedd44a2acd3220482d52476e2390f17c5ae36e54e1cfa"
