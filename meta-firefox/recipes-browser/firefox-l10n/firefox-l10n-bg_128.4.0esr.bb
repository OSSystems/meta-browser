# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c2f6e548941e01b9d940b5000eea6c63"
SRC_URI[sha256sum] = "10193a68521724b3374314287d53442063708d594b3dd27c378fae986a235c9b"
