# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4162e00b38dfe6e62098ae4a24c89b07"
SRC_URI[sha256sum] = "a738477512f0d9036d04d37dfbdbbcf17fbcb3211cbe1c02cd907a0f6fddfcd5"
