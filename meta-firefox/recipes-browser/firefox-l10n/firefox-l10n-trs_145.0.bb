# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aceefccad089503e8e3215c16ceabcf9"
SRC_URI[sha256sum] = "5f26c96fc15635c6efb940dff1e75a06e7826065484b0be70eb3e3499f5c8818"
