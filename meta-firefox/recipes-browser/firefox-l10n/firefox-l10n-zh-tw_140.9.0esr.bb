# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6e0141de8821ba59a0405757672c6d83"
SRC_URI[sha256sum] = "5b0ddf222ba1fb819442f03aa8e9175e011f0a7a706072ab5c135227b164ab8c"
