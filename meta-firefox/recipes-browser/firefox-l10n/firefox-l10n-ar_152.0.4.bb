# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "4cbdf4aece3ed166e365e580fc05bcdfdacd7e7e309ef67759090231a91e5284"
