# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "03c0ba7f738e228bb3318d24167fceab"
SRC_URI[sha256sum] = "0acf7e2924781913e5599ce26090ed49e1a6fe09d6574fab48ab4a17ba1bb974"
