# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "be5d2b1c29ab4e0f77bd67c4fe96fcd9"
SRC_URI[sha256sum] = "1b00e45d398ce048fc7ca1635a17e9db2f03cc739370cec7d8b5040a4d677246"
