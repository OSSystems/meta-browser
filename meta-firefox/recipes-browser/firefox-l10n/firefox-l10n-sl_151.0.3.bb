# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "b6b80fca160e2d70c05b141857f3e4676b59a2793144ca8b49e8df7636ff2d34"
