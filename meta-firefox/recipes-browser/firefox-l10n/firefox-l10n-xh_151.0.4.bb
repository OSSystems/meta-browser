# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d4b2fc75c2881837e63e9f3e0ab1ca95a4a23d8728ecc94b81d6a8fd6ff06671"
