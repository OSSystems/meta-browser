# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "bb728d9b5d343899a50d95b32879bf61c648200e7e087b8ee2dadcf1c11e4bc0"
