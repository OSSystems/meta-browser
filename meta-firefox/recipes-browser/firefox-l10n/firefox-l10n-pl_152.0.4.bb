# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "53dd6009dec6323d538ffb6dc994f7a69e6ac4514ed647ce69e70bf409e1c1e8"
