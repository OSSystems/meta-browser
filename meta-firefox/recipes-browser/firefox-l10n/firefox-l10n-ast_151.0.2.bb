# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ba616511e0b77444c32b1952672f4819f6bc3ad81458f418c4744a1cfcac1969"
