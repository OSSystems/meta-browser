# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "13d9706ddd79ad79bc4195c970c36936"
SRC_URI[sha256sum] = "fae13957aed563f750f7b85aafc2e0a7e12eb02c62aa30867dfe600bf7d64543"
