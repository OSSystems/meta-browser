# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0cec5d41c046eb29e40c10c82e87b4f4"
SRC_URI[sha256sum] = "30c0b72fcd35a909e6300628be240ae1fc5f70c02ee5861e696adb5046bee63a"
