# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "75ac102bd5e80296c3bf2443f3034fa2"
SRC_URI[sha256sum] = "70a5876407fe3605ee0511d98918b526dd9edc608c602373e9682ca377525678"
