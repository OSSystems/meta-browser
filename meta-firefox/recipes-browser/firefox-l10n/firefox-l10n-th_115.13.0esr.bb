# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "584334c42546a0797872644724189005"
SRC_URI[sha256sum] = "4ce6550334741450c1dc3ea3bab971dc83156d632a4a7415c5a99fafdc7626d3"
