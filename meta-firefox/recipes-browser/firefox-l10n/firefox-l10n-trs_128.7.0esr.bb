# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a0a985f860dd15e49778f374d5ee95c7"
SRC_URI[sha256sum] = "aebc22953125489e636bd50beff3bd28e8559e37f05dfe4be23470aa82c9a9f0"
