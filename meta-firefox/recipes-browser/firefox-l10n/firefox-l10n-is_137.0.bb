# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5a8719c3709f53f2089bd267d63b689f"
SRC_URI[sha256sum] = "a1e1d75b5d2a1d10fa63ec2e94344a4e37cf8cb500702cafeccae8c85a454e99"
