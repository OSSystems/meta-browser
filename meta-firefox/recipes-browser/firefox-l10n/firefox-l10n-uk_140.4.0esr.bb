# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "66ea2f068d4580da2195c0e9b63f979e"
SRC_URI[sha256sum] = "12bbe9e54d9304a262d82db621a548150dec2a0b04bed44758afec7ead04e07a"
