# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "94ab07ee98c63256784c3cb85a956537"
SRC_URI[sha256sum] = "e973dca25dd450e92fd60e8529795644266473234b9ffb436f12344e2396ceaa"
