# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8b1a1803358ee9afc05115364be35307"
SRC_URI[sha256sum] = "f9350301aa37ae85c6647586be71bad885e7189e43e39fc8d13b5721e9c07c4e"
