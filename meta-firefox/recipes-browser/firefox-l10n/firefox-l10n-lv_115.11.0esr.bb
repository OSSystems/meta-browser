# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "347e3d47a2cf6ca1047b6b77780826a8"
SRC_URI[sha256sum] = "e3ea0000312da9c21e06bf31f3ae53c85bec5960384fced5c3ab2f5c7de8a609"
