# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a2cf84ed65295e7326110347f1d9b42f"
SRC_URI[sha256sum] = "b25710d1db2448969622e408d4fbe2ad1633303716206d09ca7ee6cd414aecd7"
