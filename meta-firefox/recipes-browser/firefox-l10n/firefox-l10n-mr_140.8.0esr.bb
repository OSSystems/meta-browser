# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d7909ae93a13ff99d1bb6b369b6c7a1f"
SRC_URI[sha256sum] = "5ab33201445cf0d732a74f9455ab291ea8c46a9864c1ec4694996c8ff25ed23c"
