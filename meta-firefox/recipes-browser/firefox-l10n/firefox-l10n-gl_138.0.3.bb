# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3ed6b68fc83e8ef69b7a4f4f553bab49"
SRC_URI[sha256sum] = "1e615fcbf995891f01f604012bf5788474d66b104b790189f4ca3c979e1161c0"
