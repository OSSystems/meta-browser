# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c57ee2ea1d2f7b683d5505be61cb3d76"
SRC_URI[sha256sum] = "2a9af28024c3d6dce91ccfc620c41ceaee2bfbcfa08c8d137e7842179a5ecda7"
