# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0b624e5a48b23a14c4549e60b1c694b8"
SRC_URI[sha256sum] = "b215c85572ccc9a8a71c42658d181cb292226ef5b151b97364273c430ae65e99"
