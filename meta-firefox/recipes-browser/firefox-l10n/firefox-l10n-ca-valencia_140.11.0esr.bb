# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ba4ddf62165f651e70a9c92204dcec70a9d5f8d8826cc98184218790b3f11bbf"
