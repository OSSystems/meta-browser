# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5fdc67b467e84d05598f34513ccc4c79"
SRC_URI[sha256sum] = "103f8657963a15b8ff89bc3dee006ab57c9858589ce46b99e82c30b0e108cedf"
