# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f71c1167c1d9aa61c2cede251c5c40c4"
SRC_URI[sha256sum] = "1bb8a8e5b9ad742e1e0a621d875d69f408876eb808c52ceccbabb5e2c88f8d42"
