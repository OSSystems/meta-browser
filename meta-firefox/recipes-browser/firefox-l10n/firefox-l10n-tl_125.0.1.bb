# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d6790ebbc3e0dbef48899f618343e8cb"
SRC_URI[sha256sum] = "4839d36ca2c0bda5d25620e0fe95cb8cadc6ba5ea211b957c9da46757c486543"
