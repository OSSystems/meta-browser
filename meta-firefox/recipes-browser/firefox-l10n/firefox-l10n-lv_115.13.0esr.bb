# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "30237a04b27358590f2bf2abb0a20524"
SRC_URI[sha256sum] = "cf2f41cf4f6d6c3d09fbb707d93ba890e3529065d02b10dc03307e240d1ec80d"
