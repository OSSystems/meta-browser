# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c0ea48dd495f71338b8061b2a140e009"
SRC_URI[sha256sum] = "c392cd18665f50a9aedf0b6b8888ffe23ded061572359be16b724b4ac6e6e2dc"
