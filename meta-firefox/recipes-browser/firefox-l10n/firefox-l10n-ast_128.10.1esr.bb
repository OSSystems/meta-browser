# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d3f162a79dcf7b4bb1a3b1aae06e2545"
SRC_URI[sha256sum] = "6dde2303b4d76c69a7724ab62444cfb0e75565645ec5f22761ef4766870e02e7"
