# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "445070c796892fb2d40d76dcd68155b1"
SRC_URI[sha256sum] = "3b6500ba60738c6db5c73e00cf2fe7e5b3bc445a6813ecf2d959ac729325ca9f"
