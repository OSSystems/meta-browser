# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2e4cb2e3ce804b10197dc8f0805a2f0b"
SRC_URI[sha256sum] = "f95f2a969ed1baeb1678516bcf87adbd811101eddfdb8dafc99a853b59a21dc4"
