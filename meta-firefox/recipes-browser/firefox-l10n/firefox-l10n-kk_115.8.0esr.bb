# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9b8ff26fa9fe06a516b2ed5122919298"
SRC_URI[sha256sum] = "12e77c577165295abcb380aff668b8aa2dde6be78dd6067a84ae03684d71c30e"
