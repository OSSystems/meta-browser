# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5eb561de161e798c2526204f45f3c9d8"
SRC_URI[sha256sum] = "f5bcd5c1d931f1d8e79ca07ec84037fe756f1ff98f7cd310d248e195d74f50da"
