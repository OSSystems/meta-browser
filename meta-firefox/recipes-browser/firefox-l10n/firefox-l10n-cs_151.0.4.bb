# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "013dbb6cbc0ee0dbd92ffd696d581cbda9cb8d4c20a9f8be13c319381ec66b53"
