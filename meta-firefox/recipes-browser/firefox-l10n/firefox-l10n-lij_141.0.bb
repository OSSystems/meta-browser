# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "98230d76d579cb8840e403898c1abd30"
SRC_URI[sha256sum] = "925a52a2878f7d3669cbbf840a7c8f33ac4275e4bcd4a0e874a0df1a4ce60cf1"
