# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9bc44b3220b9ad68428e8f84e2cc96aa"
SRC_URI[sha256sum] = "5b158f3d7db2bf3072dbb994ac622be0d0cfcc5cd630a17ed1d508a27b302ed8"
