# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dcdb88de5bfe168335165040c858639e"
SRC_URI[sha256sum] = "e5f666b9f4b7e247d2de21c63cfb98d9b3ebdc1ffa67b51c5a29a03d8089996b"
