# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "55b3cc4bbe1d8657878c953d6de942f3"
SRC_URI[sha256sum] = "29e91022d99ea3f3dc4f09e1d4c487bd3a623012374918884a1f9d989ce8eac7"
