# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d79e293ac7f2275d1a4803959fddd734"
SRC_URI[sha256sum] = "9269d3cd03847e90923e4e42b68a0f8a2000bf964a79206aacb0a0a70376e09c"
