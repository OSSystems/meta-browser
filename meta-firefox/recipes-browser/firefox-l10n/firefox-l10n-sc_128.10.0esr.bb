# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "66c39f7f34200030b9b1145bb3096820"
SRC_URI[sha256sum] = "acfe3fe88d37d92ab65318d561b63b12585bcbbc8a76e7c96e2e65a5ac10ba5d"
