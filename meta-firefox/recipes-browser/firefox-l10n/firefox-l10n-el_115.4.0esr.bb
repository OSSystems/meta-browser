# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d5e95a808b2ad90d9bc74993763f52b9"
SRC_URI[sha256sum] = "5d5440cf3eb2562d08525d87d038fc295aa3c96d70e3949fb6335261bc7c049d"
