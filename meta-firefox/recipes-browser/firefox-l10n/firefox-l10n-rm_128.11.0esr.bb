# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6ab5015a839595f363dcb736627fecd2"
SRC_URI[sha256sum] = "e9e187e75e05eb8bffe35f6c79ba5643a0f3cae52f87db89ed35bea119b5766b"
