# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f51fd984bb8bf44e46e8bef14a8cc7fe"
SRC_URI[sha256sum] = "fd8266145ebaf5b3d3898e1c3e9b4dd4b14dd12ea35142ba3cee6d537b2b2875"
