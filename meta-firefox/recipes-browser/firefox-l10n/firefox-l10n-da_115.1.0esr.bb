# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "df3764f4092de266fc0b3d2fbaa37e34"
SRC_URI[sha256sum] = "b1022ff353f73bb3dc5512375ea5a17313edefce131eb4283d9240234f85f56b"
