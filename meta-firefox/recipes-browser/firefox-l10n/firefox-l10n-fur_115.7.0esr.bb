# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "60cb4ec300e9868fa7a657ee88a27f32"
SRC_URI[sha256sum] = "646d2f2077bc2773a95d193b0bd6da57d2f86cab60a19928eb959f50320f49b3"
