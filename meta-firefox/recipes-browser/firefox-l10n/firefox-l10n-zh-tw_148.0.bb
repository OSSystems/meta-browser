# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b1b7d9bb4d3860ff93192cdc4cfea00d"
SRC_URI[sha256sum] = "c88befd889abb68b074e5b37a13d042fde2864020f45666271eee986a6617ecd"
