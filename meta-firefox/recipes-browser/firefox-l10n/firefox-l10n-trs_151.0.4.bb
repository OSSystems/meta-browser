# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "37d1358efd84829ba7eb5fd7ee2a74cbd3dfde3d714bab61f4c1e9cbfe0975b6"
