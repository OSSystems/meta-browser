# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "787bf9e02905b529ce5c60b49413ab67"
SRC_URI[sha256sum] = "90312561476334528f7778f9d68e831839a382abead6f49154558183d5e0c239"
