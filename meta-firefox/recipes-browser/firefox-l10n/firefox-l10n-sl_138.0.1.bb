# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bf370261f3bafed0fbb31fae4c4f085f"
SRC_URI[sha256sum] = "8a50ef49d7fd1d2a8047b3eda6eeb17f938f4c671ecb77aad2092a5d3c22c68e"
