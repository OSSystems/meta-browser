# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ebbb2f38f0b4fe741358c573ef0435ce"
SRC_URI[sha256sum] = "daa99430c77eabcf81abb4e1b2c19b85b433917cb234c9ed53a81b86124ab268"
