# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a3bdbb9c171a21a3aa97db120bf63ce9"
SRC_URI[sha256sum] = "c51e2e05002e8e1600e42b63223181220b1195a1ae8325892d9a4f2dbf88c980"
