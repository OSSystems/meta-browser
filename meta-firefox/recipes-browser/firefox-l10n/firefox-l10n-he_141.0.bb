# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c726e4607b55dde04869eb4b73510b95"
SRC_URI[sha256sum] = "46ea9b23b56735fc68d9640a69a5e3862779f08ef140e0f15a1096a1898adb02"
