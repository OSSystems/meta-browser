# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c77efc9d41f9c4e863eb176a94888af5"
SRC_URI[sha256sum] = "6b2eb485ade5d200253ec970b5be568dcca6be50b7589d068ae24c4106898165"
