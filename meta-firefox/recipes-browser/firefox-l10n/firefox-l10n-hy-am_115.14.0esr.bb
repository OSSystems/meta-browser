# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0b7a2d95837ca45b2e2a1353541850cb"
SRC_URI[sha256sum] = "22ce2eaf4225d5969b6e1ec2be205e5bc5375f1081cb397a011e74d5547b87f4"
