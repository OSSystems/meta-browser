# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f40540bc8c730354f0f2871aadce9ce8"
SRC_URI[sha256sum] = "c4d2f593bd7b5fcf691e3447fd60fac70111ce6a43376e53be4973c6f1adcf36"
