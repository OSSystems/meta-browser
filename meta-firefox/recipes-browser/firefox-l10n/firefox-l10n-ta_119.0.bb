# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fcab262b5883a5a9e263ac6d53cba711"
SRC_URI[sha256sum] = "719e8db0ed030248615ff388286fe7be9d5d45fbc4cab381517bf88a55e96ff6"
