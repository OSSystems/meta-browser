# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d49a786e3ea83b022ff878faf4963217"
SRC_URI[sha256sum] = "97bf2ab7f61eac5e30ab37dd02e27732ae9e7715f565863d28b403b982886fd4"
