# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "896d4c8bbad63b9f7c0f9b53c40baaf5"
SRC_URI[sha256sum] = "0089445272a1e1807071a7242d038f37036b91e5b0fb909add2acc4c9a583590"
