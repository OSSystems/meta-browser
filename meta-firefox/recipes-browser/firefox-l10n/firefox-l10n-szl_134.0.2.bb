# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "50e4eed16c0a00dcb81f2b29b6fb8d36"
SRC_URI[sha256sum] = "f1918884ffd98bbe0e6d5c65b752bcbe52373e0ac18374d442e8826c5460e492"
