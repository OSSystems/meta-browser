# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d28f05ae9ed951beb4a4b7eac24b1982"
SRC_URI[sha256sum] = "bf5c89e2e6d9528c547ce1b743797b8109d42dc5c189865a349d6ad5e3dbe65d"
