# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f9aa90e966e671b7a911f88932874b53"
SRC_URI[sha256sum] = "6730d818cc22a9e48e7d1bbeaae2b54a0f43b66990bbf51021435efc9a6a8ca9"
