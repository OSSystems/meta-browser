# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2009707b6db27c340547de14678e5391"
SRC_URI[sha256sum] = "f7d9abdaa8435d4c70f62072eb5ad29902177b3a93c9150a57b862117526580f"
