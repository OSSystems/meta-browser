# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "aeb8dc3bd4bb5a7f26aa8e85e466e626666a50aa54536294da1ffab5b701e6e4"
