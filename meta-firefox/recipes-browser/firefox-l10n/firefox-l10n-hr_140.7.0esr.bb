# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "219d8ddfb72db474751c669122c32e7c"
SRC_URI[sha256sum] = "7ae0bc9801308de9863d653b7f8a92500e3b294785eb2ac5e77ffc163e3f0d67"
