# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fca7db7233570157438f9a8e690d13c4"
SRC_URI[sha256sum] = "dbe4fe7a9022d2fb65d9f7e6dfe9fc2f35839a9864cf981dc223114aa1f685cb"
