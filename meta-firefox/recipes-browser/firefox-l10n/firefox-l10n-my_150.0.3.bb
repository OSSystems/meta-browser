# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "20dc5598b1ebac98434e1619d489bdb06f210290bee59bf307d40aaf47d41e97"
