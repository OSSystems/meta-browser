# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3ee5738fc1781f194a22e493e1c6d00f"
SRC_URI[sha256sum] = "e5f37a39e77f748ddf23ce936f66a671734f6f8445ba38b27e627ad1024ed31d"
