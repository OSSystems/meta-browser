# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7e65cd753e01f587fcac0c06345ed13a"
SRC_URI[sha256sum] = "70936ccbfdd78b08f8af4e7fd6a5195f49f41f050816fca336289ed7108776a6"
