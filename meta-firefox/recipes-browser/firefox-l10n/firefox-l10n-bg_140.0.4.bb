# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "13fcbec3bf843c5403b2424953aed82b"
SRC_URI[sha256sum] = "6409bf41f9d6466aa694da9418d89b35f218934463321dada264a64cc7cddfac"
