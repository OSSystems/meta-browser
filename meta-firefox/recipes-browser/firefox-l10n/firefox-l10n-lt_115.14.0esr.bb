# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3fa754cb4faf85a9002083b9ca8ee1ee"
SRC_URI[sha256sum] = "9768da8bdcf346da88c8b3b2077b535e699590e1f7334809c6d12262a8045437"
