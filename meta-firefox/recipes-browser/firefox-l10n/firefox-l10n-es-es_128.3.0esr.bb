# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c4d8d6fa2625f847228e7e38c2534618"
SRC_URI[sha256sum] = "4974388bb32ad2b70b5dcf4aaf71212d164f961725e10c81ef83f9aa0554a7b7"
