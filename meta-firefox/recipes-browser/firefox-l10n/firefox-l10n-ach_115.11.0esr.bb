# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "da2260b2e88ccddac2a9c31fbd392552"
SRC_URI[sha256sum] = "eb5bdb3cd1f207f4cc9a03e11ce8f6f3a6aa52828794c60077381dbec7811052"
