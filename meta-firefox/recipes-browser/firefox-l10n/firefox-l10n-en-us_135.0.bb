# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ae133419f0aa565ace5b35988ad67d5c"
SRC_URI[sha256sum] = "dafd4d59a3ae233ac7f641bd4c1fe88b2ab375bb1c1b88c7625d9d2a7f37cfff"
