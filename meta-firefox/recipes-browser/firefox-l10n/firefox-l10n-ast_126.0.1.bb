# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "09d9e59e2db4864e7fa415458dd9b21a"
SRC_URI[sha256sum] = "dd711267edc4c3ac1185f244bf2a0f918155ecdf940b63250aea03c44110298d"
