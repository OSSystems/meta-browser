# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "90ffd69751b74acb30dc787d94851114"
SRC_URI[sha256sum] = "ac59a16058d33e253755fde3f4718b802b10ea585496b9191514640f0a00ef4f"
