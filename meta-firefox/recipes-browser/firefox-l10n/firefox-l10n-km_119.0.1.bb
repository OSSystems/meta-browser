# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9889dc118aa2a7345aae8db62db038bb"
SRC_URI[sha256sum] = "66fba990451a6b3125a4985c05ce3e277e09d023c77351c46ff9cdf07f7c9d5b"
