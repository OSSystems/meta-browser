# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "10ccf87647193ff724bbf9fd99e476b6"
SRC_URI[sha256sum] = "7feb7ee2a457c776f3b7b8e6ec89f5107ac7e870b4239999d2376645818e8699"
