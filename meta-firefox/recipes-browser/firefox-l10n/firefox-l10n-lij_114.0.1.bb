# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "33cf6b9e65b9f711cd1cfe4b899c7646"
SRC_URI[sha256sum] = "7d478b0fc279f54138c7372165163eb6d1f96d10a4f0a764cbdfd607e907120c"
