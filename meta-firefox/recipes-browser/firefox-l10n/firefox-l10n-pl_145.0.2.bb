# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "11060aa1fd9d8052fe8c632e2f04cdce"
SRC_URI[sha256sum] = "6838678fe9832f784ec15539e435d7f7959bef6bed7aa02dc8de830a58133317"
