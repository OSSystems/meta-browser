# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cb2801d605996d98023fe38679a3a97e"
SRC_URI[sha256sum] = "a4f12299c712f44967842ecf6b9c5ecfb8cecb167cd520efae10a6a0620cc792"
