# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "64554f82e91ab27545c14370c7abdec9"
SRC_URI[sha256sum] = "aa49949afe47642cf7b7de6c5f14608ceaf1a04396080b360e964da302809c30"
