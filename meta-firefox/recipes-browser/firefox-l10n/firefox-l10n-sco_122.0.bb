# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fbe4bf7ebb6efb6310eaaf5c69974359"
SRC_URI[sha256sum] = "2666c782b1eb2df142dc8f2c468e73dc7872350c079c5f2b830fe5176da5b548"
