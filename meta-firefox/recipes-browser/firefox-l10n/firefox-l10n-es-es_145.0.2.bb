# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "338db4c4fa742a14aafa47358a4c5746"
SRC_URI[sha256sum] = "826dc1da2c47ea971ce4a936f7f1bea3c9892b67b82e7c0bc9cd426644b6ed10"
