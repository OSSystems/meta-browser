# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e776db5b54e1f8c24e4d050d5fb278bd"
SRC_URI[sha256sum] = "63568b5d4047b6d5eeb20eb6d577f5e23142f02d61f3582ecb42fb35bf8c7eed"
