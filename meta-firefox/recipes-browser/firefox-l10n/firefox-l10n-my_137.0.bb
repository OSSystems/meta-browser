# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a168d8bb5f954ca5f09e61b9de9c47b8"
SRC_URI[sha256sum] = "03a45300d7ad724324a5ada17734c49d2b09737b64f8cd78c777f3a203286ec1"
