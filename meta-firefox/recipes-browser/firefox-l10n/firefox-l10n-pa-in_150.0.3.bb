# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "9222f6e2d2cbcee45271810dfdce9efd26338f0e51182c6256ed9ba6aecf19d7"
