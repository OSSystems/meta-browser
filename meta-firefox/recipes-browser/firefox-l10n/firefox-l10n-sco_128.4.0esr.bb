# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "81930e1722ac97a891534422fd0ea5f0"
SRC_URI[sha256sum] = "40280f899335d651f0a8801aa3bc0a6acc9997ed33dc4f091be3a4287df84877"
