# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c9f07a28270733da7728c9603c971c59"
SRC_URI[sha256sum] = "071a88a57452e6851d53cad9ad8196f27f709d220ba2dd503c4d8829bf38b052"
