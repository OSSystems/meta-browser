# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6f23cd50c76a82509b7841bfaf4438f8"
SRC_URI[sha256sum] = "99a868f7738685074f49077591f9e512b49b400528767cbbc7feb609ea8cf122"
