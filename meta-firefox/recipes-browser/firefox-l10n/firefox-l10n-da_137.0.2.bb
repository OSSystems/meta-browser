# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bb9d2c78b171d9cc87f14ef6e3529f87"
SRC_URI[sha256sum] = "433a3ea99f2307358fc105dc7bc931b51f7ae6b73c71e14b2dcc71d60d7264fa"
