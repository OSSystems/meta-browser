# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e60df7fb6c33fec514196e2a038f28a3e7a21e8801deded8a1ee2fb16109efdc"
