# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "59220e4c69a3c29d57cc57fb24cf0e43"
SRC_URI[sha256sum] = "2f7c9355d22923c697e5b2fd97d5d78ca9015b4faf15dd82ddc7949ac8261a21"
