# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aab8d015d7fee6c65685fb24041193ba"
SRC_URI[sha256sum] = "187e18da67b1e520e791454343c186c15e0fbdc8d0d45cd192dcad17db32f01b"
