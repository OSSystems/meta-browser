# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "68c42fe080d2649b26334e0f9cb7defc"
SRC_URI[sha256sum] = "a31b10bc0f69f2f364db25c80a3bfab88e27e8beed7e4b2e432a7ba6c60a6633"
