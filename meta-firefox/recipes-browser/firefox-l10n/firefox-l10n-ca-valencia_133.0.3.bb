# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "76473bf9f177b6b3167b195ab8f8d336"
SRC_URI[sha256sum] = "d5992a204d5665c14b092c3e5ac85ee4497483fcf2f755d00b40a791c121c52b"
