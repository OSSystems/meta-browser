# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d20263f4f99a0998167054615dac21f3"
SRC_URI[sha256sum] = "18d5ef290f9558bf7b9de9e6876e630e620234d4883b09bd407d9ce3c454077f"
