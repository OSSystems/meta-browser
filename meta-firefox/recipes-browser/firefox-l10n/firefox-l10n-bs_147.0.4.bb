# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "04ca2c33aeb3c48245c9e181b6f92baa"
SRC_URI[sha256sum] = "28de4e14c1e814fd095beb87af73628676bca8af52d63dfe66658328d35f7e2d"
