# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "49c25dfd80c90efa4ea648a40e752415"
SRC_URI[sha256sum] = "afc7841145fa9d453f2f30a6fb998383dc39c9b412412a57b7cd361acd9a4edf"
