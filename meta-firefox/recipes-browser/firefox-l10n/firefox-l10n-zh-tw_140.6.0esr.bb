# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1843e16a5287bf363cfb78db74146806"
SRC_URI[sha256sum] = "a033c9dba21da271b7af555b78d87d5f3d3b2f312b1b5e86065120da5d37c8c7"
