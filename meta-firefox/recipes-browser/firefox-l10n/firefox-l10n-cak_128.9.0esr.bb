# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4ccad4a1c4ff7d9fb50e4cd24461678a"
SRC_URI[sha256sum] = "3c9a2c2a7b636956dc90c346716d9000d7d812a149ee140fe24222e5264222b5"
