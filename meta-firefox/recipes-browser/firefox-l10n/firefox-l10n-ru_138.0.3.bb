# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5cd0175bae08de72bb2ea2eed676a501"
SRC_URI[sha256sum] = "fdd67fecf411b93d95608e9c37b7f7035e31cffe8aa4887169183cd087589f48"
