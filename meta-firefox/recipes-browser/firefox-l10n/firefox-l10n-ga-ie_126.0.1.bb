# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8ae89869d3c1bfa13241ce80882a4d07"
SRC_URI[sha256sum] = "c5f3aa93750afd3975ad8c5057d63ab65d73a53a4f9be25304064969e15846e5"
