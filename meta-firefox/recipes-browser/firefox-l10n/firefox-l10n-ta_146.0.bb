# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "25cc37036ae9d6af772e2afbace3fc3a"
SRC_URI[sha256sum] = "ccd0af4e30e8ade2b0fb817b9fa758afa3248cbb110527820d415ad5ab1386c0"
