# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "189818bfd639b9e22d9770f89b29c490"
SRC_URI[sha256sum] = "8739c2a03b24bbbef0d8a014c1e6971960d88343367995713a7e7055afbea6ca"
