# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ca6b5883e58357e7a6ecf6c34538abba"
SRC_URI[sha256sum] = "37bcdaa5f59f4885b2b13e4ae04564a084e6d6f1b5af1a389946259179e813dd"
