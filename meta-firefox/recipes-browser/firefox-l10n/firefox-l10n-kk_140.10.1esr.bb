# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "af1622a8d96f99e239d1a04222e38a1da2cb99cadb72a43e90cd5275419c22a8"
