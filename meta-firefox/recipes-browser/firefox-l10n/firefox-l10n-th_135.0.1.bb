# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f45e97ed98ff0280170d0e61873a3e8c"
SRC_URI[sha256sum] = "a7b0dbbf61c05e4d75cda34ed3ef771881811e3be53a204c0f717d2892eeea8f"
