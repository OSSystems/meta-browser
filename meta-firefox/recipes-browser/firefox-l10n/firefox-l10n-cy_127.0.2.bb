# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b2a89f62d6b16d28eb9aa0009ef121aa"
SRC_URI[sha256sum] = "3b2fc888c8276a2df78a8185c2de90d2d223192b68dc5035985ff9ecbf323b75"
