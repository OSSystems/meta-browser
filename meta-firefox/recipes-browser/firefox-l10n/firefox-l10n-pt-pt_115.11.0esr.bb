# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "74c53edc3036a57157ecc30f05e8bed6"
SRC_URI[sha256sum] = "c80c2056f8acacad60046e7dba8c531238632493909b8bc8fa61ae9fff7c57de"
