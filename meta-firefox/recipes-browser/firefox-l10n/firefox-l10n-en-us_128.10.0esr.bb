# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9a3a03ea110988cd3849e7db02fd77e7"
SRC_URI[sha256sum] = "5a1ce39012081ded4be3f8df67f6148589be070e4be9cf29d871cb4a8c9dbe23"
