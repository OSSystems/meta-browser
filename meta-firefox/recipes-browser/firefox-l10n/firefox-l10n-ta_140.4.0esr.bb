# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0bd3c5c0244010128a24b6e3a3ed99e6"
SRC_URI[sha256sum] = "eab9c4ea49e937e2aa6097d8fe1c294040fac57449bc1217ab08c05abc9a76d8"
