# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a1feca3b7c51706efd78595eb2971954"
SRC_URI[sha256sum] = "f62c8918cde8fb841f1546f8c9327be51e9e280fed530470fc0daab3901ba72f"
