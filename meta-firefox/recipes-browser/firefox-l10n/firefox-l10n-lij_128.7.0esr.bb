# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "40a50c2043e0b130d4901391cabf7a49"
SRC_URI[sha256sum] = "5bc766b7d9eeff4a0b14d9e7acb5a961126825a6e29cb317da8ae8a054d686e3"
