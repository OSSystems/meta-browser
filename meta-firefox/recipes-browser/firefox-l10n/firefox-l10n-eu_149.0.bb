# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cc3a3ea0a096c2f7acba1792b53b039a"
SRC_URI[sha256sum] = "8c24575387614584b139c78e5e47ffc1f18faa628b48032004b2c6af8b116c1a"
