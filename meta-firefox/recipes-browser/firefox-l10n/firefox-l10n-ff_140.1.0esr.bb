# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d16e5afd6eda08aadcf4d263e858446b"
SRC_URI[sha256sum] = "b0fa2597972c2950e1ebbf89c0b1e315f6d23bdf0c7b56ac772ffbc3963669ff"
