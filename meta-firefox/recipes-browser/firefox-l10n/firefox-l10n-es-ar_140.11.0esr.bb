# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "8999320b9024f88cb6e588615e7fbcdd4c6180c7099fbf3378b0c87757af8fd8"
