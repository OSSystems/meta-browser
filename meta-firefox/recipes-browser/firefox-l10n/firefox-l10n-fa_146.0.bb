# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "da776c464e4fcf14b6c6e5c52a8a97f2"
SRC_URI[sha256sum] = "03c5ef1b56e1e4f5a9538e40d69422f7e1c3abac1b92f81e69e2427220eb5521"
