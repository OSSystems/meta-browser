# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "32d21dd56f74d17af67092d80760af01"
SRC_URI[sha256sum] = "232151b6bed9020e383ebc9828f83ad75ad70a1c0a99f69ca75474dbd8ef9846"
