# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "801bf928b3fc01b03ea46883d6c66307"
SRC_URI[sha256sum] = "0b2afd0753a022655015274fdf6538a545da43958e67a4eaface1305e8249d9d"
