# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "668cb65352b78b706914dc89aceae2e4"
SRC_URI[sha256sum] = "3a1c745908c2b1bf3031fefe277f7b507b03d3e73645c6dc14e69c3d668a80a7"
