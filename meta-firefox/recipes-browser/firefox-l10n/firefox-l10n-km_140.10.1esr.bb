# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "45799dcd9ac20344cbc85a0f5027dd63f105499f92947e3fefea00d9e6288a99"
