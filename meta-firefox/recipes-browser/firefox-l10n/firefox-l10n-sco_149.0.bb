# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3955e287e783409575dd2719ae531408"
SRC_URI[sha256sum] = "9ced682e2e3feac6d98a3cef8d3d1779505ac6a145e47b83ff98ba323ce6a8f8"
