# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "16e34dfd39adf474115e6848d216fe43"
SRC_URI[sha256sum] = "bda54cc7c155391b5f060627aa6952fa7423c3911faec102459150dc0a230aa0"
