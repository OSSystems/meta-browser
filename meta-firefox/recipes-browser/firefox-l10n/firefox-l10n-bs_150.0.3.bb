# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c7ff70ceaa4e918eb867c537468cbb9f8d1cec8a530bf3fa97e4bcc9a5f2f634"
