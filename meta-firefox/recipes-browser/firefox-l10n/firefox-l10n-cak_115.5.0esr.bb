# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "772f7587c48d14e655858a0330869535"
SRC_URI[sha256sum] = "014489a352ba4e7a3c86d103297a0c1fa0ac1c9c31fed3bda4afb2fbdd427e64"
