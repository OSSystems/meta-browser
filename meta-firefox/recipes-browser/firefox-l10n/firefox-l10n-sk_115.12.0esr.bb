# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "284aca1ab92c556a14371ed32f48f233"
SRC_URI[sha256sum] = "b9ce4a0d99303b752de80848b80efdb2492dc971b5f6eb2c84eecba976704f7b"
