# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4901d0b5dd38b98e9fecd2813a829fc3"
SRC_URI[sha256sum] = "10bd878b7935fcf0b68052926215f892d5092bf2f578353b09f274f15e402a32"
