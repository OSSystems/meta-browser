# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ff464199357e193c77fc16d16e46cb70"
SRC_URI[sha256sum] = "aadfe530c0ed16cada4d4b1d27ebdb389a47a26906adc9653305c760b20865bc"
