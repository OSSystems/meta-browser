# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "00c8d6af5513bb3a78b71e065ed1ce73"
SRC_URI[sha256sum] = "97cb5f8cae2f37a62b0099531c13a79bb4fa364f59f9ebece8b9a89747c4025d"
