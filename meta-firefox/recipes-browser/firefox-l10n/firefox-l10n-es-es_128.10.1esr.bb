# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "98d1fdfbc3f8e0b2152ec4e42b8758fb"
SRC_URI[sha256sum] = "a3f068ac679326ad8e2ac980c32d59bc5a92bf73a9af676c353927978e3c5d75"
