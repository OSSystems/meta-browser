# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7b4739ed0fce62177858663352673a79"
SRC_URI[sha256sum] = "160fefbb31a0209c62d31f638b15fe85c37454c937a0af790ebc2e4e8df5b3aa"
