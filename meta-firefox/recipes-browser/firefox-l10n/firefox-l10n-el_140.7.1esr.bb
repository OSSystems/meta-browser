# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ab3bbe6d0d35f14d4aa87d1a3eaec76c"
SRC_URI[sha256sum] = "72b58cc95c9e709bb39ba8e25d6bd924148da87a3093afc99821870e5148859d"
