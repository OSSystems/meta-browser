# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d7bb85777defee8540cb56ca7c4cf05e"
SRC_URI[sha256sum] = "9f1d069f1a71ae6beab644f4861edb4f375bd7f391a5c46fb09e4829a9fb4936"
