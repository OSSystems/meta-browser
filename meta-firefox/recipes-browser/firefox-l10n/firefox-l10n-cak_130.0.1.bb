# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e22570311e0d90a4db120d48cbb4dfec"
SRC_URI[sha256sum] = "9f2d44b356e297dd941eb51c5df14bf8a03aefab34193e7cb25d7ec47f1caef0"
