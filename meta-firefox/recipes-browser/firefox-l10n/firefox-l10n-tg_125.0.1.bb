# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a50f3741f0b6b918a30793213422fe25"
SRC_URI[sha256sum] = "ed6a630c31201c94f402632f546ed319356c9bcf3167419a28b626a1e3a2785a"
