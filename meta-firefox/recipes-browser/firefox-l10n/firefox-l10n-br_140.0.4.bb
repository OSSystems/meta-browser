# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d35d39ea918a74525803da31b1491452"
SRC_URI[sha256sum] = "5ad7a79c69d0e9be5b53a7018eba3189451dd29f7dba6dbaa822cfe0812a1bee"
