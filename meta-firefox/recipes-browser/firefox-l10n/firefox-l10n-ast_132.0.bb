# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "959b17cf2037ebe905b0bd3ce6dfb9ff"
SRC_URI[sha256sum] = "9a5ed10edb3f5d4cba487443529575714a783aefce718ba4131010cdd11c3047"
