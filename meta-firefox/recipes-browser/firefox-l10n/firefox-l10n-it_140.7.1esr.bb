# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f11cd20e8c52e2f82b24c02d8ffd8cc6"
SRC_URI[sha256sum] = "557cbdfc5e83041f63e41fd4239ddab911a9eb4a07824a028ba960959ecd396c"
