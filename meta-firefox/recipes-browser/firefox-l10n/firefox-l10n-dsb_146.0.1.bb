# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4f50bb8ebdce9266c7d8da4dad604f18"
SRC_URI[sha256sum] = "7ab9275c089f89d88f5499f4abe4160ed7aabd70e5bcc6781557a8408608877f"
