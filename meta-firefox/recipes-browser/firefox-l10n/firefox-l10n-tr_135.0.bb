# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "74db3a8e458e9428eea69b122f63b1a4"
SRC_URI[sha256sum] = "6134803da459c6438236c1d1f5a0b97b9b0fd7410830fff31b403e08cfd0a84b"
