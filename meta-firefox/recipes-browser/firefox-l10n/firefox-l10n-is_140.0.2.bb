# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e64bdaebb927504158adf505c083a22c"
SRC_URI[sha256sum] = "c699e3231010c4059e592a7b0b5f3debee4628fdabf87fd1a624b30d60917286"
