# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f16158a6d06741331418719c738f1ef2"
SRC_URI[sha256sum] = "6231a07892fb39856347a1a3cf910e0adc376919292385f9a76cebecba4b6837"
