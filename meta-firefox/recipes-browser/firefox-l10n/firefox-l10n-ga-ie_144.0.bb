# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dd0a439cf33fb66cfd4f62f4b31baaf3"
SRC_URI[sha256sum] = "60e5fdd9e07ec7bf9ab4d66eac92566d9263174597598335f826565f39017b29"
