# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f1332c07b994a1b4ab098cfbd2b6ee1d"
SRC_URI[sha256sum] = "83fad36f2d64b982aa7836ee75ae44b8de9bf84b8d753961b91b5c2e4692e042"
