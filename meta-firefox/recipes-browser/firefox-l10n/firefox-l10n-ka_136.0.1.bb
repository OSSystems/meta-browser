# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "371839eab1cfad4cbc569d22f5ce4d32"
SRC_URI[sha256sum] = "46bbc63db8a05a887ee5b54e4f2fe7fd21112bf8b1d1554a54b1cc60de624f32"
