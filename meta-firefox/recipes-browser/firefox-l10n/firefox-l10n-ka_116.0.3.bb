# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e3d4c9a70c3861ecf104ed7b7fd0e108"
SRC_URI[sha256sum] = "57ac1942b09b0a6fdc96516680f4448aa93f360e81c631728635a5f48a99e240"
