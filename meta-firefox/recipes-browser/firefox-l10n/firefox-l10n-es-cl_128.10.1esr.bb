# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b82dfa1ed6066f8ff32890502cbebf63"
SRC_URI[sha256sum] = "9c0b71d7e1556ac000cd90b2aff63b1bef19a365060f4d67c7a4c1778a2dd70a"
