# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fd84030e81b0a89364a625ac8715c5bc"
SRC_URI[sha256sum] = "3644a5a462fe7fdb6671a50565f8f481d1756463130beec80e94804d1f8c6153"
