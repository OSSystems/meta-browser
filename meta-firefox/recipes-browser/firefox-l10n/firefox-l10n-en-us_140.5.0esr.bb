# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ecaf2957d280c0d3148d9de00f13c979"
SRC_URI[sha256sum] = "f79fa16b476b5197e72e9ee23f7e5197881dd4b2084845e78e5c89539a8bc127"
