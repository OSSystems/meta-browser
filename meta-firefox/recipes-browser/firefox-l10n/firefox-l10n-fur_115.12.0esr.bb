# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e2c11479924879fdb7161fd800c15aee"
SRC_URI[sha256sum] = "39348a6b3a699d1e09df38563bcf82f61a3928870d36d3467d01333943ccbb9f"
