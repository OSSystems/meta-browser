# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3deeed1c3483ce6438780dca85e654e2"
SRC_URI[sha256sum] = "9efa8d8e47ba9856992b2ec37d1621ec2d4d6f13de54b36a20bed0c9d8eb3157"
