# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "be0f1d1919abb0428955a88e08f9a690"
SRC_URI[sha256sum] = "0294b9ac77ada6f4dd3f95524d73c54f54dca8563381ea4936e9f333e9350693"
