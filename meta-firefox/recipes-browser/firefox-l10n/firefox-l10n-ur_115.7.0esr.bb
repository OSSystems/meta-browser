# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a909491327f9408712e3372c6fd9469d"
SRC_URI[sha256sum] = "d42a16057222d8363a1a3ff0d297e39677801fc7e66866c7438d502be3c9d2ac"
