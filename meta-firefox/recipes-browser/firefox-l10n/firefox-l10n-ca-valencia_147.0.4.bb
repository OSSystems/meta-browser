# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ea5f5ba5ce69325f9e77120a546e8437"
SRC_URI[sha256sum] = "055d5ba863f2d482e3d3fe4cd4b8754cb9193167b10ec1b11f71d17f44c3da9d"
