# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e6d17f3027ec72b788e2b971a9fd6f62"
SRC_URI[sha256sum] = "f7abc9c205ddc363b51b6957ff6b01ed8ef584060934fb07de957b931e1760dd"
