# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7612d81fc9636c7cee3518b06386218f"
SRC_URI[sha256sum] = "90d733cc33ed27b411c68446ff2e4cbd5bd1045c29a5f809126473fd26624f3f"
