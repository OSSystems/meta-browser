# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c92e17ae0f8de5b3252fdda1ba13e2f1"
SRC_URI[sha256sum] = "6a9909347d5054e4bd9dcd8b3688e49fec642ac5b2ff69f71fa1b617c7ff965d"
