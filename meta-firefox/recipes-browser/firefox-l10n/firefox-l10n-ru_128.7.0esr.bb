# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "314eb070e33afe7130e583ec21fe4ca5"
SRC_URI[sha256sum] = "2746361a06799f73537b8ad073543e0227a7cadc6493673f0dbb9a23ba6982bd"
