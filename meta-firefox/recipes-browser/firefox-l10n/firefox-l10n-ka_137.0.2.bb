# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "76e9f3ff1d840bcc85bfa4b1d41a9b1d"
SRC_URI[sha256sum] = "8109b0cff69a1ed372019cf5a03b34ca00a4c04b37590708e2419eedf4630736"
