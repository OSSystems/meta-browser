# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "491f3bac6599a6b57cd403e19f31637c"
SRC_URI[sha256sum] = "d3539eefdfe5b96eac2de29e108851637c2a0f5f43a0096aabbc59c0d5d5c8cc"
