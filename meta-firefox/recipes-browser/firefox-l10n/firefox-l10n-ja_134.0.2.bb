# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c79bb619b16525552f3c1493a71dbb58"
SRC_URI[sha256sum] = "bb3af16263c05f75fd3c8791f2ac74e46152906812d768928914c53dd9d635b4"
