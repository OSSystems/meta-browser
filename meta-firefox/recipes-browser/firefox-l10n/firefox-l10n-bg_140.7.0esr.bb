# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9eeb0716afbd0471d024f9ae7f30aba9"
SRC_URI[sha256sum] = "be72af9a0e7b3e17e9e4c899cb4745ad3e5f75cdb91c083c90b3fbebdff3a720"
