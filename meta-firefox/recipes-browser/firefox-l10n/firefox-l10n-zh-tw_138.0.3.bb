# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "864148dd030bc5e56f742548adf9fdea"
SRC_URI[sha256sum] = "8da5589ad30b48a76f2e47042bc9feed6af07db18707918eb7d5586871bc89a5"
