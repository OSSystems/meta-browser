# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aea76aea1f1bbfc25d2836d759c2a082"
SRC_URI[sha256sum] = "0bd4107ff9ffe3afb05c1b0aeafe274706fbf528e3c2cd6eade12aaa5c3d67df"
