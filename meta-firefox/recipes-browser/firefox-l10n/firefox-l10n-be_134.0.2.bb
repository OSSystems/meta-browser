# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8d769acb5eb67a3d1f54a88bc746d7c8"
SRC_URI[sha256sum] = "1b49c2137a26507ad38221859d1db61be5f0869e69c50c2aed089cc70a6d6d67"
