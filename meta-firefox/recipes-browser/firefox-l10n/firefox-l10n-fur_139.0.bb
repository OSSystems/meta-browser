# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "134d78154acd2f2a1ebf5ef1467b5921"
SRC_URI[sha256sum] = "efa4e06d5acc457ac3e92e7658cb0f22f82319bba0ba8c7165eb4ca3dc76e9c8"
