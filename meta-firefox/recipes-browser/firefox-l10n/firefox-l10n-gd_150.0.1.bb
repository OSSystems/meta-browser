# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2340a4ffe98ce3dbab1c720f7186c0f557c648c3bb1d1c47e1451d4be530f90b"
