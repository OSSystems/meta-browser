# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a0bb3f9614dfa19b070c3ecf20d49bbb"
SRC_URI[sha256sum] = "7d5d0ff351f6cff8c79e5dd3fbf9f0a378f5f1f57fbd3d6b0f0b38cbfa81cb95"
