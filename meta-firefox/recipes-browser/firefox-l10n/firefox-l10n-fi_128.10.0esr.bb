# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7cde55bd7e56fde1a2295d0f0c1ad016"
SRC_URI[sha256sum] = "5eb6675a22c6d15052580dc70a330b131795e7803bda1ba31f6138bb8e9c7dbf"
