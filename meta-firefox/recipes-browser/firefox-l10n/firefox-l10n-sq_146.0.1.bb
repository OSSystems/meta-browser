# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cff49518c9b28052af9870dc3833ee67"
SRC_URI[sha256sum] = "a81a4177ce05d160c28f8d5ab33103091c516800e775882b7d8183603304e1e4"
