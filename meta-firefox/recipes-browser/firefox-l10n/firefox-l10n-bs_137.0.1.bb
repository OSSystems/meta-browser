# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "44439f7b02b0e9bd673c15be6d66d5eb"
SRC_URI[sha256sum] = "2e25a72859512d54c625d094a18eaba6074e6ffed79f8bf4b657be775d6bf64a"
