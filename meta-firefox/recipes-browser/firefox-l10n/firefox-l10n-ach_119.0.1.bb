# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "09b7a2d6a953f19434b6c2091059bb95"
SRC_URI[sha256sum] = "65f747c38650193b091d0edad66f801347edca9ceadf8119c1aa4c8387bd2c70"
