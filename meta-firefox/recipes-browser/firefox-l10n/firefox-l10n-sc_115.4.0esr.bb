# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e4c9eb3c7317d69692afd01cf6f61356"
SRC_URI[sha256sum] = "442cbc35eb8d81cf8c0706cf4ecd8641073cec3cf39f5b94faf27c74be2f1566"
