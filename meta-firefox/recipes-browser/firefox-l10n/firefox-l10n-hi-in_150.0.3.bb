# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "88b9f8849d595b1b68f69181b22a4dd4d2b4dad431205d570761075b9e6aad91"
