# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c565db4c3410ac2cba16863cfc690a1d"
SRC_URI[sha256sum] = "6aa4bbaa3bba8bf2226d9c80c23f50a045ec99953cf92c61774c7c5c1cb3bde9"
