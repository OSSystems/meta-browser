# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ed371562efe70c874b6f9cb747b542c7"
SRC_URI[sha256sum] = "2cbcc5457e07d256390e661ebfa8446affd142f1954e894150c3d4cc0baf9e72"
