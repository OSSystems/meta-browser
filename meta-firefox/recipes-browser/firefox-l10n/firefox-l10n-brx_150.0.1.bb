# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "76d00c5d2508720b359702e9d9657961109cd7091f6a248172e6de0cafe74c0b"
