# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d4b83b4bde31c31d119ae1c12c2a7a8c"
SRC_URI[sha256sum] = "f17cfcc784a4bdd3a2ae5ab37e69750593cdf0719bcf10d9bf2f5f261f4829d4"
