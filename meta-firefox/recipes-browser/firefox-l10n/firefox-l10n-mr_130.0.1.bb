# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0240f8a41730346bef512d553d73c293"
SRC_URI[sha256sum] = "48e826e8e1a0c5c6d53ac5b8c8e59f0e3c273ea6a6cd103fb2ca5fc295194c72"
