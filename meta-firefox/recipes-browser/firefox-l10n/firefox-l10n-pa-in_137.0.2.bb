# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "30bd373be2e03cc959bc3e8bd3eddf6d"
SRC_URI[sha256sum] = "f1495e74b8b57882118fd3abc5522951375deed5aca6f0bb8aff07c9ed89bc9b"
