# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "689d6d7a95e48f7162717a1216e7dfe8462f315de9883aabf14236cb71240439"
