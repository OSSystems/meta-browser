# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a4fd4f7508b6dab7fd74fce97809a98b"
SRC_URI[sha256sum] = "8104039ec5783c2a8ea2674e0f78b2c73008a177f2165dca59e9723f6fa0313c"
