# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6a439ab899bd8f94e341793cb3622aa4"
SRC_URI[sha256sum] = "2197374b99883489ea46f6546ca1d0b6ae8b50c7b39f2279cba4a8fa05b34be0"
