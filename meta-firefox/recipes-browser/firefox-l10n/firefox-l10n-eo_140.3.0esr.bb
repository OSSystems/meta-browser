# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "514cf051ff9659e78f49d54bcfc8cf02"
SRC_URI[sha256sum] = "69d8493fcaec3e0119e308025d131804c5d389be847b4536c2dbc41ee366054c"
