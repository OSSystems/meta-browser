# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6634871bc5ec6e27851158238a7b0fd2"
SRC_URI[sha256sum] = "a957a68f621a9d1f4ce71986383b70afafcb1a3135db629935a8ac28957054b5"
