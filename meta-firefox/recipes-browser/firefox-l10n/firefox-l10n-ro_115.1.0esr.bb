# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9be25cdaad60cdfcd110d47ad43cf805"
SRC_URI[sha256sum] = "6624e91de5cb2b1fa3f86cc2761f524fe81cc8d2f339a9518a7d10a19e47e765"
