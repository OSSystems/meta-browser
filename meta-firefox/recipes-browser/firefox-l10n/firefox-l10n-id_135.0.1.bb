# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "79ae946fafac591181f21d4b12e7a020"
SRC_URI[sha256sum] = "e6b8d9b3761276cd9e905e7b1dfa0b5942229fa001c77eaa03900ad3d495f1c7"
