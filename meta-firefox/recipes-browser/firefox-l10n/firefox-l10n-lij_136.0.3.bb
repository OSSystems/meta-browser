# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "76f4ef031cae80913237104c639c8e10"
SRC_URI[sha256sum] = "a25d85371bfe68c3cd0544972eaec82a21069ef70547f1be0d9f83d3ec30efef"
