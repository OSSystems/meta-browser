# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6e0eb0920315eb183561b16b522c96c6"
SRC_URI[sha256sum] = "c33c04c0d38b2a1ec22747514c4c88fb4cf868c7e44086124a6de3d0eeb95a31"
