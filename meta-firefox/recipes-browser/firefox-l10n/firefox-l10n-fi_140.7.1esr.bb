# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c6c7379846f5607442818643ff9b1b6a"
SRC_URI[sha256sum] = "24e6ba553d4b9bf49116c886a0e5f556aed8f0bbd0591e1309f102f8fb7b61a8"
