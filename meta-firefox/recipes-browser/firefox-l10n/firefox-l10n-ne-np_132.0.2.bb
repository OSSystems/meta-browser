# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "86d78adee8c728e4c190a987bae44a6b"
SRC_URI[sha256sum] = "ae753daf6117f0b195fb39090c32c9f6469e007ff271a02ffc6783e659198cf6"
