# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2b924b21420c60db5ffa28f4279b5422"
SRC_URI[sha256sum] = "7fb068450d06b4fa4ac2d1e4284f7d039c67064391f836e4b16154956e7db2b4"
