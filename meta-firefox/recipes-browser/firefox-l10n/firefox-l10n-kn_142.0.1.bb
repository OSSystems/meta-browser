# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "03e7d004a30a00893942ec003c1a47ff"
SRC_URI[sha256sum] = "c95bc57442378e014714b80310a69607acbe750324f1ce976c59da3df69bb67d"
