# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "95a12ea9b0d7b0d8ac15523dacf51755"
SRC_URI[sha256sum] = "7c73ac2659331ed1b6c02bcec160c68c50fe2436d542a1b0be72d0a61b0d48b6"
