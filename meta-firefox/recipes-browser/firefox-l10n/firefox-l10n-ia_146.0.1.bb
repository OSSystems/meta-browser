# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "064919826af8c94d4b811b68bf83dc9b"
SRC_URI[sha256sum] = "390c2abc1feb4e9af32e9c9841cdbc612e8cad74f95523e091a7ed238c02f0b0"
