# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7430f639e2a6854c140d9c5ae6ced24ad37e18862d2837e6918a28bb8ec9a1f9"
