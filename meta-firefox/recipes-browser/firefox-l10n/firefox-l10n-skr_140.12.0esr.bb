# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "56521214589e3e9b8bc8a0c30da65c4bafccd294a2451b896eb5f461234eb05f"
