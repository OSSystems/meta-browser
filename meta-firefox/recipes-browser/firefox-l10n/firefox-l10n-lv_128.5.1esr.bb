# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "82ba3e5a7cf9ef49feb22b8983e8bc56"
SRC_URI[sha256sum] = "4f1e418458a17d93b98f2a49b1d3a4aa56cbf50d6d0b4d8d8ecab8aefb242e98"
