# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6bc0edcd494d9849dac1bcf205e72f8b"
SRC_URI[sha256sum] = "b736c392943287407e5afc2265874b6d5675502e0dacdd0d0a16eaa0d6bbd920"
