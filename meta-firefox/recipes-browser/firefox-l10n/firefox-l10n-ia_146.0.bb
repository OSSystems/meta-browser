# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "727a3846e45f75331e0c5a04928d2d32"
SRC_URI[sha256sum] = "fdd1fbb7ffc52915d057474f3da8ad14884f82ee5c0adea0a5958429acb19398"
