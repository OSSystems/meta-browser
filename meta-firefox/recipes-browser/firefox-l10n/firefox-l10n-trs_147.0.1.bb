# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "92cc3c2420905926775e6d031dfa1e49"
SRC_URI[sha256sum] = "84ee1f8a134b8dcbc1af9b5e349c7e9e41c215df5dbce39c71f7dd8b2649eed4"
