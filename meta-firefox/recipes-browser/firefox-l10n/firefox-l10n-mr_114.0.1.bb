# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cb37d0ed1a46856a239f64a464635edf"
SRC_URI[sha256sum] = "3664415eade4d69f66530b160a7fe49eac5f310bdb4e8be44814e7bcfad3f543"
