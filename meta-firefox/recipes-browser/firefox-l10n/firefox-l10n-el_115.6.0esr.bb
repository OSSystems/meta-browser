# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aab1a093ee35406472819bbdcb59c52c"
SRC_URI[sha256sum] = "d0abc66b5f0ebd1ac5309bf8a1aa4fc1f858f9acaf7e3be298391942a3e1582e"
