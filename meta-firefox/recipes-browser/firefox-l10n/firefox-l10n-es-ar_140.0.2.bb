# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0eb532269d56462970828849c67b7eb4"
SRC_URI[sha256sum] = "9a5498f0aed6cb490b8508610b02c24b665d8085679b3e1fd2f5ad9dfb88e28f"
