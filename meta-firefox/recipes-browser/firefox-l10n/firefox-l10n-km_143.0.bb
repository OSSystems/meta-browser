# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "65b3f82905ca25bcf74e3208f1ecd949"
SRC_URI[sha256sum] = "ebae0db37a1dc0c33735edd9a0684be34a5f1bd2dd8de4d93a3a34c1e421817c"
