# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "b60468fbe353f5121ebd18514d7f5bcc99e6e1ee8f427744e56f105225377a47"
