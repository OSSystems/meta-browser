# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3ce318671eec1b18d46a8ca5cadd11be"
SRC_URI[sha256sum] = "524ef8d6c0f601a752c79a42f926507854b32e30f97fcfc89ba4777b3b4dec9c"
