# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f0223c1a24f8e5dbd7b52a6ba2b81032"
SRC_URI[sha256sum] = "01966487da0df54d51fd8858e6baae8fbb7583fa3d3d4779eb6e4e4575ed739d"
