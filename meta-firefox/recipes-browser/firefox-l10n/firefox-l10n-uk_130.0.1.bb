# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d61c4bf14b9e48f5f8708303dacfb008"
SRC_URI[sha256sum] = "16af88485deafeca4e96cfaac16d7ba55ea9692a1d6af3175d459a156d92dd8c"
