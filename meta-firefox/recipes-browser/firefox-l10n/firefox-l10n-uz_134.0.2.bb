# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a40ba90d52e9573bf0876bd6204faaf1"
SRC_URI[sha256sum] = "ec3992a2855ec52ae674ba7819406bc5b31a4ff6a30c01424c6b74a474925066"
