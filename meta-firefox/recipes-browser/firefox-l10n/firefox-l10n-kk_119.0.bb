# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f26beb472480e05ca30a181cc2a065b7"
SRC_URI[sha256sum] = "76e49f9b8440bee6e3503ffec2ee49aeb93460be5fae6c87abf44aa660dcacfc"
