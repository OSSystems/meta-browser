# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "11059f5500417db1d9ec358e39443560"
SRC_URI[sha256sum] = "a8244c8127bdbeb2c6309832d85b4ce4442f2b052ced0c82464485a5c594d3f9"
