# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7e69679431e62ab1d467fbfa473f7250"
SRC_URI[sha256sum] = "75d0da063a32f2758a696e092fb3baaaac721dcc2cbd2f40a4d48e95a8af2c95"
