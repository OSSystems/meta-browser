# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "956a989e6bbbc7600f2ab1c304d8bdb1"
SRC_URI[sha256sum] = "fea714db83d0b05dee84131b5f195664f837da3b437beab71aa546a6f8f763e7"
