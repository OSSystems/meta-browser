# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a422254f39849ccc128070025060d367"
SRC_URI[sha256sum] = "bc220386b04ad1897a13c540e3819f380bb108192f270a429988969ad2aaacc1"
