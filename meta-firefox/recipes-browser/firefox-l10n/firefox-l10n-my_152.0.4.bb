# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "170e1f23a6da4b4a4240ad94c1c5c452284e947fd48a430e0daef331c2cfd6ed"
