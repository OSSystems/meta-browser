# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "753965914863ae1aca7e92d6a8279140"
SRC_URI[sha256sum] = "50be4d8a5abe4e698ed89d5ce8daa8cf507755587b838736554983f4794aef69"
