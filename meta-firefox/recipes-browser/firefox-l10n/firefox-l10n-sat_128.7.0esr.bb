# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7a62e4805254db75ef0f06f71d37418b"
SRC_URI[sha256sum] = "e65789a692d4e1129c807ed7a01d9638ac23c6ebeba882c6bedaecf6fb306ff3"
