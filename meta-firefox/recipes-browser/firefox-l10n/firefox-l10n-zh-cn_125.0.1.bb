# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e5178f93fa16fc90bf0f25ff06a223de"
SRC_URI[sha256sum] = "3972b4bfc72457399b2296ef231d43feddd253342f0e5459a97c3f4abce67f70"
