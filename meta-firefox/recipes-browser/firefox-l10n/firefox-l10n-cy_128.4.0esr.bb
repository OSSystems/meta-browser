# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c96fcca4f3ca7e9b171fdad44db6385b"
SRC_URI[sha256sum] = "297adfb532fdddf47a647e8d0b13d957d1d25a81a7fe1511629e8289175ef751"
