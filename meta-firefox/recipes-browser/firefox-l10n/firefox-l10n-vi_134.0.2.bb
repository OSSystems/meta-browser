# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "98537f30a3c65d021457746d9ff87c14"
SRC_URI[sha256sum] = "6a7c8b48bb4db765962bb9e1e8d1a68f3930483383d8fca1e2e4b5fa810e11eb"
