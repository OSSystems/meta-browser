# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "34b8d3566790d1550667787f6e02591a"
SRC_URI[sha256sum] = "d176c0436fff8a048e0ced87c9785a7d23918b3fbb839c7f3033fe01ef2ada94"
