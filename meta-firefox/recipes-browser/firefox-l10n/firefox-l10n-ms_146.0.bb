# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5b26ae8a2ff2cda856a58e229e956e1d"
SRC_URI[sha256sum] = "f1f000639157b74388a8e067eedacaf6c6622500b670f116d1515801c4ff14e5"
