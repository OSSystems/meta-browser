# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "003a5289f3330a71d025d3ecb4a7c8df"
SRC_URI[sha256sum] = "c3bae11b39053e44f22ba8be606e530cd168ce3c01e82c4270aae2748890daa9"
