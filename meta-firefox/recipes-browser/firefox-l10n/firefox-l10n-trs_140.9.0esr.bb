# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6ab030e01c09372123a6d4ef497de546"
SRC_URI[sha256sum] = "1a71e0d709f792b163df0b5e4bfcfe6028507b5c1d739c6a7fc7dbfca55082e8"
