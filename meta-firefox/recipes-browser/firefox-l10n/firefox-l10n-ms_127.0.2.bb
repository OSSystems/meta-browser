# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "176f5de420f6f4b532ca2d12fba97d84"
SRC_URI[sha256sum] = "a3eb81cc1841f393c2151a90af866905d053e738488f5aea15ab7bebce388879"
