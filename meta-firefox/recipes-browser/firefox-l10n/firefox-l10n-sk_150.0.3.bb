# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ab4b16db432d0ecc450fa61b8bde690e3a99afaee6f7ff4276510cdfe77853da"
