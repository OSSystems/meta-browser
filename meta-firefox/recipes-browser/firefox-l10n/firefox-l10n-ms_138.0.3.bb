# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ff23545306bf7d5308f2af603934323b"
SRC_URI[sha256sum] = "17e492f5bd3ff2ed3dd35508ee86f0d44155d9659e9e745a8b86725f983f6431"
