# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a6840d6d37158593d06e5f2162435616"
SRC_URI[sha256sum] = "acc6b5749d4bde67165a4941f769a2c3932687d91f078cf6850f42469e661616"
