# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "17fd31082f06f5a1f569ae4fa2d9bad1"
SRC_URI[sha256sum] = "5d547e741ad31aacda8c4aa8409e383263a14d3b68b926182c0adf7ae10633a4"
