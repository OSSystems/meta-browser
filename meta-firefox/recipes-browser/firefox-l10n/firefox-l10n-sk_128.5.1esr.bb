# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "824467a0955eb4dfa1b6cb9900829ca9"
SRC_URI[sha256sum] = "bd6b0cb8af7a6d0a196d4e88d3dc9e08f5df2860e0855ead90f4e62bcf03e9b3"
