# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "532770025e3447df364d95a04274336e"
SRC_URI[sha256sum] = "ef1e0edfd00e540f272ba3b9508cc1568674c4d84ff302f996d4890847e9d4ba"
