# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3edf6afecff30730088f262047b6d2de"
SRC_URI[sha256sum] = "9ab3841c76df2d835c2a0195f2410f88337060fb9265c069d31a5c2251b55b3d"
