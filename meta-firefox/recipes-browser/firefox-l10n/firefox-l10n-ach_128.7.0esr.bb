# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bcb9cae2ae1bb45396c4b46845c7a6e6"
SRC_URI[sha256sum] = "3ee4d49fe792da41c335112aefac66b9b97c0e7bd69383adcb73ff2afca88e83"
