# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9c04b4d92f8130c9af06ada457695c3d"
SRC_URI[sha256sum] = "87355cb09c89d369383b91d77aff3a1784ccb4b51c788d73a23ed529911549f5"
