# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "715235302f23c44ca033bd97313b47ba"
SRC_URI[sha256sum] = "75ceaf2c2c427a99d5f328deb878e1658e78b2ab090f873f9d98b06ec4f28ccf"
