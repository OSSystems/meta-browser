# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2632b32d67c942dce201b8824619a8dc"
SRC_URI[sha256sum] = "ad25f4ce404163121ed170168d38e02495c3aa5f8d8d15b98b098afd8c0dedf5"
