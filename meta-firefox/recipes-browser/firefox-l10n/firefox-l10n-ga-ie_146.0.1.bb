# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "adfa716c2da41eb44bf07545049684ee"
SRC_URI[sha256sum] = "8037772c8149b8ce50365a37753e6bbe31bc7da1c1a5b991fabdfade471c1742"
