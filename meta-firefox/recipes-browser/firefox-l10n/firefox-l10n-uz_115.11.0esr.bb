# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "43fb077dd5ed4f082c5b90857bad58f9"
SRC_URI[sha256sum] = "d5a2cb784ba01db618662ab1f8ed9b5dd8ee21b9553e65ff89a190df00e177d7"
