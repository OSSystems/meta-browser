# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6e872b9248b45a91480cc231ca1e36e5"
SRC_URI[sha256sum] = "f6611cafafa5fa18e37511ece9120281e0dca23627da2cc773c00f251b2e5a8c"
