# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "11a5711f34189c0418c158c672878e20"
SRC_URI[sha256sum] = "73ab5cde77f851f594f00df68249febe11734a9aa93465b80cd4812f247bba87"
