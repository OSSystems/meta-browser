# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ad89420d862da83309312d2d3c7a611b"
SRC_URI[sha256sum] = "cedff4a5750df3e0ff0b4ad8ef0f9aeb44a6e34fa9588664613540fe0e808d2b"
