# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5aa6fc7b6912c0ed9fba2829d972b54a"
SRC_URI[sha256sum] = "f09843f3e275585a5a5ea264c337449e544a690ad3ba278188c5386ce2dc1190"
