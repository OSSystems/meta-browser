# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1444edf66de00152305bda1e9298debe"
SRC_URI[sha256sum] = "48512da7bb058ae4ce49084e8f7076c4db2af997542335ecf9323885055d6a1a"
