# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6de660bb68592477ba402fb7b8d61354"
SRC_URI[sha256sum] = "5b2701edd0f8424dacdc9ee048033a6e956fbd796862a0be1215b4d3e8e952a9"
