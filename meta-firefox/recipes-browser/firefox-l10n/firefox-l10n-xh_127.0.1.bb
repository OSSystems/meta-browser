# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "56f745a30af7103829ccde013aff2201"
SRC_URI[sha256sum] = "1197502f5a159da76abe0e33e6177607c951db4faf01633f51307fafdcbbff64"
