# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ad8aac4e61b8531973c556b68c9d500e"
SRC_URI[sha256sum] = "3f820862117ca1f2e6e920eddaba28b4781bb15e42196b0a8e20ffa62cc23e0c"
