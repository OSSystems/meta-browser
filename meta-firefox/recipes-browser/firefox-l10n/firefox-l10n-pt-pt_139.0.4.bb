# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2cbac251672eea9251d79e61fab0ae4b"
SRC_URI[sha256sum] = "9b112f7fceb3c24f108681ca86a16b2fba5e09bd4c4f82905e3b4a8f08090f5c"
