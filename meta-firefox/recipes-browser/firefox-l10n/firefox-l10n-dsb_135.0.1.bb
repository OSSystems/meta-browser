# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "13a90911b05dcfe89794404b1b063808"
SRC_URI[sha256sum] = "7322a5492728e77ab7c89f504eceb3e18f403023557e01dd22ff15aa6c1ef484"
