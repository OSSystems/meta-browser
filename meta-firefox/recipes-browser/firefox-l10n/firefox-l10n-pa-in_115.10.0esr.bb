# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "92843d10563f5bcf8e1354bfe5dd8290"
SRC_URI[sha256sum] = "c4a243fbc04d3433eddb5b16dc0b4b981f4043df4d3b78e10bf31776c4149282"
