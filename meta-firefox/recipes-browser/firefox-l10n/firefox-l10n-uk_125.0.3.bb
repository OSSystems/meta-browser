# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fe2f40325883a64ba39874b185a1c089"
SRC_URI[sha256sum] = "450092d4777bdd34cdf210689e01baa554a0ddd729a0939d77ade7c957020155"
