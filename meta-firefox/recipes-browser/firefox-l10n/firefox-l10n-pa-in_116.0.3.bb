# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "52baa33474c45a931eb83ee64991e885"
SRC_URI[sha256sum] = "c9a4d93ef4a2bcb2b3d0797e7b587651d4eb9d777bde8d84026013a4d29c8430"
