# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "632c841c7ddbe49544cd218adb9a17af"
SRC_URI[sha256sum] = "2274c7d360feeec975dca0f437f121a52220c892aea5b4fbb1c689a52aadd1a3"
