# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "202861abfd7774a924ef51a406587955"
SRC_URI[sha256sum] = "a460fe851d9381b36e8ddaa7a1199b0980d53a5df3e6885908fd0e5c7fcf8dbc"
