# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "092312c5938e23df44ebf7ba53b6835c"
SRC_URI[sha256sum] = "d43d48aaafedd7864e5c998ae8202d6a51d7a6b1bdb72aa5bc8c80fa7bcb9c9c"
