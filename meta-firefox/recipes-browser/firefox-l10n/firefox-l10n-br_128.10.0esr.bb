# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cdf149bde5041af7f49fbfb389bd8af1"
SRC_URI[sha256sum] = "f2db3a93ca729ecb707c726cd566ead6944ac1c9bae8a3dfad0add8b6a922061"
