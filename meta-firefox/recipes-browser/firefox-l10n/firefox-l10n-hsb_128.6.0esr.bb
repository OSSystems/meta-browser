# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9c691925704e42f08fc59fd2f0a4438c"
SRC_URI[sha256sum] = "83d4b2db50186525a8059938374b168f16e00cd3199366af6d65ac98eba865b5"
