# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cb4b9d7a0155019c7bb62759e7ef27a7"
SRC_URI[sha256sum] = "4feb3ac6a4761f276c84024cebe85e0dfe751e361128a6f669ba5ef1e1f4ba33"
