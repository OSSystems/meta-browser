# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7bd01e2f88ea3e29111a7f54f23b6a06"
SRC_URI[sha256sum] = "3bbbc37835f4eccd5e69eb90e3e15bb0079efdbb7200631ac0b08491eae21fb1"
