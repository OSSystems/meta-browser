# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8b58650784e39ee34eeae6256a2b1e32"
SRC_URI[sha256sum] = "f05b92a36d65c440eb7ddda8d48bfbf17bd0068eaf6beb380f3d724774397d3c"
