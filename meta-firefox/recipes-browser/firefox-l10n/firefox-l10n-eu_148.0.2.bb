# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ebc55764d588d6794512738513a913c6"
SRC_URI[sha256sum] = "53789f6ee6fcf35c9b644bca514412a91d4935d29608c5d6f375a4b0bc0ce542"
