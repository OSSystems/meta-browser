# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "908ec2c2424798028a28841a94758743e583cabd7177fb1303ff6cf3b39c938b"
