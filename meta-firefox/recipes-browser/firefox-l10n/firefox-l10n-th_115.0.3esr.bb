# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1ade38d476d84364c3b7e3fb28e7d367"
SRC_URI[sha256sum] = "d6585a2e5e07273d8bcf1a728fe53c547adbd9fe24c4f00416bdf2ec8fb9471e"
