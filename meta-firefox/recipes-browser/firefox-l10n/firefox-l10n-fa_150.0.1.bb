# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "92c8dd9e48cd6f849ef30c58d839d6fe76a5f22aa603d94e9f9babdf1340744a"
