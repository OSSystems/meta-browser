# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "643290ce13b97f01c616b1e9bf0d24a0"
SRC_URI[sha256sum] = "61491d0e3ce9e6920dfa790f6ae87c0cdbea326f83057f692e7f599ed3fd4bdb"
