# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8a1b5b0350f69dc83d856757b0778e41"
SRC_URI[sha256sum] = "7240901f9b8eac60b02eb7891d7d8e0739acd77374df2f1ea217c9e9bb8da98d"
