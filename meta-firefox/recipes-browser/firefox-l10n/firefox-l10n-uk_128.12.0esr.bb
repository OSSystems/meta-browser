# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d4f0cf8d0d345c4148448a10d5a7ddfb"
SRC_URI[sha256sum] = "26f9e21a78094ecadec1b427e0f664e91447ecf92c170c35d183b572b541cc08"
