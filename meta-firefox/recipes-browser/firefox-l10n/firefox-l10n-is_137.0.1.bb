# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ea98ddaf21835da40345868782223e35"
SRC_URI[sha256sum] = "c6b7f92bbfcc911f7bb991c93f73d1df4ce52474e2fcd4166c71b98d69570c4e"
