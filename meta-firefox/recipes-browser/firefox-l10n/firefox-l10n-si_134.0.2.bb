# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "54ee07ca3117349d7c8af2d3cceae53c"
SRC_URI[sha256sum] = "8f0265b3a11831ede614caca5def012a1491589b6a752454874c95c9b093873e"
