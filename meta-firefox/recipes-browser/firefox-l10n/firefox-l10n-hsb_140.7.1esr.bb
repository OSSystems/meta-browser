# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7ccac58c4957756033c172a1b2a2b57c"
SRC_URI[sha256sum] = "08a060dcfb247be072f3380336d9bb9335f1de0b32994fe600b2205c0b32732f"
