# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d7fd9cfa921434867d16fe410986d51a"
SRC_URI[sha256sum] = "18d93ac4e6a4c34aba605f54771cf3cb64fc16527f868f97d81d3ca9ab9e9064"
