# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4fd67af48fc1375621a6d2c1837e4c69"
SRC_URI[sha256sum] = "902a4e6724525a961808bd10a823488ef14db013f313c1daa9b0f75caef67f5e"
