# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "39a11dc379457f4dcf6428608b389954"
SRC_URI[sha256sum] = "dfbd585142120efc1ddfec226a8f7455213328599cb04a4a892319c4b99ffc15"
