# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f6a680c9cfaaf2550a5ef4c8ac1dad95"
SRC_URI[sha256sum] = "eb25c22bd42f01ae18a7f794742e2e1c268239f5866188affd4bc0331c879cbc"
