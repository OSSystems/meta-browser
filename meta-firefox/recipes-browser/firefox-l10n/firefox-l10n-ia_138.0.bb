# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b145e7e0a6e6b039b57f137e586cc05b"
SRC_URI[sha256sum] = "0088755472000ca8bb305b231b4e0019dfc9367cc78e1428c918990d9378088e"
