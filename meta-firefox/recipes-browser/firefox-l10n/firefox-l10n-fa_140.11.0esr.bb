# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "05688db2f90b2e4f108ccc71e9b1456b5677db4f58dcc5a8a9b0ae26651c133e"
