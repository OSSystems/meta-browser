# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "09392e9f6f047331b87ba3689d6250ee"
SRC_URI[sha256sum] = "c1b46f390b8c23b6e1815aa240e6857feb1ce9759666499a2f9e8717b4e67cf7"
