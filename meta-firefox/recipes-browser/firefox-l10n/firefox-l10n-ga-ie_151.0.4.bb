# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "77a1b51338edb2578850e4ed37434e538711957c57df53201d4b039c8b3fbcc2"
