# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "001f27e5213bd837a0b9f80002f9d72c"
SRC_URI[sha256sum] = "e99fbd35064cfcf9e585b1688f149a82fed3a7ee99a2b2971b68417752f38dc4"
