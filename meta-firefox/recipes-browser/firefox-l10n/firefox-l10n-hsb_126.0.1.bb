# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a0af80d5b5adefae98f8bc912f0405a1"
SRC_URI[sha256sum] = "08ae792d015b0d256d999e32721d86b1f0a10365df66fd74e97e46814b5792f0"
