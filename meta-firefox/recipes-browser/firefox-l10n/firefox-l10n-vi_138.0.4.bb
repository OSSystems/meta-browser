# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e81d86779d71a74f56bba5014d421e54"
SRC_URI[sha256sum] = "323e5cbb16d8a54c54ba8e739828f05ae9cd26c92077914175745e0659a00f43"
