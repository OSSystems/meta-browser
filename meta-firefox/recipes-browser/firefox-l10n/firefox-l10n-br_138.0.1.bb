# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f2d4f502a541c1896c3791d3f4eb4a64"
SRC_URI[sha256sum] = "c4535c66877478b41cae232983b8cb746d298b4d083f5dbb57b0626f376cf375"
