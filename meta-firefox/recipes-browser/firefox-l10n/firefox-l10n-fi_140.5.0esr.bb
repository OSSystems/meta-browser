# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6bade334a3ca700c1835e448680164aa"
SRC_URI[sha256sum] = "61c240aa4154f40a932ef7ccf0c9e9ec4b1622e23e679094a3ff3a6b5adec366"
