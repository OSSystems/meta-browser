# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "51f4474043f91224e16cad3484e768b3"
SRC_URI[sha256sum] = "ef210db84f372279c6032dbbbad0de011383cd6ec6f2896c970ed2294f865338"
