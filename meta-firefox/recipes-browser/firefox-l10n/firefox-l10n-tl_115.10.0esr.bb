# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "348c7afbbf9dd266c06875c1069d9e52"
SRC_URI[sha256sum] = "9933d9b2746476bce02bfd1c5e17e81f29d876f9405f3bc2f313a962c3c64366"
