# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "364ec19263366dbf796d486cb1570272"
SRC_URI[sha256sum] = "44edd15b47996bf3bc7e86e4b3948e1827e2f92f396e65b6012830e32a9b933a"
