# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a567ef66988d26435fe0f8fc5ef8b0b2"
SRC_URI[sha256sum] = "2a312a67d9e768e6125d9005dc1c9ed1bbb4d95358e833eacc3891c6392c8d6a"
