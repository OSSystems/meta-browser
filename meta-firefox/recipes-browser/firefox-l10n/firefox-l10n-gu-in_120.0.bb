# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a376a74a306d181cc30a3b5d0edeb3fe"
SRC_URI[sha256sum] = "64c32f7a8e8a47910cba9afaf0448fa9f08a8ae61142cd7d84e66192a9ca4f2f"
