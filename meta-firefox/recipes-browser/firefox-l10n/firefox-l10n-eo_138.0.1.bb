# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "296f5df27679ec5208714314547449d2"
SRC_URI[sha256sum] = "ac0375d7a9823133b9337dd20b4577cad903d622982939efd676528dff225640"
