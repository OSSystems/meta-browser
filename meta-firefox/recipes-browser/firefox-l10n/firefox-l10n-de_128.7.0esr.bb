# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7b801f08930857ade0abb5c6a6e06b60"
SRC_URI[sha256sum] = "7cea60a68873f1a3e42e8aa63d60578871a83a3a8c5abcfd9a2a448e4b27b113"
