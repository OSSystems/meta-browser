# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6e33c22d536ec83559d6d9ec1d41faf3"
SRC_URI[sha256sum] = "5a7d34d4c4010b2164cc214550dc5e259424e035debb1884fcbdb702ce7048dd"
