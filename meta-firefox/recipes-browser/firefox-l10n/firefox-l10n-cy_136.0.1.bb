# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "113df6193bffffeab36bb623928725b7"
SRC_URI[sha256sum] = "85ff3a13e0663b0d23ed6e5c8c9e58eb42d448df689cc552058220213cc118d8"
