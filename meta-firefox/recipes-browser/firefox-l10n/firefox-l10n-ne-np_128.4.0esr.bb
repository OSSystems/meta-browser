# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "26acd263160df9614b94655122f8738e"
SRC_URI[sha256sum] = "5c4e57d59c8b6ade51bfb90b3e1565f0df84ac1316f7d22c5da7bb8dc59f6c09"
