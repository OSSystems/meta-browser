# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "74c206adbc8ce1d53862067b8c55fd34"
SRC_URI[sha256sum] = "f981c7b5e4f87972f608f9721a9c5ffd4fce38cdcca4195abf40fbd1d43968e5"
