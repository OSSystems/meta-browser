# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1dbd330f8a1d4d52795b19232ad325c5"
SRC_URI[sha256sum] = "080e17e81988516877991fbde900c00a34488929855f2fc5341fdae8ceac8129"
