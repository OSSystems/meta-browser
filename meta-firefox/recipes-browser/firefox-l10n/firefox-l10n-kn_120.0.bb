# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "06339d7def72fe28c6b256a865f79927"
SRC_URI[sha256sum] = "4ef0c1b2a8df6294c1f222757bcf8b5be27b5ebc6cb38bc3ea0558623093d48b"
