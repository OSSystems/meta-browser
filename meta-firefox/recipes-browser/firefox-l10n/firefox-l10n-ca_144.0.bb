# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9d0661ef7e06df68658872d93bcbcc6b"
SRC_URI[sha256sum] = "e43bffc3bf15a26bd455543aa81b6fbba5b926508f451b8a5fa64b0c24582049"
