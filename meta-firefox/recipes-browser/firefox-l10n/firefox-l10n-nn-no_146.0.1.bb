# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "179a9c89cc641f81aeb8b5e611939946"
SRC_URI[sha256sum] = "09adcffea060125c3900b227a65ad527f0195e183a94f5d7b9555dbc9c94abb2"
