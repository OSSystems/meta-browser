# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "818be5e79b1dfa25b9c69e66f7eb4acb"
SRC_URI[sha256sum] = "e15d9a79e79655bc828b340a77fc6b902633a249e7ab8199661fe978b97a941c"
