# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "90a762eb122b7781023533dd8d6a3b72"
SRC_URI[sha256sum] = "6a819eaf5254863934c116d1f0442372bcc5d7bc3f25057d3b827d3dd27f9181"
