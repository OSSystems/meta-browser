# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cffbab07da3df6eea47e33e66f505ca4"
SRC_URI[sha256sum] = "47c1ce9f00317824c8501aa3a690f4a19da7ba6f19657248a465924b39a6d2f3"
