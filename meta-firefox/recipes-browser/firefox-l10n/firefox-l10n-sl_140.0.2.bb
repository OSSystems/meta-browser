# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "492c63bb4f8088b0efd19a540be688ba"
SRC_URI[sha256sum] = "c5a0ca40e7ba2ed27d107fecebe7f6f866165c29bdb0b9dd6913233681067f22"
