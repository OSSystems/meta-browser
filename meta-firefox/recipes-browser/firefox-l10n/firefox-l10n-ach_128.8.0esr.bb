# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7c44bd1f290ae5d3ba2ae36b332e6057"
SRC_URI[sha256sum] = "9fde7238c2ed713d2e66bb6278cf4b16536eae379a03596c885a750e0e8ad55b"
