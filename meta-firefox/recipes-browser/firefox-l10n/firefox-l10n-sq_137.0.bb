# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "79c6c26cb633f16d82a2479b8f0e0bd8"
SRC_URI[sha256sum] = "6178d73da3c9882eef70715ded77fbda2a66ea9080cc0abbf9df808fd72830cf"
