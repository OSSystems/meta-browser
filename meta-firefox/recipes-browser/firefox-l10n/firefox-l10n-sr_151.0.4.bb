# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "b81728c47c01c47f5b3f1decb00384c58ddd6017235bd0f13ffedecaa9b3a340"
