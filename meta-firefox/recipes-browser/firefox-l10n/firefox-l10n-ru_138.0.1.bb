# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "152aa99c3098de700245a2d42cb31753"
SRC_URI[sha256sum] = "2f2534fd0c2d25efbdfcc5b7fa40e94119b13a97388b0529f40a6f6d3d99370d"
