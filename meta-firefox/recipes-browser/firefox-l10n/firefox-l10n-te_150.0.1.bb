# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "712753984c873a6c398e4eafd67917c1fa3f03abb97f88b750fd2c9610f85558"
