# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b57536d7486384f435b796da75c4aa23"
SRC_URI[sha256sum] = "6f6b5a1a5d53ad6f2094bbe296b8f61efa8cf15a22ca45a579de288b7b8a75be"
