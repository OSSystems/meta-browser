# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6d9f01bf8458ba61abf178447696d40a"
SRC_URI[sha256sum] = "192f4727a274791f0b7a87629053eebe1fdde843b3aaebf904abe4b644e42b07"
