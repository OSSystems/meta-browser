# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "60fa9fdca78adc4c7a80b8ee4f5f9172"
SRC_URI[sha256sum] = "6f20c94abd479b5512cecf94d76e7b26a80183f98cad3fdfd2c79942f3c91bc8"
