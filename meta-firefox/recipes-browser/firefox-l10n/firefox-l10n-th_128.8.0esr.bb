# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c28844a083dce000a9e6d3882bb2c866"
SRC_URI[sha256sum] = "fbf07b897bea299aeddcb6d9aa06cdebc189428e6fa8d7221d45c8172e011b15"
