# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4d71eb4150531e3320e8e49a8f8fa307"
SRC_URI[sha256sum] = "98d32317565e302f77482bf97eb090171575724c805d746e343f85533a110479"
