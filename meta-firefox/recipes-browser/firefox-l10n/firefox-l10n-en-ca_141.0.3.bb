# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6cf2e5fa4eb2bd6e0338cdcb69a6d65f"
SRC_URI[sha256sum] = "aedc1ccfbab806dec6e4c1e74b966b796d2b90d8a81805f6f90f72613d5596a1"
