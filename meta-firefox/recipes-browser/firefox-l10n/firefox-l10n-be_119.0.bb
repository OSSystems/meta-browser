# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8e57d7cbd32f25ac8230d53af1be6871"
SRC_URI[sha256sum] = "0ae1dae6a54550db6043d40ed9db0e1f6d6407f5348282ecfd06a39ce77666b1"
