# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "30dc71ba4250a5a4fc7caae79efa07be"
SRC_URI[sha256sum] = "5b76067e67c87bfd6605ef61ab88db4c17fda48a824b6b593f26d7de11c76646"
