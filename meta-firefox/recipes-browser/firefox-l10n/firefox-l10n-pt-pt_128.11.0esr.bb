# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "87d8e7c7b44cb46eb526bbc02cfc6360"
SRC_URI[sha256sum] = "7c740e50393131136615e3fb74282bec497d7cdf4e20f9ed9a4b3700a1a56807"
