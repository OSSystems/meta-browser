# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "593b240839bf0a2599189842c1f34db2"
SRC_URI[sha256sum] = "ff3584fb524ffe69d10b0b1fc94d24c143b6304b2ad511da439245cbafc34ba0"
