# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ff9d1dcd934c8d8fdf898b490546a653"
SRC_URI[sha256sum] = "00f6b138bd39d4184815dc5c11f6d53642e5e0f3ed87c5426dfb5abbd0dfe823"
