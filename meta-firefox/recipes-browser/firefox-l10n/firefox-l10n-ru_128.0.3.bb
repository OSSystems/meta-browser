# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dd2730cc32e8fb643471392cb502851e"
SRC_URI[sha256sum] = "ed62a31da1dd13ab73ab43f682650a0d9641fd8546bd71237181d0051ccb7fc4"
