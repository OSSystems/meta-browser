# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "60bf45243b1e9207ba1182e6e9e43471"
SRC_URI[sha256sum] = "47ae149cdfcb91499640e7470825a3812584e7f8f65c50d72faa77a111c19861"
