# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "553f101034c857cb69bd7bed459c35e9"
SRC_URI[sha256sum] = "6b7dc2920cd684337ad9d96d29b3075a702c162b4936bcf501992f30576f0152"
