# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "494b039a7f682d351f3aafd4a405c498"
SRC_URI[sha256sum] = "a1d5ac3bc2a5aff407d8afad3c0a69bb5fcecb12480ba3758e2f514f655fd46d"
