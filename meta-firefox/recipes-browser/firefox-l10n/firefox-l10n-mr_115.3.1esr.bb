# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6ebb81c584bd0f1d5a244239c76576e5"
SRC_URI[sha256sum] = "d1aec9b2ad708454041f1ed3c55059dcc4d69a7cc49f16f61076abf358b1bc15"
