# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5690b606d9f00368b0f14716651d4694"
SRC_URI[sha256sum] = "2dfccb908ece0ead756b6ca58367dc799e1bd34accf240ceffd6f94ff41336ba"
