# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8b2e1fe0ff82fa0c3297eaff1513799d"
SRC_URI[sha256sum] = "13681a291df845b39a822f388c9568dabd44214cb534d20bbc58b497857a8919"
