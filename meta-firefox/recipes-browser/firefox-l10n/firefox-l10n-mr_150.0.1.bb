# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "11bff8160a91ea58a6b874d850373d90ad0a40cd9ee105c63241ee8fd3479c4a"
