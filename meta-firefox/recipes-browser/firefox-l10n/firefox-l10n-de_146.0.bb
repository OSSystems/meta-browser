# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9991c9eebfde5e12dcd8be55bef527d2"
SRC_URI[sha256sum] = "6270ddf8127de73de84914eebc6d0dfc47bd5c222a4e8171142e1204eb74f039"
