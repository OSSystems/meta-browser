# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1cec38f9e205c94a98ff5a25df0261fa"
SRC_URI[sha256sum] = "e1317d4221a989801144ebdb1ada1cfbb2ab79788f08eda4f151628ad8f356fb"
