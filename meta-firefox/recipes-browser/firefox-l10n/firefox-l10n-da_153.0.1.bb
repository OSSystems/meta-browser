# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "5491a8ff0bde5ef4c378789c9908ca899fe42c2582e0f1d9bf4a24780e54954a"
