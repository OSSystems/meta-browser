# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "eabf0405f5cce1579e31760795fcbf7dded41b51fd7f1b7913763ecd435aa204"
