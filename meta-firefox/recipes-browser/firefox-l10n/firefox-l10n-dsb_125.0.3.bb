# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6ba22fee03ad1ee38523aff098d8bbb3"
SRC_URI[sha256sum] = "106a2696f65a6eacbc2e1f0708742bf2eaca5962e0c5c178c0a62ad204c36d38"
