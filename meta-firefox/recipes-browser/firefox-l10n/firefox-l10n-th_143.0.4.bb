# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1c3173e03509e31084f6f8e365c7c131"
SRC_URI[sha256sum] = "270a66335629e76969bbab41f36a5c381abe8362c352bc825a3b0f9a7c7c407a"
