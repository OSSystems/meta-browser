# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "169059032b6d084c0133833b2825abdf"
SRC_URI[sha256sum] = "c0bdb22e0cc873edf06da3ed184ead73e04b858d54b28c6df0c78dab5e1c97da"
