# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "06562b92be2dbd5028dee479dd42f67a"
SRC_URI[sha256sum] = "f7b910b8c95c5d27430e90fdf6087763b831bca099f6c426e55de11a715e03c6"
