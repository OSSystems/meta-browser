# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "521fc6eae9fa890915c491a394a91f45"
SRC_URI[sha256sum] = "4a7089aa8115c6e67b4ad1c69f44f69e608bad1aaee40c4dd3d31a10a340fc22"
