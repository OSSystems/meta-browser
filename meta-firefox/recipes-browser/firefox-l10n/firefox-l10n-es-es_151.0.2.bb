# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "8bbce00c7ce8d31ae5bce2c9af7fa5b4ca980d63778b1f5c98cc3ebbd31a6bb3"
