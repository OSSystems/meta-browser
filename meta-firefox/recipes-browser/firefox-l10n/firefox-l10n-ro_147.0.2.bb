# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "66a23aef815104948bb873b9b60394a5"
SRC_URI[sha256sum] = "6ef1f21da7b2b4265fa29e02efa1adb935cd565c57309849f4f11d33c9121edb"
