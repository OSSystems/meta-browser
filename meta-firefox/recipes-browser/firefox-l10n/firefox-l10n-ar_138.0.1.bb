# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fc36dff7d825a6ad4b23ee9cc0a85f98"
SRC_URI[sha256sum] = "d2048e47ca52e72e294c78539f743edac621f32942f6c1c2c9848bc0c7c34905"
