# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0a7bb2415d819645c2d5f9dcf1aafbce"
SRC_URI[sha256sum] = "5d055ce3978eed5e6d01190286a93cbdc0e4aea889e211fdde606fc9b3dc1315"
