# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "46c3f8daa981c292914adce1900c14c4"
SRC_URI[sha256sum] = "7646538c68731b3ba56ac7ae7e79d1bba076c85b467a3a975b5e9fb78473a341"
