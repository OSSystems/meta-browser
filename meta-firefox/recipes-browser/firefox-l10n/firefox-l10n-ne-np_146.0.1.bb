# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bd314ec8f7cf327835819a4081e34aa0"
SRC_URI[sha256sum] = "f6c6c8dfd0f65d0735b9b0c849e3068b32e95cceb1e96fa72ec8722ef40fbb9b"
