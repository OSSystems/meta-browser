# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0f9c9557133301cf3438948df91e8380"
SRC_URI[sha256sum] = "2dda0dbb2a536d1b2c4ae423436ae238f2958f2cb0836e623c45dadd49ed56d4"
