# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5fedefc8b50a5e2a9d1fe4daaedfa1a4"
SRC_URI[sha256sum] = "b43176b53fdc3669e1501becbb900a99744163b4af099ecefea2d9cbf81f90ef"
