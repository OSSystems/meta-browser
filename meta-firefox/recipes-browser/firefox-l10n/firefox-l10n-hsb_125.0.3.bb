# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e0584158a9c3fbc760c339c5d400db9e"
SRC_URI[sha256sum] = "95561dbabaa563933ea022d30642d17ff2368f6c5eb30e7001c13347a0b8d92b"
