# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0e1fe82d1951385ae618b9b3b4d2d26d"
SRC_URI[sha256sum] = "34b1ddc03dbfb9e9bd2f940fc2aadc988807e92147106d11ccd873e99dd40075"
