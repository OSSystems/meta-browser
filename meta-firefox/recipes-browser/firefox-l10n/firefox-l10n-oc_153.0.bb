# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "f6d1a6bbe4c87849bc8c28d3ef00699b64a3b01ac64e4bbc7776b53f246184f8"
