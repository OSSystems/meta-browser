# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f8094050f801ba97461178d3e1fc4f59"
SRC_URI[sha256sum] = "a3d0478c121f24a6f141c8652345b83b2052c2a7509f78e4afb443975405ca1b"
