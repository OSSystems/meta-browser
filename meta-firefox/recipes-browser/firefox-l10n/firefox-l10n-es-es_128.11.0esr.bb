# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6adeaf49a51e1bd00d42e3ab7ac99256"
SRC_URI[sha256sum] = "85e354e5338649539f378b61e8dcab5666f9a0ec330aff1fe5eb15f7b2da02fc"
