# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f258966128380f775d2b6d8b18b979fb"
SRC_URI[sha256sum] = "beb8652de8a9964ff95a09db52d1639dbf2d9d8c72f3a041ffa2be8adc4b2c1d"
