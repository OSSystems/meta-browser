# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cfd8686eaa5ee20e42a0c82332c22b08"
SRC_URI[sha256sum] = "af47f7405f81124bdc5e82355f56156ce201f8cec5210180d494ff05ee6d4777"
