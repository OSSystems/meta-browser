# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "83c8004f5de64788fa5611dcf504b05c"
SRC_URI[sha256sum] = "ac536a8b06f757fc56de6d00a29ee52e28b69f58f158d13dd59159fc72519d89"
