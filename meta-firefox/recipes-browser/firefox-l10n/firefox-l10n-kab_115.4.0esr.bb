# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "88112e4683f865bf095da62e366f1276"
SRC_URI[sha256sum] = "220c85814db60c4772925af1be83e015af33319f49c2b78b6c6eb214f23485e5"
