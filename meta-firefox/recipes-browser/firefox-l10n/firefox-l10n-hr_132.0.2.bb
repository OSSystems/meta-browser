# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e9d08eef8474f2e013ddd4319af002a5"
SRC_URI[sha256sum] = "7e4f17b48fa2e2ea2be0a197d03dbdf42c10826d8e4b6b3849ddd643314ae04b"
