# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fc7c706bc326e31bda5df384c4de7061"
SRC_URI[sha256sum] = "44a45da273273c8937112f56e151ebd69045f6705228f957a6e41780c592c9d8"
