# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "efbdedd2e503344daa3d69236e3ba676"
SRC_URI[sha256sum] = "e94dd53a5c5b5f23c2cb04ac927d88c022be37fee6e5059d10db80305747b7a4"
