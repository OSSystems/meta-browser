# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "87a60850eeab04874cd54b80c7f6aa70cc4c904027d331d3731aa063bc1dd143"
