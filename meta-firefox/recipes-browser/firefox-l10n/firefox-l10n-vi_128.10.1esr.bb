# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0048b91a8b58e559310d4ee1d35b161a"
SRC_URI[sha256sum] = "087b973cce6b6d4e14b4e1512a8218ebf3572650da39d645676029e0636cdb68"
