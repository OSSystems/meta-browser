# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0aa3e7b439bae1e7036df2df08170196"
SRC_URI[sha256sum] = "3f111a4ea6d3795b80d80c5dbe04e5af188af71ffd96d230d270e9bd53e37d12"
