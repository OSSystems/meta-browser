# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "1f4913a15c9644ea2d80d876b67b8983c6f5b4818467a5b7b249c6df4d0ce2d5"
