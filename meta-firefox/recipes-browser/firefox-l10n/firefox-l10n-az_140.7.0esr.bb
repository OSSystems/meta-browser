# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e78234e7213abaa5ceef67f7745bb33a"
SRC_URI[sha256sum] = "68390dd7f4353fc2a802f44fe9428e10c07db185e05108b42116b087b7e1733d"
