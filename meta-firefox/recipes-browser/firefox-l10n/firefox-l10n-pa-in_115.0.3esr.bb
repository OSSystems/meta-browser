# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fe3b0df6fb82943f12e08a0d25deb035"
SRC_URI[sha256sum] = "4038f6a0e1a16fd8508905b66c08cacc8517f5a9a70a933dff3b71a8d4aeb0da"
