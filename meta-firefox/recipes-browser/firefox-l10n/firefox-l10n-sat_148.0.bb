# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2977b920e59a7644b6d23c36f4a4d277"
SRC_URI[sha256sum] = "19ac3a8a49679141aad7452364d5adde318e93249f9eedeb565daf19ba86b3c4"
