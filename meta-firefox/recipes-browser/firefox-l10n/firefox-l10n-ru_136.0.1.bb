# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6b94f41e3c24755b53e5dda37525be7a"
SRC_URI[sha256sum] = "3653177a49392cd8694355f91607b3ab211c4cce571adf9534100d4a26ba00d2"
