# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3fb1c3ed7d8990b0f0fd8050a0e0e63b"
SRC_URI[sha256sum] = "44e7adf15d18283c4a3bfacb018e77d9fa38ae65cf5bcb34ad3f98e45dd78ee4"
