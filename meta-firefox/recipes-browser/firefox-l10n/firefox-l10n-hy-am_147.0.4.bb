# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "48b529adcc6613a317a91f8b9322873b"
SRC_URI[sha256sum] = "24b9e880f2147151303cd289e50d966964d623302221760b94daed07772f1a60"
