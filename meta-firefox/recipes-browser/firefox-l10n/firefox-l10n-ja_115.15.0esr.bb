# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "597d323bbaaf64518175d9c8202001c3"
SRC_URI[sha256sum] = "3daf41ab5a6073c94f489be1ef8933be7d2822fff4886b1530021352a16eb092"
