# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "cd93fa2eeaa2158d58133eb1999e37948841380141a716bf1a999b212d6fceef"
