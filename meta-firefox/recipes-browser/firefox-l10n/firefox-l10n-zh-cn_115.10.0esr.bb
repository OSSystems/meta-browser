# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "923df7fa489c7107aa1fe3fae96a108e"
SRC_URI[sha256sum] = "ed5d9b2e77826d34d2f681064f093d567db28bcc71e80c7fb36f7d82f466e796"
