# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ce27e63730dde767b1acc7b3680fae4e185482d9d709df845f716f09cf172050"
