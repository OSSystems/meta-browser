# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "abf750037989117f8d153e856e33b231b8d1a82ddc8a64a47356f21d4162fefb"
