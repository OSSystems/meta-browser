# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2b6799f79934e7dacf8fa865ea5a596901854c9c8659ab8dcfd185706ab8a86a"
