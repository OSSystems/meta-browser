# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7750865730831b5a1734d52bb12c41ea"
SRC_URI[sha256sum] = "599ec437b210f14c561b6f091138b6e82bffefc6b889e8208b121ad80f570d73"
