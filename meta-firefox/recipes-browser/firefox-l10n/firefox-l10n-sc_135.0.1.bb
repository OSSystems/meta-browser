# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5e7cfb70a5086655cb289fcabcc0bf52"
SRC_URI[sha256sum] = "0bffd6c6355d5a7d6701564d91adb8e4818503f56d815f5f620adfcfe1975b3b"
