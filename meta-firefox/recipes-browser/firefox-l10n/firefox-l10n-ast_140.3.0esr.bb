# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aac3dfa9bbaf50e1d62774e17def64ef"
SRC_URI[sha256sum] = "6d06134e560320ca6b4a86ce2bbb1a05fc3eb3ba18ecc7554c2ce20a8b0dbe5d"
