# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a72c47a06547c6ebd7bbaec71b73abb3"
SRC_URI[sha256sum] = "fda92b3331ea9a7e9c9562a463421eb17e99f1bd48301394a95598864420b888"
