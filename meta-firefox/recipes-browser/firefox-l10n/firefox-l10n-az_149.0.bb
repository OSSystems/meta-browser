# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5654ed1a22dd9f314845926c39c0738e"
SRC_URI[sha256sum] = "7328c225058fb2461d324fc39d4be7accf92a2f6cb64b6c067bc431a942e3f06"
