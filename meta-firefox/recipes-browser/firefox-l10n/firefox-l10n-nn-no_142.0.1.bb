# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7021a3c910dfef1a245080e9151d9286"
SRC_URI[sha256sum] = "3d3a067a070090e40fd2b5e4ec947fada5d363a425badd455f2411acb961e5d4"
