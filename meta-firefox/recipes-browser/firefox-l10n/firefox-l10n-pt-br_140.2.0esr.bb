# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c71a240ede95d820849ce3e0d7aed33"
SRC_URI[sha256sum] = "fd22140f77cc60d7de4896dc8b42dab720f35c438bc1b373e51043663ae0c400"
