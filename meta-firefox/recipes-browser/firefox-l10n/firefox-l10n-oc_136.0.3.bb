# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "995190809783a6c283271b48db33c9f4"
SRC_URI[sha256sum] = "e7cad9379715b6701212baa7a4fdcba39175510c27a2494bd52bfde9cee52f0c"
