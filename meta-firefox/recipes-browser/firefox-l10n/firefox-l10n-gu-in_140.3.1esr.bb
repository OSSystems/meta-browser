# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5b1087a0a2d534939036aa28a2fe05ec"
SRC_URI[sha256sum] = "42629244c5c24a2b5d9a1e00e874b540ac39618273297c1e9e8a982a674fed97"
