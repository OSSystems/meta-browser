# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "53fdb38b69e1f294d0578427efc85d42"
SRC_URI[sha256sum] = "e6fa24d115ff035ec4aa55eb42fc3fcc8ad35c20783badf27cc5bf1f242d5b3d"
