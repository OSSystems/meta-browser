# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "54b6915d1c3e47655ab20623f2d94cd8"
SRC_URI[sha256sum] = "23dad6c3fe2e20e3f0c53614f8c0b2bce852ff5970d4bfbe4c028642c6b4c8a2"
