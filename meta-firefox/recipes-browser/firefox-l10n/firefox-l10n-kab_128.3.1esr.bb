# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "541ace77eac44f02dbeed7c62be7b9fc"
SRC_URI[sha256sum] = "66bf3a647dc9b47d884c98b0f5fbabac19929c8b9baae8ff04ec7fa193c6e0ab"
