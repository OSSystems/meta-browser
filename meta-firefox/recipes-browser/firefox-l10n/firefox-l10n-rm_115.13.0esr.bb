# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7d48668767c9d49d6d68a34057f2ce89"
SRC_URI[sha256sum] = "f8633c58d00406ac86870913946d960b4a547fc94227babf9946c83c8838810a"
