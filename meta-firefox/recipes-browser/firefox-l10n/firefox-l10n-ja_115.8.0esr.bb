# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ae0753c00a986ba27277e1778a91bbec"
SRC_URI[sha256sum] = "55fade8f9f8b5926b542c5db12a3dbf1df9a4cdd6020308b4669ac3be441db73"
