# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "664b11be3c8fc7795022163e4b2a5997"
SRC_URI[sha256sum] = "5e2638d667f049c22dc5b8afe055b6febb8b5e6c1fd6c914116a04482683aa25"
