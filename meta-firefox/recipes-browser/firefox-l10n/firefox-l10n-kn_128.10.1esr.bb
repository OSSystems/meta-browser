# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "efea4db0551b76557a9959110e8f2aa6"
SRC_URI[sha256sum] = "00e6030ac7c1155c89e84c9f61778af2d4bac5005c7f18558576ace1cc62aa32"
