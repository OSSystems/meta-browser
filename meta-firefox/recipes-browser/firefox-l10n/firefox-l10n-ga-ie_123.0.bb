# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7841e1e687658b2cc6f2832a86283e12"
SRC_URI[sha256sum] = "9f28c9e1bb3c30775a9d8c7ea4c470788e0c96d2f055a2a144cb84fb0c8ade8b"
