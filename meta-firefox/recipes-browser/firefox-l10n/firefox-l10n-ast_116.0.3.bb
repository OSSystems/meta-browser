# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "99eb26e0dcf2573193599bc69c10eddf"
SRC_URI[sha256sum] = "aff3e58896f209b49555de24f9fc56affa0615af4a1ec5d0c4e86bde28bcd39f"
