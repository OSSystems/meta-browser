# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8569ea06a9e295c390b0ed2528e52daa"
SRC_URI[sha256sum] = "815ae0b81cf77628535653d04f5656bcb6eb5d2de4f184b08b9cb95781e46678"
