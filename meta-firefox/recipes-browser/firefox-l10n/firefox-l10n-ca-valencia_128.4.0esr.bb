# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8c04abf275de91a18e15cbef01c32389"
SRC_URI[sha256sum] = "224e67320ad3c7d7a21111f096bb5e96aef62496657d9eceb1fac183480c594d"
