# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "eda84d974cb06f12c0b998fcf3d4b4f8f3a0bd01c6ea14d3fa6d219416cd76d0"
