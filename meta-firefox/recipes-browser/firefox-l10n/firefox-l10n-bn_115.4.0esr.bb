# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "59bbed31b59371eed4657182d8881c49"
SRC_URI[sha256sum] = "9242f40f380bd3489a51f4edca62efed0dfd0af04fe989f47fec7c4d6dc4e032"
