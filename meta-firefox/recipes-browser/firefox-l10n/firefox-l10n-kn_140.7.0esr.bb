# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a04ea852dc60d5a74ab06661ae1205cc"
SRC_URI[sha256sum] = "11b7f7fad4ea5547e300a84fe1683404386c3f88cb0ea8f9c63376a1507f99ce"
