# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eeb871269ae19c63d0cd100b70cddcd0"
SRC_URI[sha256sum] = "96d01d5439839ca0e6b69642e05d70e9498e1f33a541e0b55f571a4e6568b0d0"
