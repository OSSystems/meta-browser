# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "4d95c0aa505c5799181b21f5c81fb5dc2603dfe4d4726a7969c191a4b656e53c"
