# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8c4c67dcc1a676664bb65571d4086e6d"
SRC_URI[sha256sum] = "1eb53a7d86cce901ee67a23d47115ece45c0d3e165a0757d9f6270743461d376"
