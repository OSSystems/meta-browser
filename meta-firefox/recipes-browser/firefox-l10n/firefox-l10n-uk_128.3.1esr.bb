# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9e8c6d405a6c82001a100a0e2829106c"
SRC_URI[sha256sum] = "971cf1ce3019f90eed279ee3d816b88c9cb2b30a9c55301ad50437a94075a8ca"
