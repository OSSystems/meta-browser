# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "329593779ba61d7935d8780f69e18f6b"
SRC_URI[sha256sum] = "6d983843b5a31ea1121a458676e6d64ca5ce18c0b87a15a1c7f76a5126509b8e"
