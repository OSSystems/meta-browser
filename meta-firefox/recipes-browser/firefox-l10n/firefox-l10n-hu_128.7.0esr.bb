# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d57980da1c99bea0443ead8908e0fe8f"
SRC_URI[sha256sum] = "04190c663fe5c80f0a5a888d9552d5b36fc0ec87630da0f84116e04994b655b5"
