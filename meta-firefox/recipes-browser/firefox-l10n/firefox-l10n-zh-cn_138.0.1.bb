# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "83fe2e3c910bd7594536cebbbef15b76"
SRC_URI[sha256sum] = "d2c257d56ff37d2a40f3b6185cf7cede39516af3fb4ab46e2b7790223e4a08aa"
