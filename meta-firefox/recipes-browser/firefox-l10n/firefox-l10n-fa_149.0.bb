# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7d7f9b51a923243a8e49293e0e63238a"
SRC_URI[sha256sum] = "6074cc22f67c10d856e6206568e3510af12302bf64b556147d150835d91ca0f6"
