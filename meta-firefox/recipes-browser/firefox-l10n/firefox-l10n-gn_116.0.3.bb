# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "65cb095568e7e07acb86a0368567dab5"
SRC_URI[sha256sum] = "4c54735d01afd5a5b4131b5d1eb5e01f2753c725da8f685b620dc4beeba8a54c"
