# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "df3388b600f63187e6d0fd6e52992193"
SRC_URI[sha256sum] = "deaad0ec43806279805bd6e9d2beed85e23bd1f25fd01e811a7758a0f600cb41"
