# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e851783dac34541c3d5b3eb57049b70f"
SRC_URI[sha256sum] = "fe16da30d59cb8d145fa3f94b989636572f25184ac9896f3adace51704305852"
