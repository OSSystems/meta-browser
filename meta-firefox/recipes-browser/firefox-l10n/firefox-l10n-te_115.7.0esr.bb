# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1801ca0434e835f616a1fd6844bd6b48"
SRC_URI[sha256sum] = "c38ad7708333f42d1e45db2601b70f22a609f83ad635956c94c1309e57fe24fc"
