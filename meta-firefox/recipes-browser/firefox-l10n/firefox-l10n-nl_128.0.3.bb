# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3a954a85489c8571e00d3c1926aa41bf"
SRC_URI[sha256sum] = "fce152bb74668a80431e851fef395ae336b75ea62088ab16f5cdcdd7a02b9672"
