# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "99614df4e60c5b8e110c589a495e6c94"
SRC_URI[sha256sum] = "445524246aaae61c0654b90add7cca3a693fb5a238d3944147efd064d52bbb55"
