# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cb300068d1df9a1514197ed2b93479ac"
SRC_URI[sha256sum] = "ec820e3cb7df1b5fe8c79253e5394986609b49ce2ce61bbd956b8b5779adfbb5"
