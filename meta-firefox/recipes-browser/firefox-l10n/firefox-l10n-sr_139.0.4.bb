# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4f8b21eb17b872e51cb5e21ee5ff7c02"
SRC_URI[sha256sum] = "37299357aa58bb59b0666714e91985c1e2537487b94fbf4c46ad624551f091d5"
