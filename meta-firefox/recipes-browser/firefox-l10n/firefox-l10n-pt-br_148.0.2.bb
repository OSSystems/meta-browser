# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1a0728ed9ccf24e346b6291471e2daed"
SRC_URI[sha256sum] = "40ac6f4ab4895d3a03b3a806d2df1da53bdc2f530114f6da8f3968bd4fa96b68"
