# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1c8495d1acc438f2a0dd8bb578fcb75f"
SRC_URI[sha256sum] = "085f38ab0ed7b44177ca1441850f1e96a9b7e3bf2f31814c664ca3525107a2e4"
