# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "122f0af6c2331cf15cdf420db3835444"
SRC_URI[sha256sum] = "d26a92e96ab0de1e4e5d7135821a8b59ca0e91c4a5e554fbf0f08035e018be5a"
