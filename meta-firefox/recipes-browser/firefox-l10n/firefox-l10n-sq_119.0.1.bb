# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c9501455bbd80d1d419edf6e72c7c21f"
SRC_URI[sha256sum] = "bceaef532ca9095d720911286687069b324771397a7cedbf9b04009f7b7b5531"
