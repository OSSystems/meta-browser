# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cbcfc9f7df9ac008007d695df8bf1f4a"
SRC_URI[sha256sum] = "c0535c00a6b00f7fafa7f2f1c667ca7070020febb17beded6b11b095cdc8a316"
