# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "95b1497fb98309a682e10905a4420de1"
SRC_URI[sha256sum] = "880677865559a81cbcbe331ebcc31b02a644e4d0ad94ff77813b067a4d700391"
