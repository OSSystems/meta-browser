# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "521260367349ad5e50732e4287497ad3"
SRC_URI[sha256sum] = "dc2e297726efc808942102534f78af2ee1a8b53b3fb2a9594d41f4eb361ba19a"
