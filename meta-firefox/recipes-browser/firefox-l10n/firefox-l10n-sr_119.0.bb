# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "72b2248d2d3e0a363fa880434d7787f4"
SRC_URI[sha256sum] = "e706f7fea65cf83b37f357b56a846a8a95739d909cb198093072d155bfdefe9f"
