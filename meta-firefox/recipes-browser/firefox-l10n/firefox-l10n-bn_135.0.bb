# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "08b52d2ae77ce2ee968979f04d85145b"
SRC_URI[sha256sum] = "656811f6b4cd4c9c324761b903367ad6d9e013fdc388ede1a98b7d5e4fe0ba34"
