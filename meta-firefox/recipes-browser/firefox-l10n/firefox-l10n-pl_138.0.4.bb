# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e9cee50c05aa528e54d6d8feec1d00c7"
SRC_URI[sha256sum] = "32b68adfbdeb5d91a0d6545a47b50baacb3a1dfb252f11a3b54578756557a38b"
