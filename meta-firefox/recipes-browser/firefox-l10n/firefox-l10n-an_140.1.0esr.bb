# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3f42c8fbb59ddd94a16bdf57b0638bca"
SRC_URI[sha256sum] = "c3a61a75fee2c6565ea2e8ae3f2d2d40a77eec1b35e69ed8877a845378caa591"
