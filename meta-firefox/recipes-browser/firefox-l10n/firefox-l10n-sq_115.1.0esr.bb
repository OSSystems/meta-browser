# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f45594fe296eb468c2be7542aa342584"
SRC_URI[sha256sum] = "b102ffe7b9cf724c7a58249a4b5100e1c13b344a633f53b043743d0486017e81"
