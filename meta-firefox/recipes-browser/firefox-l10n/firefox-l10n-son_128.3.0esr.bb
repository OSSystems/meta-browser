# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f7ac3678c88d512e787b256992ba2b55"
SRC_URI[sha256sum] = "66bd218cc6ab25e1ff7e9f02de75f6eb491676eff3fd8fc6a6799dc148683d98"
