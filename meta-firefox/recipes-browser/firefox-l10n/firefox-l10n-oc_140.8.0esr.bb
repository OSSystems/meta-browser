# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0bb0f0c9b495c83a6cb5a53d51326e10"
SRC_URI[sha256sum] = "3786dbf6802ad2ec50e7833501925a8788d7a136f3d276a90c4577d99a429997"
