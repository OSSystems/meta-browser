# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8498fe8c911e0c0c1c262e048bb28d78"
SRC_URI[sha256sum] = "098e8f28d74ee2ef2e3fe29bad606450b0f2b2a1c9fb73226ac523c7966ad0ce"
