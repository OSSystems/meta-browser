# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "18c6472a906453cb1a2c54656bac502f"
SRC_URI[sha256sum] = "14ea7f91480e19f7c8c6acef42c1d75ebdf7d5557f68221c04d956d764f3580c"
