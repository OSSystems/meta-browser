# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "27a6a61d8c3ce4956df7e6fad6ee4b78"
SRC_URI[sha256sum] = "ed08a5f142652873890783164cc4fd1a74fa80410c9a3a63b245cf758b2ddd4f"
