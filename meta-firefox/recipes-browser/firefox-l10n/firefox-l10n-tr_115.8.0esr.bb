# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1144bb18a302697aad307fd1f73406f0"
SRC_URI[sha256sum] = "855460e19536e54689a050fd81dc3860d8056edd5aa91fa213bcbde0cd27aee5"
