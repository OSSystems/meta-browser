# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6d4282704f66981f47ded136cbc1e87d"
SRC_URI[sha256sum] = "89f38aaca270649c1662d1379182e135db88c227ec9de1e22b32ca63ad205b15"
