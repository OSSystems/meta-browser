# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1fe2ce1f822125d526b4c8549864819e"
SRC_URI[sha256sum] = "8d61d081ea3c46a2512baf5dd407235a9e99d4ed23ff4179924aca3db741cd5a"
