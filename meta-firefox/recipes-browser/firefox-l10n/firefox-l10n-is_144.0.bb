# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a2e455c25299d19633eba2b287ad58c6"
SRC_URI[sha256sum] = "b2f263eb886a2a2e9b4a8df4828d4383d70a979b6c07fce4fd7d2bc55c2102ec"
