# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b97679b8022e7d266740df66323ad6cd"
SRC_URI[sha256sum] = "cca1fe6b959806fdc1ab20db4f5040373bede4e548eaf426c30452de6bab9428"
