# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8308fdd4c93828ea0fe27c19b22e7af9"
SRC_URI[sha256sum] = "d694e7cabb6befc963a7b3397dc30f6ec3f03b23b565ba4af069af685b35f87c"
