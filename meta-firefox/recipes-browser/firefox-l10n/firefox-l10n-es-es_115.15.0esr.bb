# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "75b021f8850441e1d7267cd39dcb2adf"
SRC_URI[sha256sum] = "dd4845ab843a6886432406a512858ba19e489dd053f0eee9dac14644bdc5a82c"
