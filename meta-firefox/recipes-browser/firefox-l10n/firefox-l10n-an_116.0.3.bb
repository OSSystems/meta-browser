# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a8ff0c70500efcfff1703b13dccbed0d"
SRC_URI[sha256sum] = "95a0950b2960582f525e257331b45bf86da78b2b975edbf59327fdb827200ed1"
