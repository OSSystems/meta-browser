# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c1291ab0482d9380e45ba2dfe1426745"
SRC_URI[sha256sum] = "9d0ab271b3650536de43c5757fa3cf9dcf8bc4dacabea029b3d8585ef0138a9d"
