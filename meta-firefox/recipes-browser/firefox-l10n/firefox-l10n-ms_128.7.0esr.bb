# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d5e35b9ced8de75c92c92f671145d921"
SRC_URI[sha256sum] = "7eeb279a46c6c22971552675fbce6fa78259440c3d812a855631a28cfb3b8d63"
