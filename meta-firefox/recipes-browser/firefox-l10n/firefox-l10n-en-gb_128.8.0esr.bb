# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1aaa4ac0d120297cbacdff732ecac020"
SRC_URI[sha256sum] = "0b77c09ac69013282164a8a11c6880c666242fe5ca79c9880589a32925115908"
