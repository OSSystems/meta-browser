# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "89f5e4d357e0611ce19e47d2db49516e"
SRC_URI[sha256sum] = "d981dfd568c773995623ce3dddbd798fce8f531f1dcedf139eebff759ce41325"
