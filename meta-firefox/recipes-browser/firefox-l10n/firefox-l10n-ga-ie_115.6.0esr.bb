# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "26863da02d056f272b732bc38a4f066c"
SRC_URI[sha256sum] = "5d8b60e7ea3e2957ca1118084028e4b962b02c09f3b2fe516921933194663aa9"
