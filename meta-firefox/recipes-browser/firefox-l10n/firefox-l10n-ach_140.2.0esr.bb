# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3ed4f815273dd3f94492522a51c22396"
SRC_URI[sha256sum] = "309d2e895607f695ece8505d110d44b3456d6e0da30e7d13e169dee696f11eee"
