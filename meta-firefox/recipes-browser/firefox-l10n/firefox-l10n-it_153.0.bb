# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2ef4e04f3ba97e6596e1f9e064f0090c44c2e7375561b41fc9f3d0e9a138c160"
