# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7b2792541f0c540cb6072ad3cd2e8b76"
SRC_URI[sha256sum] = "f22c96e5ff6c1fc9b51cef6636478128401a38eb07eafdbe359cc86d62c23700"
