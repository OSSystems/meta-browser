# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d18f2d9ac40169cbbed31c43bfa1e56e"
SRC_URI[sha256sum] = "9d86a0e264d901721cd4882c39454f7933853b5634036589c4417cea3cafecee"
