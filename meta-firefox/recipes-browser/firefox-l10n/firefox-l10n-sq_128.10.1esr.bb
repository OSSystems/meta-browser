# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "34239934f2164659312c0c3fc46f7d90"
SRC_URI[sha256sum] = "f5510e3f811639b8c0582f607ade0ce4043911649ce49723dac5cb74918730ea"
