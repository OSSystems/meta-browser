# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ce15afc66b46f96d2034fd369697224"
SRC_URI[sha256sum] = "e8fede255b067b3f165e2ae796b98037755c77b1e42a03b33803f63f415d60cd"
