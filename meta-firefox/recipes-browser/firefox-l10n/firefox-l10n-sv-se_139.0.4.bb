# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c18464cca28cc05358f7af2b890d19e"
SRC_URI[sha256sum] = "8a27f956480767a41559670bd496d10060d85f708313d779603bcd2df39e5460"
