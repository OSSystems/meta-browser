# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "de83466e9f34d13db9dbd64b65777ff9"
SRC_URI[sha256sum] = "a8bea53cd6d4a6c74b0a8546fd2ce5bf6cf5bacff6e73a8278556b0ebe2dc433"
