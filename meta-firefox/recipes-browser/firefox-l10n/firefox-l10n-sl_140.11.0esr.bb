# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2b152fa050020e1cb24fcca21c8a82884ceba14db637d337085174fe0dd48d14"
