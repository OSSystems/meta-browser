# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7c5884c641290b81c5073a8922f762c1"
SRC_URI[sha256sum] = "daca13add5fe804870ef50e4fdd204f0323406fa5602bab8ad526d8bf0906d37"
