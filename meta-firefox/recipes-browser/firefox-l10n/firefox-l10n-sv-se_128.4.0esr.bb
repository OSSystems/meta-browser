# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e067e341490f1535f95aa3cad60fdcaa"
SRC_URI[sha256sum] = "f51feeecf20e7f26ed2227614c50ac6260fde088db91cf0ee58d62cdbf357beb"
