# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e7db2d094cc559bd849275560a7df165"
SRC_URI[sha256sum] = "21c5529fdea09610c45486e97dff85aafca4078432f4c5061dc0c5670a0e53c9"
