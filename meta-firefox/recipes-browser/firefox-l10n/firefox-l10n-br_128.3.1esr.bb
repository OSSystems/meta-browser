# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e6a06748934d52474b85ce5ea7350f45"
SRC_URI[sha256sum] = "87c501ae8daecd95d52e0704cf1e370e67e955e5720bfa3b02731cbfb7af4f33"
