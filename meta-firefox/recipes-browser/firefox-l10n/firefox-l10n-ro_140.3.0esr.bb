# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "085d32f21eeeaec4c7c5d7c5ed387628"
SRC_URI[sha256sum] = "7680bbb95ca8a1568d5534868a59d548b5740222202560ebc298768d12acca1f"
