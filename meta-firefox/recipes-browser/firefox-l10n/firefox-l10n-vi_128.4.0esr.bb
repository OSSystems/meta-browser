# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a9f41f34df956ade1cbca47e47cca6b6"
SRC_URI[sha256sum] = "e02661a0d371a12fda46cd2e5619611fda7891f7a496cfef36fce1136ff01268"
