# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fc426dd706d978ca72b6785487612223"
SRC_URI[sha256sum] = "c16cc2083592b5654faeeeb4b9380f440a17558f02bfadb7d4f5a9a8f38f2fe2"
