# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ec29c355d0fd4f670ecf1e64e75f9a0a"
SRC_URI[sha256sum] = "ec78d5175f8f6d13ed201f5e3add97fc7bcc8bcce6e5ba9989c09d8e58a3bfea"
