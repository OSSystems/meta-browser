# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "47b079530f8ee136bb72828af3c800d3"
SRC_URI[sha256sum] = "fcba01cfc506383576f7ab645f06073010914fc3650ef9b5cf9da701c0256b2c"
