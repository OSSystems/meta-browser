# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "77ca04e742ae6f8f2b946790d6552af9"
SRC_URI[sha256sum] = "8b4c24d15fffe60c0bedbf2783df3509ff473ca78ececbe04feff45b7d3128c9"
