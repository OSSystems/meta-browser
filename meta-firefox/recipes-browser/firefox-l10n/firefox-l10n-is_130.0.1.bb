# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8852c8f4e6943ecd67e91bcb45de7d46"
SRC_URI[sha256sum] = "9bb9bac0d9dd5fcf9b33fab6b4177a9874c6fb17b342decc7d3b0f43b3baf005"
