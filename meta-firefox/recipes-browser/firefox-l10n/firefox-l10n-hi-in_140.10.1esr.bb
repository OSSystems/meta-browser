# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d9759f7f3e80286c047f0841e4f67bc2527877a343a9df1b48627e4fc0ffa311"
