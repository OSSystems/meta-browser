# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "06f967f69079653c2e92646cf62ac83e"
SRC_URI[sha256sum] = "1a769c1e5f056d9f6b1759268d54c0b670ae36a6c7e650da849d300a2f90231a"
