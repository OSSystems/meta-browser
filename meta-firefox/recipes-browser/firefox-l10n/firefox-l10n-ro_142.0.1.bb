# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d6ff04813612028079052aa9a182a974"
SRC_URI[sha256sum] = "a566cb9cc9c27b3b976c0d0a2cb23702651c7e125f6813b622edcc38f2d90d21"
