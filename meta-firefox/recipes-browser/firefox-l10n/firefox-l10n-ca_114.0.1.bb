# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "43f09887b230bd7f9fb572b23ba7dec2"
SRC_URI[sha256sum] = "1b5a6e04387e5a352761197daa6008f5ba36eb5aac12eb122cf1ab517661b42d"
