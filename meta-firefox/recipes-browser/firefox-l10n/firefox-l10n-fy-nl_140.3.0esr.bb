# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2471e24af9ddc5c9847400a9a6fa7673"
SRC_URI[sha256sum] = "6925b9325d6cbc8ff254aa36bcd57632adbbbeb15da7760b777de8e41641d8ea"
