# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "562f24a68dc5cbad8cfad51dfa03cf59"
SRC_URI[sha256sum] = "400e194928a5ac0e8129b82d3bd1b7724c8ce6fbed29c19b6e9a87a58fc2e014"
