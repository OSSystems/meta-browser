# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7d705a99656b13ebe948aa94e33bed71"
SRC_URI[sha256sum] = "64904a2501b1c9a6e222a93a5445ddc1b0603d4d2e23c4f07c14e97090a3c841"
