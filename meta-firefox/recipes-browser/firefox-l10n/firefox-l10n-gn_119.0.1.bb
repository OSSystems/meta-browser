# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c7dda0ccd7f65aa21ad927aabe1742f"
SRC_URI[sha256sum] = "261da73966f4b91378c1a1ff8c3d810a45f4309489368e601b79506257ebd668"
