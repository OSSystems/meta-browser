# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5d5a68dc6fa0a49fb146c68a5b1d491d"
SRC_URI[sha256sum] = "a96b6eab8bb1a07794d2f499b874e99e002383e4b1145d5dcd9652f56df358ab"
