# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6f4aa9f366c19e073b4c5b961787c1d4"
SRC_URI[sha256sum] = "ecdb48141bbc54737c994f420f72757b86978c2120a1212e5a82b543cf65ebc8"
