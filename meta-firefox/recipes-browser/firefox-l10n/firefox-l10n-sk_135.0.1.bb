# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d9e7415c383ff0e6e704e54258045eb8"
SRC_URI[sha256sum] = "0ded47f072717e978c095d8e2b66cc098ecd47c1ae46b92b1efabda2fb16319b"
