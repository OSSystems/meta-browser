# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "927f81d187f12e4470d1a5c37a011158"
SRC_URI[sha256sum] = "bef1dee599c8d250f7a001a7e4dadde2b54a0f4972eba9bce1d89304f54aba02"
