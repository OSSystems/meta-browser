# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ba1b3a289799ca6182190d4b6fd93863"
SRC_URI[sha256sum] = "fd53a6b9e93a52df7808dff0faa5466e809ccbf7389dd775b846ca1774162229"
