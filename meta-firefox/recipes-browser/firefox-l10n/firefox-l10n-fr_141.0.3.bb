# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "57dce998077cc6ae7150d333f0ed7e7a"
SRC_URI[sha256sum] = "63fa8c21f74426692a92857109d1c3bce5584a073a76f1c04c425eff89573cec"
