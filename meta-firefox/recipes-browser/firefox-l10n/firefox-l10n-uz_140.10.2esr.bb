# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "a1fa95f52d3cd4e24563e1917d636052c7641757ba3f6824d7cf8021ccb50892"
