# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "45a108a43689d20951504648e9e293db"
SRC_URI[sha256sum] = "f67286882eadbc63a0cba693490f2f2c6446e2762d4fab00df2ff33062d4e7fc"
