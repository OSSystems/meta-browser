# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e076b26ede3488cf0aa1bd3fef2e521d"
SRC_URI[sha256sum] = "115cad0674003b9cfc43fc6d4ee962305d5ba8fcf01a9be0daa1390e2123b2f2"
