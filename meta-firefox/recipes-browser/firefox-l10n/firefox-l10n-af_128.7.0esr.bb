# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "66aee74810b10be181ef775b4473f2ba"
SRC_URI[sha256sum] = "a1500a89f539b5423bda850c92da63690ec213e280fae14e73d70e3567b801be"
