# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "dff37bc1a6321a3f370d451be9bbe4eccfeb7a61b9009e3634351254d189240e"
