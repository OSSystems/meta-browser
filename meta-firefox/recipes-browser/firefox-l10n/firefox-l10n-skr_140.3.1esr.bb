# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "18fb7f48c280b45cad5ae62a61490672"
SRC_URI[sha256sum] = "61e0d4726473309d5199e804892e8d0c4ccb6d0f07f4e2d5d033b196607c9951"
