# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "913c186f8445dd5b948d7d75f5305292"
SRC_URI[sha256sum] = "0fefd854eb25c900891419d55852d7b9a722d814cd82edafdfae942fee1d9e95"
