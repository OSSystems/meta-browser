# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3d038f8ca40c28b4fa8b9baa788ec8e8"
SRC_URI[sha256sum] = "be24539fe585f958a4e49e7b23917f54f70c654b90c2f1997643be805909a352"
