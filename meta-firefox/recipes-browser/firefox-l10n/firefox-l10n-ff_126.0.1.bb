# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "90993bd0281dcdce7daf7302da8dbec1"
SRC_URI[sha256sum] = "2b949cd4311baafbcd5667287f50d55151f18273c87d4db5234984b9d7cfe14c"
