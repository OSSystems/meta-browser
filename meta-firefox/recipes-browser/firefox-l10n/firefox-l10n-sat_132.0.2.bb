# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7e7bf81453fda748c1e1cba20ed55fa7"
SRC_URI[sha256sum] = "9dfdb9d2eaf9c1fef527db64423061b03963ca79fab47e9bb09b7273f3a29fed"
