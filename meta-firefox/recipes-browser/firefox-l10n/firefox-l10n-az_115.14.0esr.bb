# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "47c8932990d2d78b3c31a1053acac8d1"
SRC_URI[sha256sum] = "15891f8ab817a4c10a47b3dc03b4cd0d14b3b2ad317347ba5176ded8f94fd0ae"
