# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cc676ddb89376af1b03ef60f9d0faa61"
SRC_URI[sha256sum] = "f5ec40417b4f8f94327ef5fb0bb56b8a0757d3df04749c0b55aab507d8aa1805"
