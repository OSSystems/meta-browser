# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9c8dbbe2094ff903f3d8e6730260fe4c"
SRC_URI[sha256sum] = "82ff5d9222445c4154f9c1d32ae8a4bf55bb7ccfd8e5b043ead434dff5409267"
