# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2b9d496fb19fd64d0aba022a451b8a44"
SRC_URI[sha256sum] = "96814983ad68520d217fd26d06ff89c6f9f6596e559aca5036a262603bc216a6"
