# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3d78557cb2786806aa5bb0139e7a72fe"
SRC_URI[sha256sum] = "57ebb64fd8573220980950e714350494a38ad2842ac037a13b0ef372e1e5c450"
