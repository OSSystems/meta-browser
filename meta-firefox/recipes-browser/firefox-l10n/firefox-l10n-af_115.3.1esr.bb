# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "96dc80a49157b45ef1f3a4e63c0f3dec"
SRC_URI[sha256sum] = "d997f84076a157e100e537eb464549cdf6d57e09b124540b3f280439049119fa"
