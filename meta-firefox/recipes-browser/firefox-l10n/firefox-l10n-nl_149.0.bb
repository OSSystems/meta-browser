# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ce91251fd02402e2aabc211bf9a913c"
SRC_URI[sha256sum] = "c1daceb600aebe13671a8f20fbdfd566cea977de98b0c4e15c94142f12938265"
