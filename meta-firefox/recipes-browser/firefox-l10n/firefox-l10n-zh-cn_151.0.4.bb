# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "171d78e696d3829583584bcda0c9fc873722929f6cc7216f8eb21b1bcf23fb54"
