# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3af5b8f0f1b3e1ad87e098440c6c8f91"
SRC_URI[sha256sum] = "0f15b44e027a80145d5993c7a17199a212790fe99df7eb7d6ecf029fbc11cd33"
