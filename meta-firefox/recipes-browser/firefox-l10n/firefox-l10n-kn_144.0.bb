# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e4d06b467d7e81c3fa129b8f6c32fb6f"
SRC_URI[sha256sum] = "18367f86eef0308cf601fd58564a29676b48ad5085dc0e1e18a8869bf279d76e"
