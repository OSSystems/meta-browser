# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4d6c4db6b0d36ba084424df2a71a465d"
SRC_URI[sha256sum] = "c3d500222859732b9a24fa22a5359f26d4d85954da8225a09c750913ce707ca5"
