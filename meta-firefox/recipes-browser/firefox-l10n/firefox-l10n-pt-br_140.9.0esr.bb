# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cc84920acf204eac170b864164c92db5"
SRC_URI[sha256sum] = "a78e141bd9879834d1b8924d1884f0442f465fdcf66fd7b3c249aed39a5fedef"
