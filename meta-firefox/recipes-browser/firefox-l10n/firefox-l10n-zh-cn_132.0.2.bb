# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a6b0d6aec0fb5564690b252dcc2a43bf"
SRC_URI[sha256sum] = "2629a78c1fafe869bc318976427821120a19d4f8f4dfbfd651af7ae24249d102"
