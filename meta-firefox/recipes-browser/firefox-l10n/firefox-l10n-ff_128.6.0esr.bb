# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eb0f0016a3b11cfe0945eb5f850f3287"
SRC_URI[sha256sum] = "ca1c8388a927baf19075ae83667522be735f0b098ad2a630b38da508d779f0f8"
