# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1ff1a216bb79659020b7043a40872853"
SRC_URI[sha256sum] = "74f4ff873e05e26ba4d0b1a9fe6a1b76a15baa06c05634dcb444dd329eaa1dc3"
