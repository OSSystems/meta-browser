# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bc63382227b493dc89c6fd9d29fb5b1d"
SRC_URI[sha256sum] = "cc1d57cedb44730b3d367527571d0b291d758aae61f2708ad490b28d984baa07"
