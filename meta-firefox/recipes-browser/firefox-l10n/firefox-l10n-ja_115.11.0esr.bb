# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b63426cdf69d1b8bd5096f1c10df7a19"
SRC_URI[sha256sum] = "2d257450dd0168b5850631b4f2af49c840f5a0fb13e75890316b2f1517ec8321"
