# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1824682fa9d22078fb9ed1177fd41546"
SRC_URI[sha256sum] = "7d1d9cb294b06f7abba033cdf6606ddb5f989b8d9c5e35051a38932d0d217901"
