# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "88f40f10461223f6ae0a9b28b2553424681dd9a2f60a552f8b4d2b1418da7a09"
