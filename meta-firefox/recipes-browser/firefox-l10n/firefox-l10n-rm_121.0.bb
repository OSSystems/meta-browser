# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "950edf953f3b1dc424ce6feb6cc1dac3"
SRC_URI[sha256sum] = "aee0ba16451ca45d352d1f63a4a4bcd62a85c9f68ba55c54c65c456fdcc6e278"
