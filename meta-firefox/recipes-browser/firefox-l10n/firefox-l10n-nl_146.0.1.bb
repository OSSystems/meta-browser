# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e7b48c00e315856737970bdf52e42a90"
SRC_URI[sha256sum] = "909579f207cbccf18d20f6e35f7c293cb945931bc2ea384a928c750b93d639b4"
