# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c63b1ab5e01b86faa6257d1059adb94a"
SRC_URI[sha256sum] = "c20b8978f23eab17ce3747f1ad0c305d7f860bf0340e84388d9eabe561f264c1"
