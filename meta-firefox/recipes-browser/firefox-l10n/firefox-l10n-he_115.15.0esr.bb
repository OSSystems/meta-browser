# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0531412c5d02d353db5205c467195116"
SRC_URI[sha256sum] = "f40740b5296821bcc3720604fa7ddfc310aded0d1df60a0f96842ccfb98ff8d3"
