# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4e0112081c3922371a4d17a68371e17e"
SRC_URI[sha256sum] = "1701bf60a93ea03cd06270cbedac903f8e852f2b18fd290de872be9b98024816"
