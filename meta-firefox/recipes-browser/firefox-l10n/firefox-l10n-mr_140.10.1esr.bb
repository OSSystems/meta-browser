# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "4b837f1b46cb34ae2edaa5015cf36cf82b6cf0795dc8345e0bb716b73343e117"
