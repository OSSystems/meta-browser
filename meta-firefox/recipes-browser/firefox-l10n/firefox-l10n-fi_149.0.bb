# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cd8ee9476d927093f5350108c56a182c"
SRC_URI[sha256sum] = "e76ffd72a496c3244294ed2f574fc14a4ca5f7fa90d8ea323983eb0e240d2243"
