# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b1edc7a36eb45d3cd706603b77377a82"
SRC_URI[sha256sum] = "f1f5f95c0f174b17ae07f2fcd4d5479cc00a237c48693fdeec373aa4e5fe6030"
