# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "27b830e2b7452e1658518a9caabf8f51"
SRC_URI[sha256sum] = "f1d7798d5493997fac0f7179dd0cae93929361ea39531bdb0ef6a29e081b1119"
