# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7ff26ac393ff349322c7e2e343aa9693"
SRC_URI[sha256sum] = "4eb9b48c884a4208bdf1aac59941323557b6abf1797b41289b00018568bf528a"
