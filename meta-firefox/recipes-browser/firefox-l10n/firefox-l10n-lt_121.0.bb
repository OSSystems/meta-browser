# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aec1c5e836a73e36b9346e4f28dc3ad1"
SRC_URI[sha256sum] = "000c54bf1a913e241292a3b1202c1e6051e052e6af48cb78516cbd406f8657b2"
