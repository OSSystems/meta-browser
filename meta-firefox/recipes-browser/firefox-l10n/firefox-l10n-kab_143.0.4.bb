# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "33299739bb9541e68af5affc5bc1cac2"
SRC_URI[sha256sum] = "f380810681e134f1140e665627b59d8be72d154980c0a6e03ff657c5aacaf170"
