# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8d9cf2d44a70b92b0d7b8578388c7057"
SRC_URI[sha256sum] = "6127bbeec632de5b1298aca3ee95afb9bbd48f78b7a14bc27d6ab44c9b618740"
