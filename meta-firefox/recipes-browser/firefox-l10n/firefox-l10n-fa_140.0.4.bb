# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2f63f3bad37a96feccee9b3ab4f2b93f"
SRC_URI[sha256sum] = "7188d3b50a37f457d91a85de7929b22d3fe702888cb6733e561d6f7057473b03"
