# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "f2890f07a58933f2608efce43a7dc0ed4d72e38a9d030470769e95020883b9e3"
