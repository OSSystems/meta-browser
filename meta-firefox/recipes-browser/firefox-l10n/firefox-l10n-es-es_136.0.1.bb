# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3ef1e831ce15cf4a2702d7155dd986cc"
SRC_URI[sha256sum] = "5ea9d1a55b070bab6ffba5d654cc7b1baa4f84253c4078ae5c6a73cac4fa1794"
