# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "27a226dcb01b285ebc8eedc360766033"
SRC_URI[sha256sum] = "fcc303500de3274a9a791bdc3387e1b1811ea9e4e7af37f77a96c4687b4f184f"
