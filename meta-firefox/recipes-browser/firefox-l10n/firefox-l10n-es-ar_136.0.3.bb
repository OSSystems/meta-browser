# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c3aec0401c681e5da0f021fba3c0e65d"
SRC_URI[sha256sum] = "7086ca086deb1b65f688a8a81a1e8173068efc8e7d46c619459f396a4fbad2f8"
