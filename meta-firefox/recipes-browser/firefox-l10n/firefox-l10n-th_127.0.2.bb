# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "29f6223c2813a71a7ea6f4ad2c6ddf62"
SRC_URI[sha256sum] = "6edb7295a52b027d4cde5ad9616267a4a18fa081988d8686af21102d94845a66"
