# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e2f47c200779e9e6bd36e36722cced6b"
SRC_URI[sha256sum] = "cb212f6d1c74b72fb4549e30a8e062e297a82f6f938e09f4e105c9b80ec795f5"
