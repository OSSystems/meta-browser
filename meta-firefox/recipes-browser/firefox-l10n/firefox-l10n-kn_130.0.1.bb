# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "56c84b054d7b16ac4d676ea520dd272f"
SRC_URI[sha256sum] = "d2b79cb0416edd5b36c7ba7ad05ef7452854659d7836546cd66b264f78479b6b"
