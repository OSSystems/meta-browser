# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1c86820577c19720ee37d40441518be0"
SRC_URI[sha256sum] = "13170c010c4d5fe6ef7b8dee1d07c1eb8fdc47ab6f53bdb492b5ac5ec54ca233"
