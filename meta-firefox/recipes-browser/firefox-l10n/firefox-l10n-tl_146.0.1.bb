# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a24d3f943fbe69b0d7ec473e7e3c0fcd"
SRC_URI[sha256sum] = "ffad65fe9696bc7896e275c132045d05d5294851957a23dec4f623c5bf69342f"
