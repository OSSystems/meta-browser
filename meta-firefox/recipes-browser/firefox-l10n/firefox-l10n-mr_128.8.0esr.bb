# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "684a14f564805ba582f9e7759adb3d2d"
SRC_URI[sha256sum] = "b377168fd79528ab62888e6aa9b24144b5fdf2458d0d400c46e5bed6cad31421"
