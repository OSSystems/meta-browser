# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c79266768ae220cf591710d7a8a007fd"
SRC_URI[sha256sum] = "90d32b4eaa4dc596f7e2a272bdb7d23ea848b955787a105ed514b194238d63d8"
