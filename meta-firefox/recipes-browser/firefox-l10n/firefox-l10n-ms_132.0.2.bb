# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9d94902f2742fbe9f72cb1a67964650b"
SRC_URI[sha256sum] = "c53c00d79f899f2ab919ff03c533a8ab0cbcc50653bb2eb82377c8b62f0a2319"
