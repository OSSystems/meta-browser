# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "085ab99dfca4a223da4018dd37f55144"
SRC_URI[sha256sum] = "f006279b66a2cdb62cf0460a6250c04ad93260f7c07dd88d2271f5e637b9aa9e"
