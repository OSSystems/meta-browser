# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c1e3a09bfec61e6f4bd0664582b79dac"
SRC_URI[sha256sum] = "fb777e48cd945ab22db0133aa4466ed72dac1df2b8596da1536b7cd36c3e53d9"
