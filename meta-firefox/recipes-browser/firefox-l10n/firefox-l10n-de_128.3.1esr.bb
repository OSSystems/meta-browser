# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c2933c311f59f5994abe3879b4bf6592"
SRC_URI[sha256sum] = "44aafe25d1862ec3456e7e1feebcbed1e13a26b11b4740264119f73990c2e63e"
