# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7365500d5d5a095c51f70ad04c66d46d"
SRC_URI[sha256sum] = "56dfabda5358561520cd74fe1ae45b0a2c395335b736da40bf8758493c6289b3"
