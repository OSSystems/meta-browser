# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "86321dc933e03398c75edc23d2d39454"
SRC_URI[sha256sum] = "211a5c5b69e4cfb7f4b1a2a6015a897426d8e64821c08625835a631fa5231b9a"
