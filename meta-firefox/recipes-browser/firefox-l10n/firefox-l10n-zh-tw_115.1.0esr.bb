# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "007d854a98c33bb21175e44eeda78fda"
SRC_URI[sha256sum] = "b60ed17be8603f6a31dbbb6c10fc0cc6f7ad702f366bcf66f060d33de2f884e1"
