# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dd355a3b2212ef45285a019cc6d03158"
SRC_URI[sha256sum] = "46f0b96d352832d8c1b87399d0b6bb28027a84f392a48ef612b941f7255df29e"
