# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ae1c3a096f942dd260d5faa5a94b655"
SRC_URI[sha256sum] = "a2ce27bc0aa484a3572473fe23717dd48e7a982ac79e8ac30a1436c0a3cf0d82"
