# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7a0d601a722bc06a305cedfe6990b2dd"
SRC_URI[sha256sum] = "470dd60238fc0fe72efb55d8b180fe7102bf42faac0b637a298ef2fa7d247d6d"
