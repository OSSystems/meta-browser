# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2e3771e56bb3cee961b2ea1e0339dcb4"
SRC_URI[sha256sum] = "3b12c5fb8f68c538631cf897cca5340f0170c6cbee7c7b2509c9284958b182c5"
