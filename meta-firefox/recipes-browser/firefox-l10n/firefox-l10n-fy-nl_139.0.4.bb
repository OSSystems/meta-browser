# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a0fbe55809c180e7855fa429560bf678"
SRC_URI[sha256sum] = "c9651c7b94ceb485d8382d348f8716059396ce66173c2932a909efa97d05cfc4"
