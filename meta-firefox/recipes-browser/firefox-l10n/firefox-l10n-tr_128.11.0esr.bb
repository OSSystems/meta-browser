# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5e2523d6f4c2623bd6c4becec974f90c"
SRC_URI[sha256sum] = "a373c2a279b6c1a48346a5ffeadbd710037d58ccb67d97cd34cfb549d91dc34f"
