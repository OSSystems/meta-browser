# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "091ba8d5d5b39a42fbc441ff5a44d9a2"
SRC_URI[sha256sum] = "2ff61011bffee7526dd9c9eb9e16fa5c6cd23466fdd5057ae1e74a8fbbc1edc2"
