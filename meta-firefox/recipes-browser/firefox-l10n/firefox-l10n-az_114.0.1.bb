# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "62a2526996238f3c0d939bc3d23d902c"
SRC_URI[sha256sum] = "2fc8baf891172a24cbd2ebc21b7ba533337636cb6da497bfd35078110669853c"
