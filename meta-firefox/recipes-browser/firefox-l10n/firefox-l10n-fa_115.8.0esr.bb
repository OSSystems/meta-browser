# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "91b44b7932841f2e07c13af98f2c3864"
SRC_URI[sha256sum] = "58fb6bd902ab2262ddc7cfb3fa84cf721846adb5c9937492553bc9d7ef30cd75"
