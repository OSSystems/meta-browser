# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3e384c09b05412bf6b944ed51b2db1f1"
SRC_URI[sha256sum] = "00db5d32f9165bffd971e3c8d7d73548ef94d99f1f059cbfa2f8fb00aec682b2"
