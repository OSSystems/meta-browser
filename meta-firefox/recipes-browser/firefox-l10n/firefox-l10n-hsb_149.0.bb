# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ae3fdad505e1fc4dbe8f0609ab8d1f0a"
SRC_URI[sha256sum] = "eeec1d163eb296855e160e20d028a2b199a5688e3489b2a5187beebed061ec9c"
