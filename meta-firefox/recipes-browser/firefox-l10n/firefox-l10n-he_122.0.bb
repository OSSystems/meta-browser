# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f32a052ec5b3b957702c0c8404e545ee"
SRC_URI[sha256sum] = "570362ac385c1363cde53cf3f50b0ba77eb7bcd804934ee53da0c64b8cffc962"
