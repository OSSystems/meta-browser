# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bfc16f655996a9288abe4a9738ef3b10"
SRC_URI[sha256sum] = "8d56c4bf495eaa1085529e653fe18f4cb119e567e4479d9161f6387a46b2c67d"
