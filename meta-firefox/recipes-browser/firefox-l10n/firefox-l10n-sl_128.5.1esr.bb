# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5d6bc8a8d4f0278bdd8902c9b66657ab"
SRC_URI[sha256sum] = "97ed67251c1edbf456230f802d6b0d5b2a1b91f7263165ac40ec5fbc614d65be"
