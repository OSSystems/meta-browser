# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3634f6e428310d6269e9d262f19d7be7"
SRC_URI[sha256sum] = "d7311f057a57f0f8a089297bd4584e71ddd38d239cb385095bb944d5e9cf6e91"
