# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "036f5c8802ebb67e788721157c2ac543"
SRC_URI[sha256sum] = "7afbd86178e5eb195ab8747dc560a605b029bb27ea79ed27ffc0ed9d615649a6"
