# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "70accb017951f472cfa7f9606e390c58"
SRC_URI[sha256sum] = "9c4697d691c7579155357eac191ccc789a7fdb89a0a4b5ab0e74f7688918a05c"
