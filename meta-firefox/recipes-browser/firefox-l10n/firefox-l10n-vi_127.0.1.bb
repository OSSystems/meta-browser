# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d3d0014cd8745f7e39e1d46de11c2e13"
SRC_URI[sha256sum] = "45a2a8c0f506b250ba9586fc3fec44db6723fe7c9d025478aa5489c148b226f0"
