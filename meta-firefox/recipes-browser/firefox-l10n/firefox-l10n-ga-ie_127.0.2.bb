# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7da9bb53e87303e7d9c6dc7794526f37"
SRC_URI[sha256sum] = "3c238a17b74b5f85d5ea32be96de7048e2faf22baabf68cd9f64597c8aba404b"
