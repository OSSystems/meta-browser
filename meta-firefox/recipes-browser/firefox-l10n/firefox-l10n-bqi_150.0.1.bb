# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "36997b998af96f8832e6eb813222878386dfeddeac1dcc733b5b7ddaf0ca519e"
