# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4a4b3eaf86459414262c021c3a20fc94"
SRC_URI[sha256sum] = "dea44107088fcafcb494bbd003cbd76067777722d5c70cdfc6559825d2920f37"
