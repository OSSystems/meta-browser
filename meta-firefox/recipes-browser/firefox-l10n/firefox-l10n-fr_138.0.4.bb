# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3a529f1f918e5ec4e957d6ce811cbbb6"
SRC_URI[sha256sum] = "7d5b59a0df54289bfdd77ba2e3111bae5ba0a06ce10b49820c267fccb20d7f9d"
