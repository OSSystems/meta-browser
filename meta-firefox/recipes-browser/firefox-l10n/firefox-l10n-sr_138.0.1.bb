# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f729ddcf549d2f459d2388d53a0880c3"
SRC_URI[sha256sum] = "f013747eae3f4b0b5a84bb4598c4c0b37cb6880debb6b5c051815afc3e1d69a9"
