# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "f8d14f497f34069c462b14f55a0df5cc3634c36f9ba8c77cf586882a850c6548"
