# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "19065ab3632d00c72810f20f369d2221"
SRC_URI[sha256sum] = "3f93a3ef6144625fa6e0943350d132a2732d414e66274d1bffc96b7aa1dc347c"
