# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7a545a4a1076d80b2afd1e613ade0be492ba955afa740cbe723b9bd39226f6a3"
