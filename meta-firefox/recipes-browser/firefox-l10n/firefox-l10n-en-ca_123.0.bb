# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c29627f98db0be2f6f901327659439a"
SRC_URI[sha256sum] = "849da15263c541dddef1ca84fa999fb0d5f5f0757ae3239d88c6f105b1f9e00c"
