# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8d9ebf617ebc23f471b3dea827cbeb96"
SRC_URI[sha256sum] = "e4b3d8271337e805f0637ee535b102a3d21a3207c22cf011bba4a7104fd4b42b"
