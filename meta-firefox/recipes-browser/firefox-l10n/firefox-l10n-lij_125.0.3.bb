# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2d9d5ce82e95d1f1ae21c40c0f2a3180"
SRC_URI[sha256sum] = "dcea6626a871fda19cca8bf54b8bdc9b761f0bddb28e827b603e66bff4a82476"
