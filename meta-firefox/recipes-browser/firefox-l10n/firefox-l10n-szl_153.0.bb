# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3fa0057ae20c11c16bc34ba793e39f42794347b63829c4a91461a06be62ebcd0"
