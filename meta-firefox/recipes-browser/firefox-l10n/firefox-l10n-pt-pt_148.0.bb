# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0bff742f17136e28b4393a75eb79f33b"
SRC_URI[sha256sum] = "9a39e923568f08877d429f3ba4c25bbf157b9dc0eb3b235a9b0fd682e85dc05a"
