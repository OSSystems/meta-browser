# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "21c2454ac4fa0f28cda5be9705a8a619"
SRC_URI[sha256sum] = "c5298e7511ec436eee9b0204fa4a3b47ea8c5a1760ecdf96166f081eda268474"
