# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "6fe918ce66b96b5f48caefbf0ef348ecd5c5a3baa22d3c96f07bcdc4f475c01c"
