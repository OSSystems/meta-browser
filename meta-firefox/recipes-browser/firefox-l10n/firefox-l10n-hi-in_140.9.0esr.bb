# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f6ecdd0ea7bc1c80100e42d1431140f2"
SRC_URI[sha256sum] = "b9b3d85122507027981328ea6b0584e6aa1b14e01235e66ec907c88ea12f723c"
