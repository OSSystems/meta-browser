# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "98c96a7ef3bfd7850a3ea8880b17a03c3e13cb733b265f5e679ac295cb7ef7f5"
