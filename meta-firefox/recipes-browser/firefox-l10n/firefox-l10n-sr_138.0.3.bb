# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "04f757650a8f0f720f9654c2045fa2fa"
SRC_URI[sha256sum] = "bc82b8700e99ba4b0620bd470647ab2b3ed0c1755b75067343f3abcd67130401"
