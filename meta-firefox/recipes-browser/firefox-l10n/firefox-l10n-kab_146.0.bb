# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d8031611865f08275d3326de01db7678"
SRC_URI[sha256sum] = "df2a02d712d7cd74f465c3b16591cef7189ca9d24f3380c84ee4dbe1d3006525"
