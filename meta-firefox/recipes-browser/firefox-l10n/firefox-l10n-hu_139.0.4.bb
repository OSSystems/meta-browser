# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d2308d35badb38fba5a5151ce7aa7889"
SRC_URI[sha256sum] = "13a695ec15047a73af30de19cdc27ceb3bb33d59c19c805130d08390d395e862"
