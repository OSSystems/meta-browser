# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a6d9054510fc424af36e06286ebfcd15"
SRC_URI[sha256sum] = "a39b1a88019414b84922494397b71f2177ed69707ab99a476d58674b553730fe"
