# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "575ed69389bd84bdccfcf03ff141ab56"
SRC_URI[sha256sum] = "81c57d00f5c181867c362222addc8723c5a8befe101ef2ba49bc10d95616ef28"
