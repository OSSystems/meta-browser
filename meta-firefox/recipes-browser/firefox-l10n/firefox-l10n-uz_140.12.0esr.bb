# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "0903e247099d8fc6959798a5b4352e537e3754e893efa45961f8a673ecc26480"
