# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c195842b92bfc5d14d316267a7502328"
SRC_URI[sha256sum] = "42f1092728529f9be98edc9ceeabf0f0d7792b70f45c32cd746a06281b1ed282"
