# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3f741479f421eb376877df16e9d48f16"
SRC_URI[sha256sum] = "17593ef9e0d4808ed58d4ca02c8cd6eb722b67080b1e05dfcc5b9da8799db653"
