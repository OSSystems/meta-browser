# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f8f81237ee51b20d51a0ef24a4488a3e"
SRC_URI[sha256sum] = "1956ab199ba22fab8f786790365b2e72508d3803d8014198a2acaf1a0404d589"
