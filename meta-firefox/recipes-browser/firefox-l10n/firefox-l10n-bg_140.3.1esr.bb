# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8c0d1d86cb080f58afe672f91fd68ee7"
SRC_URI[sha256sum] = "14295ea52601cfa8bc9a9ad6a70225b5528ca10119d4f967248981c8514c1fd2"
