# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8de75d58249cbbf7efc5906bdb80dfa5"
SRC_URI[sha256sum] = "c69175655cca2a2ca70402f98b05710520f40001dd5b5b9015c37df7b2ef8c4d"
