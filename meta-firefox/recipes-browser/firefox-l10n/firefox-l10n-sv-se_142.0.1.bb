# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f505c69e66372aa29025a422e848fc0d"
SRC_URI[sha256sum] = "81bb6f80b1af5412819c572ea54b35123a8d91ce9bb8a955d917b234230b82c1"
