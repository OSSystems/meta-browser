# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ecf6385bb7379a92a3f48e711b880b07"
SRC_URI[sha256sum] = "96c05e8bec132ed3cf0975fbd9fe2e1eb261d04e7050a0ac2b7ef90a2a3e1062"
