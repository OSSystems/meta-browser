# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "8cb37a234bd0f1d7fbba21680bef96044ad56f504017579a113a98b0f97741a0"
