# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "215b2f38f765cdb6ad1a8efe6ca18424"
SRC_URI[sha256sum] = "15fb1c2156b5acab8475d73f62a9a298096e1ef3baa99214a2b0956ad9a5632e"
