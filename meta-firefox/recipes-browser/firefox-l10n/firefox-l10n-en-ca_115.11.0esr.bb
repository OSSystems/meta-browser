# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e4d4a9a3378d7488efcbcaf386e02ed6"
SRC_URI[sha256sum] = "2777bc2024b4dd2ac3cc1ffec5c60df5e6725520c9f7e11f01dd4921a6a0040a"
