# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "678d3df237e5fd8035b5501e25734afb"
SRC_URI[sha256sum] = "9de0e05c96283c3387f6c323060e30cfa305e95620be47f1dd3b245d6501d03d"
