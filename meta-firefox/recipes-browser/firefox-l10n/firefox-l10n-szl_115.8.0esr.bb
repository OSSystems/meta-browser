# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c51e00c94116ea3a5395af9346e845fb"
SRC_URI[sha256sum] = "611496a4b6421ee184d5eb475eed4a3c7b8b9ab76f3341b8ccec7f6ebd5bcf2f"
