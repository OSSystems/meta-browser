# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6c2d1287d3ea292ddde156fcf1d4dfeb"
SRC_URI[sha256sum] = "e7b0f7840ba9644f294f8651c0252fe3d3d3412906aeba207b3f56556dbe7e98"
