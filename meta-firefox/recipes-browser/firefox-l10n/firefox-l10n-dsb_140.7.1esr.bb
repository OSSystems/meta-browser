# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e8b2138fbafbbd76a98a35f3fff42e8b"
SRC_URI[sha256sum] = "7ea0f3d3aec8f21c987d68d0a41f7fa3862f1e0e3940ce7c0333476552a56ff4"
