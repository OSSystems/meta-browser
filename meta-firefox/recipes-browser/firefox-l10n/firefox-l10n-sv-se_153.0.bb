# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "5572cd655626bfc9334ca46129300f49fa3c08e27c6f5134e6c5883db5b0daf2"
