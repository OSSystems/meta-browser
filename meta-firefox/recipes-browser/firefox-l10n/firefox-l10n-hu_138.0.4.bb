# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ad3359e61f0db1fe373ea53f147b6b3"
SRC_URI[sha256sum] = "763a0f98b6edce6bd53ba23e5e815788b74a37ba05ccb8688c557792738fddcb"
