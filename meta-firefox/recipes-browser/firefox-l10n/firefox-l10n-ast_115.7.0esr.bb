# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "658a5ad2f13018fa63ceef373ca30aa4"
SRC_URI[sha256sum] = "f35ba556a8850aa4aaeed4163f680c693a3026e57d6fc797afd343fc78e30bf6"
