# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "49f6209d8305d694cba17bc521b1d3ed"
SRC_URI[sha256sum] = "64df724c47027961a5f9847dd982d0db5138815346130038c2be77a68e69c52b"
