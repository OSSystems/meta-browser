# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "553e3c4b4337ffa89d0f77794a982731a7c3552b3a33b40d6d3a7ecc7eb6a868"
