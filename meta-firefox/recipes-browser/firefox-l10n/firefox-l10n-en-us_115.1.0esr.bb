# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f2e2eed908d2e0fec2dd756f0f9a5c63"
SRC_URI[sha256sum] = "7a6600766bf37ef61ef02ebbf97c6f4556fe9bbe75e13b2af18440a52dea42bd"
