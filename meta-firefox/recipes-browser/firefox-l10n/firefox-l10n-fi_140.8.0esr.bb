# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c4fed54d62011a9f41513729ba9388f6"
SRC_URI[sha256sum] = "52fcd26ec4b99b5f56b9eb83a07f23e810e2e128e6759b24bbf8d69ab8ea9569"
