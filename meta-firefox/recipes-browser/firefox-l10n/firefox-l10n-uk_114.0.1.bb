# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "09a6bf95c0d426f1ef8269d6e084e838"
SRC_URI[sha256sum] = "31771b7805781d9cc2022b4f9d54e4f375a8cfba344e3df98e4f76d3ab4bacdd"
