# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "25993079073807b463e5c1b50b6fe2f7"
SRC_URI[sha256sum] = "2e0a25357c61f951b19d9224173d52a49d998623552f88523ef7443ea056b95b"
