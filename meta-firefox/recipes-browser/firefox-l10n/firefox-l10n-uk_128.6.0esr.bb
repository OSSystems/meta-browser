# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d5cba97e9640bb1f2ea8596a451e2046"
SRC_URI[sha256sum] = "c70efda208642581751db7323633018fd5590e6d0505e211ebb6c4abfa699b8a"
