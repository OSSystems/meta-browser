# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a037b312aa7e52c89d14def1aae6946b"
SRC_URI[sha256sum] = "f8abadaccfde07567d7d0d5dc617a3a0bc841b6dd166f1b804b1f853792ba0ca"
