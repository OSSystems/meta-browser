# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "62f03c0be478e2f2717bac7f36e1d101"
SRC_URI[sha256sum] = "4d105f2fc1cbd6c56868f8b3209713dc8fe087322fa67d6247435b246555c59e"
