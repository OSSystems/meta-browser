# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "38048bff90a3cf8e50a84a709686a000"
SRC_URI[sha256sum] = "940ab5f3154c68e8d7b5adeacd5ae7ca82ece022a47c647a94e732662b5e7c6c"
