# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0e7f9deae7897a05715995457ee48553"
SRC_URI[sha256sum] = "d34714c2aed50601bb2c17336145a00bcc2c91cb53671dfd6f7ed80d993ef5a0"
