# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e04b90f5fb50672c635be9316a675b6a"
SRC_URI[sha256sum] = "b6cd5242905bcc5329f640aa7d8b5a9bab92083541ca2be82a08296cbfe5e1ed"
