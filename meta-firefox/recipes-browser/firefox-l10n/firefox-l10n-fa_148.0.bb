# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4b36ec3b4942d35fc42c074b9feceea6"
SRC_URI[sha256sum] = "10fca6e72b0e8daede779a393e7d1d9d632deaee4bbff62dcef2b843bda6407f"
