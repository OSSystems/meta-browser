# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d9780c74a96ec19391c51cfc1de69748"
SRC_URI[sha256sum] = "9e54d76466af4e8bd5e347be2f67e982044075d396a2ae391de7bbedf32a9218"
