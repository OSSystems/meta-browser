# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "01e5bab0285120651761419c08eba248"
SRC_URI[sha256sum] = "137286f48ac5921933c2c5c7397a305d9549d8296c7f6445701a4fa843b140b6"
