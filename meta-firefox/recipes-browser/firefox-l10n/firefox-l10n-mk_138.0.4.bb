# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "86e3b14af806897696dbfe0dfb675d55"
SRC_URI[sha256sum] = "d5da09cff39ac5a7c9e9a8102cbf830c6c53e8f61997bcc0999a0ededd78c9a4"
