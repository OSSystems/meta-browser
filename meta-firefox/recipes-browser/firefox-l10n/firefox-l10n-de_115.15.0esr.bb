# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "896c440b4c8501d79c64edff54c8ea66"
SRC_URI[sha256sum] = "2335a4cbd50a6c570e91df32b2759b798a9bd6a814b33b482f6860806f053f5b"
