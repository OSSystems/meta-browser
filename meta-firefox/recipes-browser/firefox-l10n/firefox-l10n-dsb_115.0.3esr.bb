# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e6076b09c0652f0f733803359378bc69"
SRC_URI[sha256sum] = "c65f5b0ac4ea77fc4241372a8479f9d7c67bc00d0b6f0402ac8ee9c830c76b5d"
