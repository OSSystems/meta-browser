# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1eaad8fee9b049bbe0f8df5c8bb5e9b8"
SRC_URI[sha256sum] = "7c9b1ab4ace212e6fdccfde701fdcc133135cbf34bfee562898a570dda7853d9"
