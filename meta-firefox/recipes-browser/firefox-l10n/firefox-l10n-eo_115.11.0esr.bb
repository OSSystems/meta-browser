# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "48bf0b273eb84f024afb8b726aafea0f"
SRC_URI[sha256sum] = "66dc6427aee282d9a47ee2e0b8eeaf34a3bc80bf2eb09c80bdb2ee3e76af9f8f"
