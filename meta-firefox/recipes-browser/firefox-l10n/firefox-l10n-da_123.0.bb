# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f5faf9d9df400030cfe926befa4da397"
SRC_URI[sha256sum] = "f7fa56c809883bb100f538c1d215d9758a97137f5f51878ab7e721ee46f2c511"
