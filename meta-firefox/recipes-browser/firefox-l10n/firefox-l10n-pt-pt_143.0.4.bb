# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "696f3497ced0868ada44759da448d4bf"
SRC_URI[sha256sum] = "bd60c66e953c8f397ce99585ec55695ad7abdc694bfcd9678b799257e0e70ef5"
