# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ce2f3d6ca6a33e1059e0590e89add7fa1075bbe2bf2cde12ebc9534bdf42c02e"
