# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2899383f341739b6db15ec930655f2ea"
SRC_URI[sha256sum] = "b0e30cf4b6043b02b2beb4ddebaccbd86866a646977b7bb6f3ad5c915d9e36be"
