# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "15b985528027aa3b36812098dedaede8"
SRC_URI[sha256sum] = "cf5e23d12bfdfdb48ba70a916c3992e78a457c1d608a0bacafc682203f95ea03"
