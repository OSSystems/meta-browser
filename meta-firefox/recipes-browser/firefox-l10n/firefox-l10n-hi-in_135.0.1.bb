# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "12cff7bfda87de7db1a382443676eb42"
SRC_URI[sha256sum] = "a67b39740c3f3a1c23d25de308c4f673ce3f85733213781bd30117b4b34884df"
