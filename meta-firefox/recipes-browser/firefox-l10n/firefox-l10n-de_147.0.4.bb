# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5d610b6e24c34929a854fa23964eaf8c"
SRC_URI[sha256sum] = "495d2e2306b1bc04f42e378b79126d5ed242225c375e492dbe1b09eb34f17464"
