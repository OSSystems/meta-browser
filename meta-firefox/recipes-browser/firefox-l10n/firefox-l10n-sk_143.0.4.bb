# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eebaa510eb7796bcfad838b2d4370b4c"
SRC_URI[sha256sum] = "2dcfd3884fc0c4bcaf9c14e253233962534d7b14f346650b7b073239f624191b"
