# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b0baf5be69fbe76e7b3cef34c3d41ad6"
SRC_URI[sha256sum] = "48ec5575cbd3eb771dfcfe05eac2b6182a0731aa6b7a118dca66c401cd25a359"
