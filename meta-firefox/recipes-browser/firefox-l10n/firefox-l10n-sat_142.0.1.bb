# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "33d6c3b5dbb001fac20f3507430956c3"
SRC_URI[sha256sum] = "81b2c5e5f668c10b0c05f4fadffe1133f7e5988bffd71bd4a7825726a68da6a0"
