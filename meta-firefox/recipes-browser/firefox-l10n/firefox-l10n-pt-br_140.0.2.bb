# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "592f326aaa841ab1af2ea5f3cd21ab1e"
SRC_URI[sha256sum] = "5e092b0c03be66f0b786b988f0efe88de1c58552ecb73eba22e5cac8b9ee8935"
