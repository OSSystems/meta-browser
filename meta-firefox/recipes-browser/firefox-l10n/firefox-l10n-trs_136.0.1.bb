# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c6993bd96f73dcb372a6c90017a508a"
SRC_URI[sha256sum] = "a2972297ec25cbe72b99641543fa5c706d055617dbfdb356ef49dd684263d293"
