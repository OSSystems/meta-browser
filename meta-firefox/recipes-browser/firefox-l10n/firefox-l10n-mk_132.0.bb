# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b7cd892cf6e797a959cf1501d26e5f6a"
SRC_URI[sha256sum] = "dd6e5a12792ef4f4d26e27e60d1250e41c407a70eb9a388beb17c60ed74765b8"
