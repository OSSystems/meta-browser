# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ec780d74f354d90796809285eddc0702"
SRC_URI[sha256sum] = "b4e6180821b1e5b35789f5aae715d127660c14568c29dd67339602dca001283f"
