# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "566c4e80f212ab3b43fe2071ebfdeccbe4af472e0dea5c9c9c5957757d625136"
