# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "79e2dd97e2f2448ef0537d230f85ec79"
SRC_URI[sha256sum] = "03959f01be155474a37ad335cdae1b8f803b515b4c60877d8558ffda6d0f787b"
