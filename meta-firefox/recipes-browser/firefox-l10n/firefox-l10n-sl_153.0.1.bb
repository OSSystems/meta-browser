# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "6c1750bd110c8b83ab7e51ff872f14f59d8cc1ec053bd9186e1b9c43f47b5af9"
