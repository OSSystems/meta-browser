# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e3035563505321905db069feec707e32"
SRC_URI[sha256sum] = "612370a2b4c7e6ee13bdf475c527467e98b9eb48cabb66ac61d9f3d13653880f"
