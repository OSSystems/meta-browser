# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "200f985be3c361e1967d15b5369fe08a"
SRC_URI[sha256sum] = "b1ebfc4050a08ee652b5cb4dd889fc57f210fd3ce1338e0ec75b7d9b12043063"
