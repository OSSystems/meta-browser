# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "32fa0763a353599e96923b17d1978969"
SRC_URI[sha256sum] = "8b10edc348f4ee2d80d43c0c5c4a96d112c23598dd33440a3840330e0d656e1b"
