# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "36220e2dd28e08ba8e08f7f51e193bf1593b673260612fe5c9810631cb60a06e"
