# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "b03c44a4afeb8842af16044e2b8ced3aae6ddb49bce00472f008fcf7be57425c"
