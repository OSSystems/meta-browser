# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c255985a8a8de63bbc4ea55021c2f3e8"
SRC_URI[sha256sum] = "215794e3d5aae4064538aabdb9545f4f2bf1b2292de8fc329633d7f592ebb906"
