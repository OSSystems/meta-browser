# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8fe55d0b6d0f4f9b2778e3a2740f9a46"
SRC_URI[sha256sum] = "7ec5a9cca7faa714585774f8f8a0e2e55f9f5be626a8609e0b2fddf0df1a4cbe"
