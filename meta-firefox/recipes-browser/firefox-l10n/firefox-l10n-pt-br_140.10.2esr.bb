# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "1bc186ec00a3de09d6b88ebbada39e05ba7a7151cbbfad1f8d24c003149932cf"
