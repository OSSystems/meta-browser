# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f27e40cb164634de34a90ae670aa5556"
SRC_URI[sha256sum] = "97634cc424df80a585450240b87059dc85289feafe077c8d3973fae3329f0f90"
