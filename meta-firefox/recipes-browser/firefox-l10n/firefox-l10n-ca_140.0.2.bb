# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9bfa8371e5dfdb442f1ae967a0ed3ca7"
SRC_URI[sha256sum] = "fcf4682c4d36b769df74243da6cc853ba26a225db172fb2012cd2498c22d35a5"
