# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "42681ed8f1ae3c34ed2a5ddb79cc2dbe"
SRC_URI[sha256sum] = "c0420894769a94028ee9c6a27cf3d6524cbc3ec836c291f4661e62c37fb17839"
