# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "aab266101ef75092eed66771cb7b9ec5780ce24a38331f9118dd2c195d682102"
