# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2fad60e0299b44636a874cfd486f7e28"
SRC_URI[sha256sum] = "0c070b64081a663c5001ea0d705cb16b6894df4675138d78a14970abc4c66ceb"
