# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "510ce00ed881dbee54aa18cf5bd9786f"
SRC_URI[sha256sum] = "864d304689f30387f0890acb172ab5e3ffaf22e4398a19c2d409c2f4e2257638"
