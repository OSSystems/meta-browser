# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1b8500e085859f4cc14bff876c05e42e"
SRC_URI[sha256sum] = "637747a1592ec8a5003e935292aabd103c53ba9ea5f70cf671f5dc5b8a529e3a"
