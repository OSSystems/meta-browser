# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "127e40926cf038a0cef8b8a73a74c868"
SRC_URI[sha256sum] = "8defee0168075c43ab74d017b0932f7dfc11aa310cb703b4e5082665463940f4"
