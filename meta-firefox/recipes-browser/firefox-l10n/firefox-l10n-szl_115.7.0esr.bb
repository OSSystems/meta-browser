# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3ec88a5650b5491c8706f1979749ef60"
SRC_URI[sha256sum] = "0dabc9c67c36caf111152c9c645e7a37bad0a42d65848f2a6490dfc48df287cf"
