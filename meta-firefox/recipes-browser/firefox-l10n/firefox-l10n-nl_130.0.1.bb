# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ea404aa4e7deff105f6fb52407b4224b"
SRC_URI[sha256sum] = "46706b4a74cee8743e9dd573fb44ba2fa9c7cecbf3a8b34a2420f83be3646aa4"
