# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "93b7d0992b417ab90c1ac3836c48eff4"
SRC_URI[sha256sum] = "eafd78c1fff44582cba3a759f1f2e100116ac755d567e8dc1f08345a4a5266fc"
