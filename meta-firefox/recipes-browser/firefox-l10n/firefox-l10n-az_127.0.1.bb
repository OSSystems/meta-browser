# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d84bf3266ae364b6df28290a2b2ad0d1"
SRC_URI[sha256sum] = "c219e7ca0e79b76ee69ecb4546b8d079ff8d892671ffdacfa4aff58699aa1b0f"
