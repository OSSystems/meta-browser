# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f40f983eca2139c9d5bf8d495ab583fb"
SRC_URI[sha256sum] = "fa3d821dedbbc1f83162246a02f0377851db172ca8c7ac9a59ae562b97514786"
