# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "33fc89d8bb6e5bae235ada6348ddecc6"
SRC_URI[sha256sum] = "7b1d930c7086e5414f6d4e4b336027a3eb9856421d165cd2184aab5ff0dca7b9"
