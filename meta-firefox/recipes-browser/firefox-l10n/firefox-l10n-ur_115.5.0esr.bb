# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "27cf2cc8f043834dd94fdd76df69f0cf"
SRC_URI[sha256sum] = "d5ed85f6f1fd96266fb381a0efcf65c6b37cd28a7768be6537a7c5a0db573598"
