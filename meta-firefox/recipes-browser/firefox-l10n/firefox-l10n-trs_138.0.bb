# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aa695060833de35fe084aaf4e54847a7"
SRC_URI[sha256sum] = "0663bbaa116f095cf80da7f908bd14a8af8ddc2d23d15834281ade6255230f47"
