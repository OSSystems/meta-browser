# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e479e3abcf71127ad949926f73feeb88"
SRC_URI[sha256sum] = "89818992c306d97205b3b3425ea6e4fffed4a40270684fcf2effe2d8bb6fc3ac"
