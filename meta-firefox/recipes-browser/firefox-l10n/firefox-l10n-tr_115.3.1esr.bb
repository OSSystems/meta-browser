# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b98bfa27ce18a008dd242e9d2574db1b"
SRC_URI[sha256sum] = "754e30c4d739c0a5039c3e22e39505c24258f5e833565da7eb922cbdc4cba0b0"
