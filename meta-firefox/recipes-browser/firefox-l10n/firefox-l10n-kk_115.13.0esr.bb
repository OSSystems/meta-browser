# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "04dd024e98fb40bd9a9cb66b7b40f9db"
SRC_URI[sha256sum] = "0b8932fb05aa5b1c57a6035ed9bc88b33832590ca214cbf70ff65533a647d37b"
