# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "95063fb149a3b52fb31abe54ddc487dd"
SRC_URI[sha256sum] = "0c1737e08d6053e24f5d3022d0b616d983596b159e00c6acc211888396468cc1"
