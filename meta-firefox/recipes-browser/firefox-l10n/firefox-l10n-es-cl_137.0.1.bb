# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a510b9e72bb56508ff0bf926c6f18956"
SRC_URI[sha256sum] = "6bf9713ef7d9d2929fa90cd6054d7cf009545306842fd1c11e8e86aa1dbacbbe"
