# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "24eb1232d6c508980f8cb27de9a5aad9"
SRC_URI[sha256sum] = "c015e9424a517066def08626a38e5c0bc99a8019d7d4c108e7d338fe2da96b4b"
