# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "39dc05a08a56ac153411fa609ae96534"
SRC_URI[sha256sum] = "f0393719be241ff0a570dec078d7c8700673c579a750c336130a8e0b5baceec8"
