# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e13002ef15fd38b20384ff6c0b3f8ea3"
SRC_URI[sha256sum] = "f47a1032dcfe5ac5af4a49fe64f996fc27857da4129e30917ff28cc9cf03563f"
