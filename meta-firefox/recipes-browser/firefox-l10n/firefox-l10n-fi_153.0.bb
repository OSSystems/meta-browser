# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "b62f251e23edef0d03c2e2707f45b20bb2fc33d1d86b9ca202022ea0c288699b"
