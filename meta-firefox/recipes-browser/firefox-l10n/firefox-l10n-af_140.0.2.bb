# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a3a92413fdd976a090d6ca1822a8d3c8"
SRC_URI[sha256sum] = "f32d6bd830241ea188d0cd1d58c2cdeadd910d057d9c616476fd001a9375b501"
