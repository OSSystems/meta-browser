# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "44e7a24eb373f399ea1f077cf3019795"
SRC_URI[sha256sum] = "fffab6269f6c9ef4a777b77b93b0e18d80d5810242ed1747efba0e3dec15b761"
