# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "744faf02340fa73bc3c19e1a1ac6a154"
SRC_URI[sha256sum] = "5cf961564b3e4ac6033c104ca008780f12b532be2a743b9143980a22caf08f9a"
