# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "262289d0ffc2dddf2a82ea1990794600"
SRC_URI[sha256sum] = "0a2730457f2a3ec424d18a9da2d62a7a00937d3da0a50a62d7ae6ce06b388ab1"
