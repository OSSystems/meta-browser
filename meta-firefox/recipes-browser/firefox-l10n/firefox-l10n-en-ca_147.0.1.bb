# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cd3bbbe12b7e87636e047381d66323f9"
SRC_URI[sha256sum] = "20fe8c1af16e823f878725e10b30087222a52001c83350c566a29c573d3c56ee"
