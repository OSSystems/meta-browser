# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d9bd8ada4f41de35f9c326186711baf3"
SRC_URI[sha256sum] = "57430b386f961525da244dd0d51dd3254773528700d1616e2b1c82e4b6a0e3a6"
