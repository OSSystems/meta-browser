# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c99cb282842cc07f2d80e383552d8180"
SRC_URI[sha256sum] = "598b5e20bcf031c5c1b722c35b00062da28cd0c7e4cd5d9322664e5fb4037211"
