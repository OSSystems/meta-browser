# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "8bd49033d225b2df8c347f1e08d7210598bc0f74840fed514f135b79ba1ea1c0"
