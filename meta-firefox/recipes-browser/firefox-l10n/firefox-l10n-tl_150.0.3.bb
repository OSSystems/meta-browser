# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "1ed30ba89823a03aa65408c9b5cff60bd341dbfe4705f62395ca1cadf1c5600f"
