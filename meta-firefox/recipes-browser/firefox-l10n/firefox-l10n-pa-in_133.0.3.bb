# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "024b47dc38b198de2e9bec03438cea0f"
SRC_URI[sha256sum] = "200d0680e426a1609dab2219701919145563cd255664105024d61de2e7c5b26a"
