# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1defbcfa3ab7fa373c9000450aa99fea"
SRC_URI[sha256sum] = "446c00e10f109d59576bac0fa90b3a74472f94e9adcf9b1245dd8eb390e374cd"
