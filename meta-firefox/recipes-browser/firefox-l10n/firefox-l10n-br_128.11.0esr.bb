# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "758d06551f6166caf4bddcc23081a872"
SRC_URI[sha256sum] = "e1f03ae303c2f7c033f6f94dd6224d4baa152bc7e44f2ab2e2a02a64e46ccf9b"
