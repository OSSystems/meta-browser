# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c07a19be282299a22c949614b5615d03"
SRC_URI[sha256sum] = "a9d2c0ef15a6d7470f2abbeb0c889e8769aa88ceab43d3ed8e87a9d86905ba84"
