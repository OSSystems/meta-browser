# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c0cb51aab7170afaefd87adf01acfcdc"
SRC_URI[sha256sum] = "6f9d94019b8ce01a6ad4e121dec83ebb43e093cc4ec1152f1a2bcff561b359bf"
