# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ae21fc0510d5b51ea27ef25fb18e0f16"
SRC_URI[sha256sum] = "cd27b00c178f5b7c31813a8c9e37aca1564fbfff79d4398bf0437bfce72f1a36"
