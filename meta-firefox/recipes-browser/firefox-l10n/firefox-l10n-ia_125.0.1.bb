# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7d74657c5bfcad81e94c9a83670f1998"
SRC_URI[sha256sum] = "4f1441f1ab74d50470d0e59cbb76db58d5e8e45b06efd50bee0c6e1ae0a1901c"
