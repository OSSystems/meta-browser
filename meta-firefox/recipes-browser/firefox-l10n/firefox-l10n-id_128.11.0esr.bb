# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f10dae963c12f49903704854c8b4bf23"
SRC_URI[sha256sum] = "d0d15ccc5833d6767b9c87807f7f94362a022d6e0514c94dd215e755af18e1e7"
