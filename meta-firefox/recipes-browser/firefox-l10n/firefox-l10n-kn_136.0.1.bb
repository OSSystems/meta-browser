# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f7198278db731cb0888fb277028d8885"
SRC_URI[sha256sum] = "c0d3b562f1b4428214a45b47428a7e39ab06e44626124538d89e5f3391f83cfa"
