# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "06187a6e2450396f9a1e1aa516d595d1"
SRC_URI[sha256sum] = "e997fa27c70819e7dacc2eb63f6344951f52d52e93c15fbef3c3f5a85575d333"
