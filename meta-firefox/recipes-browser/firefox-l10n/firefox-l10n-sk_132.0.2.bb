# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d89534e19d475af6a3414799c207aa3a"
SRC_URI[sha256sum] = "1206597da7d2e81e0cfe637e5e67733d5c4672ee1033816ad959cf3bb7e1d53a"
