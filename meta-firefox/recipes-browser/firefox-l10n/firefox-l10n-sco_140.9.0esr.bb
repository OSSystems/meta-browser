# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "76e32aad42af20f101de9d1efbe5f77a"
SRC_URI[sha256sum] = "0636ed9ebadefd8075f20312032ae61e35b0020b00e4c95d85ee2b840aa602ad"
