# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c2b5cc2abe38bd6f19bfe1b107bd5684"
SRC_URI[sha256sum] = "32644636472502557782d8baaf6251264f0b4d8569398c6d87f0fb8eadb92911"
