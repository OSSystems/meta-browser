# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "bd5e5e1fff4665ae27cc5645634dbd0cc99ae21e022009c47802975f0b8fa5b8"
