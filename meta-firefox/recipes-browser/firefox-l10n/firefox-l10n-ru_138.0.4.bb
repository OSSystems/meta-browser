# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eb4a20e2c30d36163b109a47aca0b9cd"
SRC_URI[sha256sum] = "4e1d5b578ebd1d2d6cc4b7728c574491be93cb11958ab95050534b36cbd06615"
