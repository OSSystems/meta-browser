# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8a4ef0ce899e0bf88c83cd3b7f9f9655"
SRC_URI[sha256sum] = "b36c1e4e4ada11dd5c1da547e143f0fcf42da747f4c871cac63ad3153326754c"
