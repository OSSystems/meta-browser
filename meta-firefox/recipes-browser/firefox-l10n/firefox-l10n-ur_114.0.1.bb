# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e70ec65e129b6afdd60440a448de0aea"
SRC_URI[sha256sum] = "30e901c2839de9ee163c44afb585afd24a1a0fba5d127c733277f1844b672ff3"
