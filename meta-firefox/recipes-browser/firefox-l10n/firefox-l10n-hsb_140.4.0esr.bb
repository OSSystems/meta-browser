# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "79152d7cba0f0480677b9cfd8a393233"
SRC_URI[sha256sum] = "79fb110f3357804f89a17041df617f4e28c12abed0f3a81437d1d17ce4fcf525"
