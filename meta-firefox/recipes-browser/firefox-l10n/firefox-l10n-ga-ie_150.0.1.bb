# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ec2b7080d4f0a0a99debe79514c22c0376ca7f906ceed7fde0b619ffb8ad65d8"
