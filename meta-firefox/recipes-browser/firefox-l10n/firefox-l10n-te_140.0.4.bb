# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ed9cc02bb1e2526f52a69aa0d555de3c"
SRC_URI[sha256sum] = "0088b86109030eee06263ecee674f82fab74d79b8bf07d4369e1fa324679eddd"
