# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a2c6b853f4a5bd0284ec7b5d495de972"
SRC_URI[sha256sum] = "e66d07577519b3d8aa2f49a0b3723d889c145837ce42c88914d8e14c75b365c1"
