# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0fc496d8bc3aa097692f6f447d080f93"
SRC_URI[sha256sum] = "8f6904d8e84411601ea0acfb653cc570581e73f13d1013943086dfd0e5995478"
