# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4a19adcd94d12e6582ca9b13b3475ead"
SRC_URI[sha256sum] = "d11b2bf5bc38cb4bb6a180326fc6430512a6d2c6fafe714662fd7feaa67a464c"
