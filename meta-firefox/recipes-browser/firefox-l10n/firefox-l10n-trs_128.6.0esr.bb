# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a92f13998bb7dd3ad93c09fe0a1b8046"
SRC_URI[sha256sum] = "86399a7afb3743f36ba8744c2329685cc82442badbf1ebde5b62f350e31b08a3"
