# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a6d0e1966eeacbfac601ceb8857b4401"
SRC_URI[sha256sum] = "301cf27cdf2d8bd85fec15c7c773899d2fd014dac34306213349d681b2e40472"
