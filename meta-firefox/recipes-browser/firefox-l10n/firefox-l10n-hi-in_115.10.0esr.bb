# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cdeaad84e1fa9386bf6cba805c35aeab"
SRC_URI[sha256sum] = "36f8c52923dc04340628955f684fb71caaffa3e75af01837336a8ed2383622ce"
