# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "f7baa8c019a70f37df13d174d44f757772067bc71acb4134cea7571047ea3e4d"
