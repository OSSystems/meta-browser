# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "014448fa4daf21c91c27704fd567c777"
SRC_URI[sha256sum] = "b0b7edc9d453ef77dec02bd930b4e89973ddc061f0efd692ba772991c66806a6"
