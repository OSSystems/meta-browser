# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "97631cc6e5a01a4b3acea74cc10a249d"
SRC_URI[sha256sum] = "720ddce8ab20e69c3450c299b067170f85820ad56b60c5f80bf1e3bd71593b5d"
