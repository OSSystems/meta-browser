# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2e24938e276785ee801d732f95210b9e"
SRC_URI[sha256sum] = "76fdb645e051ba4f127620835f7965e221bfbf3ee39673c969abde1fe3d43dc1"
