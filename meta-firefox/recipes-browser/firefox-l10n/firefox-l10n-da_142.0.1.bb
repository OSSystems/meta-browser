# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b887eca934fe069b5e11034c460b4de5"
SRC_URI[sha256sum] = "ad337b5253e214f769baf7b0700156ee5fdfc569f87e6347d1d435aa4b5cedd6"
