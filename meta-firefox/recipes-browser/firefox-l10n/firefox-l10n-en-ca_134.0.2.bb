# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5ee3d221181dd77e095180f66cd1954a"
SRC_URI[sha256sum] = "00192df6dc37d0364ba1c228e41844dd530e12279597b3a7394a30bd114be518"
