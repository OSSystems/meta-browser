# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8c29a0f3308c12148aec13128bc85323"
SRC_URI[sha256sum] = "f65120539759933245ba731ccd6a706d33d68066017970ffe4ba26bb10fe149a"
