# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2c53a6e6c3d70bd17e1a4a35d0db3fcf"
SRC_URI[sha256sum] = "2d436a04841dccd4b19f0ed1e6606e4b1e23207a3201c92593dcef44bd40b0d2"
