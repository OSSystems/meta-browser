# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "435787626e8825bf9f0822ddd25a4ad6"
SRC_URI[sha256sum] = "54f47ab7dd023ad9182827ac1e600d49aaee00935d63555b3ceaa17314cf6c8c"
