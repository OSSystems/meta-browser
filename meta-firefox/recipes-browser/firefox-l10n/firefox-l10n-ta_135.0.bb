# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "563c584f4fc28c134e90a505d5ab35bf"
SRC_URI[sha256sum] = "ba7203d7a9a9d7b3f0f8ad73b3d53c095c7d58b8ad8dc3cffd92f46d1ad89f64"
