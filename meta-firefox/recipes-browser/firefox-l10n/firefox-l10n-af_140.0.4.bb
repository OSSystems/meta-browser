# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "69542a739ebb7552b6e1367de013fc67"
SRC_URI[sha256sum] = "2d932bf7f51d9787b5a6343e65fd4aba98e765af6066e568b239281d0cb26ac9"
