# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1f0d341480e96276a03dae24d3195f53"
SRC_URI[sha256sum] = "78eec917a41f4c6926fa1b2882afa2ae1ba6d146a989dd91bb4b59b128fa2ed2"
