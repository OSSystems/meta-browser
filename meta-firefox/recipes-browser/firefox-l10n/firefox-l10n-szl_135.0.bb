# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "110a7d6dc8368a99f8f69551a49615c8"
SRC_URI[sha256sum] = "ee3a3f34cafce9dd59846a9d2591b2201304fc715d6144b6a6f381fdbf868cc5"
