# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "05a286de8e5918ca62444c89d50fb7e5"
SRC_URI[sha256sum] = "54b26d998e7299392c97b067bf8cf6aa982d8cecd3a1f20885cace281b37ac38"
