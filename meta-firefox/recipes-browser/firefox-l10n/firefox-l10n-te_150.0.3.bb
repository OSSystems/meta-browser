# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "86e7fe0e04ba49e665c4f9f0d82551cb1881a90a8230a3aedecb3942c4f8ace8"
