# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4b2155fb8961e98d5c7ce36c605f7c22"
SRC_URI[sha256sum] = "245bfabb5fb7981ddb37b0eb0bea552a15304c06e7b770a45ddb5ae7f4f76efe"
