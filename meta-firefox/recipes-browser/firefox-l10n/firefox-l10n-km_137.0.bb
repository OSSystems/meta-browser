# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9a9f038dcd75c009a5c83af25fd5509b"
SRC_URI[sha256sum] = "c2238532be6ee57fe9010115e253315f33b9b8cd949cd56f4909b25a6f85c950"
