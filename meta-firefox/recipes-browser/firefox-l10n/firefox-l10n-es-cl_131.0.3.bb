# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a0fdcbc5051f412213eaaf10837b2b9f"
SRC_URI[sha256sum] = "f2cc7f2051d4a8ce1043f5ccf25d640aa9b053304f10c211114b304f3d707a4e"
