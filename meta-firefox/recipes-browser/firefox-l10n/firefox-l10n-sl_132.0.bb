# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "84b289c9cacd6eb541bc8c734ba3c081"
SRC_URI[sha256sum] = "028cb7bf4d05409b9eda58538237965ec2489e31fe22d6d012d44b0ebb00632d"
