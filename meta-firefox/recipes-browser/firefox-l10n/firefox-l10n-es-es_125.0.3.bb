# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d858176175e8781808fdfe26fff2b30f"
SRC_URI[sha256sum] = "8b179f0fb81e371914929ca8bf41644fe3246afdf781092f3fc1c6e475365cf6"
