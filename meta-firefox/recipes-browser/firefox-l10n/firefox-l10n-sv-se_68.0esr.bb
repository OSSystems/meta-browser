# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "395b235aeb48da65440ff34841e569ad"
SRC_URI[sha256sum] = "83cd4f4769a7363004e322762735b3583ea9414a057fa4d2f16eb588fad7bec2"
