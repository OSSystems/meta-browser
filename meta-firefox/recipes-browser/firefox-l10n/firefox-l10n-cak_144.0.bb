# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3884740166b642c5334c07c187f29d02"
SRC_URI[sha256sum] = "b48d4e544a9029d36f6e5251f0a9b7fb273c83c60813b1d70add392e820e7581"
