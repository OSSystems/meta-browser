# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "70ca2a5483ad062fec6230aa604f461d"
SRC_URI[sha256sum] = "dbdeb924c33027937cd27bd0f1f3947ca8aee17b2511c8ad27fb119952fce1bf"
