# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bd5374bfc139880bb9778ead00aec344"
SRC_URI[sha256sum] = "9c3f84f6f22ef46af1a3db5c103fbd65bf7cb269b50ae20da87e282daa8ec320"
