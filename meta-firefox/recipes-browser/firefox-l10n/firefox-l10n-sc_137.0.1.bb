# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f7cbee1b0825f9ae7d2151ab6d506e01"
SRC_URI[sha256sum] = "dd9eaa365fb8899d5ec71997fdd87fdf3e74f0cab654a67a688772f904c4beb3"
