# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f5633dcb1b1aa17b541935c38f284c0b"
SRC_URI[sha256sum] = "be45c53220e4adeb7d99e5c4d214ca057c35bbc20ef7ce5d5c31031ec99120ba"
