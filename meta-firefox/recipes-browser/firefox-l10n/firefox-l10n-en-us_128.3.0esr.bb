# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "01cb8810ea57b5c93734a2078aadbd56"
SRC_URI[sha256sum] = "ebae8b930d7609b6aedc7a1bb8c4156e4fff5e73622014e85f59178add2d567d"
