# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fd6a1535782dbace1cbab37f5dd6a139"
SRC_URI[sha256sum] = "6b2cb3c5e9eedc30b3d5521071214308a194d60ba1c6b519be2a4cee4852b26d"
