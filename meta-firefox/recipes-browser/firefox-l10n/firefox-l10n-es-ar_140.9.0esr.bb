# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5ecc6704fa394c14d91dbcae087aa36b"
SRC_URI[sha256sum] = "7821dc1e9cd19fb46dab81e5e028e7e448c6fa273caacffe0fe8d08b96072e66"
