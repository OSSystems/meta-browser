# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "44e6926be2881bc3e27c1cde57c94e28"
SRC_URI[sha256sum] = "bb9665a2842ddd5edea75ad1c87bac63d0006590d43c6ffa296f01ddb90c1772"
