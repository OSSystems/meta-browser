# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2ed093a40272a24c2dd4989004ded898"
SRC_URI[sha256sum] = "6871a65566dff4c5a11ea07145da8dd7bd06b44fbc1e880b85b1bdbbf0f090b1"
