# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1e57ab6de283582f03f3e857cdaf3de5"
SRC_URI[sha256sum] = "ea89e759ab6cacb49d36e5836c463a180288273bf2dbff06e11ef3e6c77e7f36"
