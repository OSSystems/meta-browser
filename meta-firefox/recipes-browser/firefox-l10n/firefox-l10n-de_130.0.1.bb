# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "404c912f14ebfbe25ce37320e012687f"
SRC_URI[sha256sum] = "063b1bf87584ca655ea53441b074a9ec5d7f3bba835f27f577fd2f064b1eccd1"
