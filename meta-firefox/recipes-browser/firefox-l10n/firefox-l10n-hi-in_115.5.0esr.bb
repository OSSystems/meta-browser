# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "af13686734f995fdad46355860ea41b6"
SRC_URI[sha256sum] = "154bdb3f3a8c5ed67699d1503c925abc5e5a92bb9828ff0edda6badf2b6de023"
