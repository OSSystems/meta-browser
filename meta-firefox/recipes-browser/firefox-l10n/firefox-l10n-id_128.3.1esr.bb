# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ea72759271daed026d2da975afbc8bf0"
SRC_URI[sha256sum] = "c3d061965444c42ff8bf785a97e977ec8dcd394f953d4f521c8b267468a28826"
