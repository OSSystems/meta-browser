# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b4912eaf0c8b14ac48e994405292401e"
SRC_URI[sha256sum] = "3185e708bf9e89e6eae59d3fc50031d60205817f9fa9b8b2fe8f6409250ed7cd"
