# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "39804dfc9bda6e98356fab10aeffefb8"
SRC_URI[sha256sum] = "bad59f608893cba1947a3f20e43a6df17afb3590c1a975c0f551493b18217331"
