# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3ac29c4c4f46094c0b8f34e02f605395"
SRC_URI[sha256sum] = "f9602bd77a9000aae846611d0f18d332b82fb45e62febb9e93ee122a5134807c"
