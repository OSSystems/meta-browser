# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0de7023ac3e27e05a7efb43bb44b0191"
SRC_URI[sha256sum] = "cd380efa723dcd49dbad95182f4b6a5648fee3cdb84f0f2c0dbf97e833baed9d"
