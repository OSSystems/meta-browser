# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "b6c444d113602d65f5cfa725b90dc0d37df677fc89595a786fccd9cbe577bcd3"
