# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5cd85b57f6bd204907485220404f1b25"
SRC_URI[sha256sum] = "5b7bae2866c1789220cabd828045a133c8ac3e25a535367759ac46227d2686da"
