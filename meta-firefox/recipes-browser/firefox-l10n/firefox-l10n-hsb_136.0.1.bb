# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "650f388f00f31261b24356595307da76"
SRC_URI[sha256sum] = "264dda26ddf66468fa319f22a194e22efc5d8381a1ffdb175e8a19b8fc73f235"
