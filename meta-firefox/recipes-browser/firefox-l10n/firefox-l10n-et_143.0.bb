# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "63a2bfe9ee95fe454eda2507497bdbba"
SRC_URI[sha256sum] = "7e5b34a2cce03e7afb46c9afbb6df4b0e10aacf2042897d5b4da7b5e131a0258"
