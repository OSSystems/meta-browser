# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "554022d669a2cd02d57069fb8f857437"
SRC_URI[sha256sum] = "1240e59f672c763c71ec291b9893261ea602da9752862a8a31ec411baa9419b2"
