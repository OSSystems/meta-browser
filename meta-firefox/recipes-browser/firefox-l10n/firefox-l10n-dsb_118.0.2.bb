# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "22fb7f7a98f32c9fc1b836166442839f"
SRC_URI[sha256sum] = "417f004593c337ddfe80de8a898370ec80054526a73623830f0a5e6e42d0dc8c"
