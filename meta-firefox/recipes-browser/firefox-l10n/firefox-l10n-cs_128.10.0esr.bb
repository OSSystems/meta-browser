# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "48cd260e6d94596569c440e8d0c7d81b"
SRC_URI[sha256sum] = "320288ce9acab0dbeb7340e9eeefc0bb5722756757dffe9ddf35f3bb6a9baeaf"
