# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d6ae26818509bbfa9861d3cfbc2d31de"
SRC_URI[sha256sum] = "916b711a7635c670b676c497b04214ca2b5cbce392ed3cde172b7a92e256f9a9"
