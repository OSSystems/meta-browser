# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f8634a8734986592c724052a10d6a3d2"
SRC_URI[sha256sum] = "f9694e5b0f141882300c4c54dc1ae0fc5fb3a6366efbad0fc1864e1e3b15763c"
