# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7a54c9f8c4dd67355c93d0d98d62b3a8"
SRC_URI[sha256sum] = "6a0116e4c791a9a374a3a4d47bce426e21b934b1f008fa63afecd8e3d8464239"
