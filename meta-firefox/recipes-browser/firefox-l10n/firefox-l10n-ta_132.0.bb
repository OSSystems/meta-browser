# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b0f554775e620cb070c7879d96f8aaa8"
SRC_URI[sha256sum] = "7ec63cdb37af0123ebcbd08ba6ec5b33435c556576c1651d94d22b5d7b96b9c6"
