# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c52018ac11fbea3dad7970367f844482"
SRC_URI[sha256sum] = "52f2d8f8476195e1b62178d54b9195d04659a9f3aa47b9d1ff001919d67a4431"
