# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a63472ae48fcd5146adcac312e3a5355"
SRC_URI[sha256sum] = "6f504123236f5c63aceb50a1531de11afe668ad4f2e33b5ff4adc2b646f02905"
