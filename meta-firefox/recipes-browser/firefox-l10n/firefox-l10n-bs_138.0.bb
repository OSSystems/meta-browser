# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "37b246e4a8cf59b4dd24b743e5bc69ed"
SRC_URI[sha256sum] = "043499900b4d538655dcc5a1335fcecc195eec48113a1c3b189c1c10e510793e"
