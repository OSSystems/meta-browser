# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "5a852ea12cc329993af8e908e76d7d8235ccb9dabb6698a9af94c775d6eac40a"
