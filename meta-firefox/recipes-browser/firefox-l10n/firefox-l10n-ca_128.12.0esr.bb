# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f9fe1185f6cac55b707b1bd720fa0b32"
SRC_URI[sha256sum] = "a4c7d1d6229dc39cd6796651174b5fedadad0933dbae40c0d069175aa57ac618"
