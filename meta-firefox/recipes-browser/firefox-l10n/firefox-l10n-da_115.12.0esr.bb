# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cd082f019177ccbd1815cc14222209ef"
SRC_URI[sha256sum] = "4e8d05f95d5bfb124b7116f683066c199cee01282e92ee1f3edeab65dce221f0"
