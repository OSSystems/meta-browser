# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d84876021c2812a5e38d7682bb120bb841115d6dbcd2e7a2a735ee9e67036545"
