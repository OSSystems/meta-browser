# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "a619d57ed54fc4815ff40b5689304ed67718a31739ec62d7ae5bf63ff2eb231e"
