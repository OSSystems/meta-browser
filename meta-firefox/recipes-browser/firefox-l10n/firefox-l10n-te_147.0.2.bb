# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "289d78f81a193b0b8d158fddb7e98fe4"
SRC_URI[sha256sum] = "133a09523cea5526319ed1feb9eeec5dc16a7aa332e2bde02d6e69127262196d"
