# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5039d9d43fa5e98f724923c02eb1537d"
SRC_URI[sha256sum] = "3c7a10ee57b442a0b432fec6d531f621cb4846b8e5be948d99222be58476ec54"
