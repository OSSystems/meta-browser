# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "634a6ea01d03854d7bf2acad837c11e2"
SRC_URI[sha256sum] = "36484a3a1255610a2497a4edd1b0afe0506c42fdb36f6b2129ae2386e4cd4a11"
