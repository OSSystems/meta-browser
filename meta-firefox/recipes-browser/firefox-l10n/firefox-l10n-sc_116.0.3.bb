# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "92da248e8ef4292617ec77821d501dbe"
SRC_URI[sha256sum] = "5442fb92c3d33bf554b72fe5635a7284c3a3847d4a0034442814678c99666869"
