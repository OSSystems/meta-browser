# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4b5e209fde6efa56bfd11ddc0a232d6a"
SRC_URI[sha256sum] = "cad8b367be91d38cda47c03e65c5511b90ad67404e1c3dc39a6d41a82c259d3d"
