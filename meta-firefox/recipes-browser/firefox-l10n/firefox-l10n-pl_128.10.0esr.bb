# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "055fb5551fdd121fbb4caec819ab6d80"
SRC_URI[sha256sum] = "dfeb82d53d9011d7368b17645c1d5990e13827e7e117d9cc0a4bd756e553dc38"
