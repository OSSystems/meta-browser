# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "65b202cc65c1a99085cdb517d8602bcb"
SRC_URI[sha256sum] = "3900ca526a233f345bed250454b6ed70275aae236ac8ff2d1b8912648d2a2fed"
