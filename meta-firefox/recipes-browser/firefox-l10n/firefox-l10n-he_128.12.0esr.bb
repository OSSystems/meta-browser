# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0462b151b2c96e5f08ccef03edaac516"
SRC_URI[sha256sum] = "9f08edaaee2e1d7f6fe27ef0541b5dd24b556c9be2a8b05fc5a05f2b0f82d114"
