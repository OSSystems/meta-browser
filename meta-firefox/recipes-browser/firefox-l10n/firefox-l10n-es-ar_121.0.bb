# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c42c76a77c0878f42fd9d4bb09a39508"
SRC_URI[sha256sum] = "c6de8b7788721baf36ca8a4931a823b9fb3d8ddfb72913a91e563d7a7fe276a4"
