# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a5931161d0c36d005ed8804ef341f5f6"
SRC_URI[sha256sum] = "dd3866c6509f10c2d9de43f7e153bc3bb96fa20c30461950d86d5f2b41c9f996"
