# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f71e8e54e7def4b5b28e0d9e6b6d8c68"
SRC_URI[sha256sum] = "3b46c182237999f024f665cc6c79f15b2b72efdf16588ade100d3c3287b8fd0b"
