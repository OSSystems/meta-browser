# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "259ca991d2e697bf885b1278e8843546"
SRC_URI[sha256sum] = "da0894c02e6f7afe6d8bdc4262faee4cc60ae6730454e269f5de3964917b8bf2"
