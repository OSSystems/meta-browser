# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "30b156fd2737e21141ad60d42dfef581"
SRC_URI[sha256sum] = "7adc05c7ac3f859dd534979a1e7c4ad0d34c7505a980a4fe9748ced0ee90b91c"
