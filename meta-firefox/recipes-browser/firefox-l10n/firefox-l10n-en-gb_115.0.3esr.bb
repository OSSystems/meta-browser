# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5b96be9cf940331f157ff81586a2ebc1"
SRC_URI[sha256sum] = "d91f20abefbec77576cd8d4af6da12e8a6d8a2bb6a96971951ad2de43ca3e051"
