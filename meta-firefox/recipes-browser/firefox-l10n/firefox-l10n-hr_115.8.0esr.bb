# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b8c8b5f68424ec41886a3284bead6210"
SRC_URI[sha256sum] = "184e4c7bedee6f1bddd588a785390c0d5ff45fe7e40a1a0de0b3ccd6d5f65ea3"
