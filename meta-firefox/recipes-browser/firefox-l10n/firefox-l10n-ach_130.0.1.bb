# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "240cf808d93da9537844cd0d54102059"
SRC_URI[sha256sum] = "b27f08481246336f1d8144b65e87306d5d326823b00a894ed9c2909d58f34460"
