# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4c454e1e47034f7af2db0085ec99e18c"
SRC_URI[sha256sum] = "d59216b24e9247b5c311d799324228f418f543c6fbfe5c8264bd2cd36b121ddb"
