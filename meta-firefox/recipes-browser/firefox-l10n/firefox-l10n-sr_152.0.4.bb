# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e1ee94d620acd9f15e187f9c220a4044b86883f3d38e2160e33e6b420a26aa13"
