# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9359ca8addcceb83c49b8b9024951316"
SRC_URI[sha256sum] = "a4039acb95ecb28a54499ef61582d916f8d6297d7df3502e23c7ab810f5195b1"
