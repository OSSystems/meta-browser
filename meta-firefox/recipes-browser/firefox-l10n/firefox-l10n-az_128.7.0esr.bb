# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1d87778c0fbeafc9dca134cca0986c08"
SRC_URI[sha256sum] = "d557b87f767b9c6e555b1074051026437c25703c6a6e8cea93a6a896e82d5bcd"
