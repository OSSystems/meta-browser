# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5c9953622ec2a20e375057256db54b9f"
SRC_URI[sha256sum] = "f3a824cc28a25f73a1902c48729f0a36a4e79f2cf614a7ccbeb569a55ba40ab8"
