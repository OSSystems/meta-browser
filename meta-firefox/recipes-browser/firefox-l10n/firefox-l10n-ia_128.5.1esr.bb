# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3aa525cc4ae4bac5e3ffa79f16ae162b"
SRC_URI[sha256sum] = "d6657ddd52bc4d677f76a4b951c0125a9745d318349db2b712cdbe6296013775"
