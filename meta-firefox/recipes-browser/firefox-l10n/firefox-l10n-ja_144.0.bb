# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e120227ccf783cc9c461bc6ceddbe098"
SRC_URI[sha256sum] = "caaf8593983d61936831a88b306532142e54d79c429fa86259219ca812bfccb5"
