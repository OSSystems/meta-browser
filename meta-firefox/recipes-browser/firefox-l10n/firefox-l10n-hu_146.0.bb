# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3138c09d90da6e2652809893d9cbfd06"
SRC_URI[sha256sum] = "315186fbd20175afb4696f283d3e6e7764a9a64300a777c3037be1eb249a0d98"
