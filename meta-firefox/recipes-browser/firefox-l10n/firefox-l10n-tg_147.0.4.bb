# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8e8967b1cec599a58e414cdb7069ca82"
SRC_URI[sha256sum] = "524fad6a123d220cc98dca4f10d8996d2b1935d8daaf4967b546d6b5763ba015"
