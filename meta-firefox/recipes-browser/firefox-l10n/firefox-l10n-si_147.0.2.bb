# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "47b5a35ed2dec8eb21851e45963fbcd9"
SRC_URI[sha256sum] = "6efe3928c118d986c9f5768d40bca1ab56ff73eea0411deb0e5cc3677723dda8"
