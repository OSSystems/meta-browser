# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0fec5565c58f857d8f05a74443990461"
SRC_URI[sha256sum] = "826d5094d3e0908c5b0bd2280060f46bb452c462b1034a906ad5d2f16c5b843d"
