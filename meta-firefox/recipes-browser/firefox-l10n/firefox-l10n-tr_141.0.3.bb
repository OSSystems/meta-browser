# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "016c908690e6047c4212c2666087b045"
SRC_URI[sha256sum] = "73fbbd6f1b4dba762b8f39102ca2c60b929b8d2936ad13a638558dc5e40cbaf4"
