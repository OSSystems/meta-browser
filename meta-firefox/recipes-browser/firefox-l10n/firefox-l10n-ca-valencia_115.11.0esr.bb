# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "225f77c30d6e2d2c8c54e6e859e79c74"
SRC_URI[sha256sum] = "0bc8a7dcaba9cb4fee36762587bc84d9e426ca784b72216c0f11596911e8fcb2"
