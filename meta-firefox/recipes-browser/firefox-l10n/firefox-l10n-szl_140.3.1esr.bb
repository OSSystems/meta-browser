# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f3b9ac1ce40b3315c8e51328a601255f"
SRC_URI[sha256sum] = "36963325eeb15f07e0d2eb60695e1657d1ca815f32eb99c7404be08a058cc090"
