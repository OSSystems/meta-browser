# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "1f6c6c3c79a8750c1b6c02b9a3975c73637c66528ffc96bec20bd21a7bb49900"
