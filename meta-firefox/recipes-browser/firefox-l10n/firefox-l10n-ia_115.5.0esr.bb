# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "91ee1e6492a84bf640ef69e774458def"
SRC_URI[sha256sum] = "ff80931fed4b2d0e9b62aab0c67b24fbdf13ed8fdccb940708a8d92525103642"
