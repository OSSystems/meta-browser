# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "389d2b87ac0752af3b3b5bc1eeb04312"
SRC_URI[sha256sum] = "7bccb853ac1ad40669cb8ea1d93bb08be985e145d3de4687343cfa5c8ab68234"
