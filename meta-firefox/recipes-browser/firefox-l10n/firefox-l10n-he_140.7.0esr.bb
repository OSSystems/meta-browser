# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b85adc5cb89b68039b7d3720f50366be"
SRC_URI[sha256sum] = "df88720b5c78822721116f66009f221e784a24da9befebd032fe4daff2c91a80"
