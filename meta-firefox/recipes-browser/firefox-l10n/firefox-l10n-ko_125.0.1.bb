# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cc377e83e9e75b292b826220a70af56b"
SRC_URI[sha256sum] = "4c48e24df7ddb0b808e1f664baaba95e0e6fdc7624fdd73ea3832509b97db090"
