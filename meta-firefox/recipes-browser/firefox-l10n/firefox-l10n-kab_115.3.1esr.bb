# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "41d656820f958dd7a394b4bc5243aeb1"
SRC_URI[sha256sum] = "6364768b8e3543e12b0986b644427174bdb72e95cc31c9abcb96480e126b0462"
