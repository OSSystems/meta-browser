# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "1e508393b9de8e95f49f165081c65e0e7c1d633cd91890b191bb0db902c4cae9"
