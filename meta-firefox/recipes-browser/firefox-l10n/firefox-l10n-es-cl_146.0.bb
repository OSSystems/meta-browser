# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db5b4d40da9c310a94b66525f2828235"
SRC_URI[sha256sum] = "fc8e9f54be33ee3fc369eb569e0c4290739c03b607df2fa72f43b95a487168c0"
