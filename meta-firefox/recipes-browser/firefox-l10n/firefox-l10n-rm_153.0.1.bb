# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2cbb12cc6fc13c9999b3f0dc9f4cb916a60772fceffbd8e242445be24205749c"
