# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4184b190404ba026489057731ed4ec84"
SRC_URI[sha256sum] = "f0e8731c8eabcbbccc273dfe268fdbdaeda09c052279f20058544f5cf56fbc25"
