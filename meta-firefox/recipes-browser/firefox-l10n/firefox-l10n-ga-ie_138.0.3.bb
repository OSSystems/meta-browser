# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fc76e22f8bd8a3886086c6926f362ee9"
SRC_URI[sha256sum] = "b6a3a00b197df35ac3e58f31d2af32001f5d935bc24b68290b0757a76509569f"
