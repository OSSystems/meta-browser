# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d35c3e5ca9e22d654b54aa5ca10e0e0713d5020c27ead02fcc32e65ac0cfa0cc"
