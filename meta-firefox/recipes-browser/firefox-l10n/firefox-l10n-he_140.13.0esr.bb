# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "0e85a04a0f44241f61e2d708602ae5fa987d959f1fdc3772ccbba2c557da15de"
