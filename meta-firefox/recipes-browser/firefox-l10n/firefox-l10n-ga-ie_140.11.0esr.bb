# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "feeccfe3e66b3b9d471456a582014a62695ba38f5f25e6e008b869189ffb0dcd"
