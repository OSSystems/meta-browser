# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d12bdb8d53a6e87be15abfc99b6fc5451128b04bd18b0720050b4b76d878a59f"
