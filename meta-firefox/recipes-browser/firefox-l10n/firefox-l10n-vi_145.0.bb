# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "19bfd4131e19e279422b6e74c3da8225"
SRC_URI[sha256sum] = "11cfcb53414407d42d562e1acb7011d37be6b20e0463a5f6feb97e08a94a39ba"
