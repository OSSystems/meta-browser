# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fd1f256a74582b3e56ca152f6e14aee5"
SRC_URI[sha256sum] = "082e984c977a30ba29c2c3fb1b2bd4d42eb89a7a249fd7d2b8bdedc034f329ec"
