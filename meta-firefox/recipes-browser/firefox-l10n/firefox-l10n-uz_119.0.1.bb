# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "320adc65eb5b0ba16d72f5cae8ff939e"
SRC_URI[sha256sum] = "f0debcc4c6effcfbc9ca8bd6f27ce2f7dd7c6f59783c64eb5c95508fd03e850d"
