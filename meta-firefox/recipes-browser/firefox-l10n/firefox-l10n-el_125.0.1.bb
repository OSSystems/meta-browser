# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "978ff4844117e603ec7201c3d366026d"
SRC_URI[sha256sum] = "ad78cd53d212bbd64c18a53fad27690137c48620e165a6b6b00192ec87d74fad"
