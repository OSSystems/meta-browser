# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6c7a43a6e8b877888a781dfd6fe2a0d1"
SRC_URI[sha256sum] = "7c974d6dd1af1752181af50a52209406a7a666eb2e8ce564aae04f770a8cf3aa"
