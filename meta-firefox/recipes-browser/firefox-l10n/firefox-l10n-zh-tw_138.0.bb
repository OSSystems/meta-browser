# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d653944d8aac4794eeeed60ad703ad4f"
SRC_URI[sha256sum] = "e02fdc18891278100d9fd24e7f9acd6c42c0eee5d35b4d4b543637998cec5b1d"
