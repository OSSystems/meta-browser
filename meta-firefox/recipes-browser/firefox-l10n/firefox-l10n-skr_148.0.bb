# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4e3b0483333309bf3db2d606350b56fb"
SRC_URI[sha256sum] = "165c96e505a1102d3c0a20a7540eee7ce55220da5a34e0eaf440064956b78c0a"
