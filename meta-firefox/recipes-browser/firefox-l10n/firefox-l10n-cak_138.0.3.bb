# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "340941e25b77e9dcae0394140b93d396"
SRC_URI[sha256sum] = "a6e770cf046c8bb17c6a07e4179b9b46309ba401b57a07b58d3ca8289c9bb4eb"
