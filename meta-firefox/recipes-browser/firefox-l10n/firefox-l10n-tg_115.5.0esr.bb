# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "20341d349146f5fc678990f89d2fed62"
SRC_URI[sha256sum] = "b0eb4c72a532f574d4f106509e1915382970c454e60f6c15f475a3cd56a2cee1"
