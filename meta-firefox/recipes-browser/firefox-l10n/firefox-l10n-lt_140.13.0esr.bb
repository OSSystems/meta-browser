# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ed96c90a6285256d03735b6b142f661df5ab1abba7f2429bad29f9185922e69a"
