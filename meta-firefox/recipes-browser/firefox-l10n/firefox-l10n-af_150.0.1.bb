# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "df826f0026a3e9a9d2ba8dec51da5a9dab46ecf1a3ad6f0b2aa5868743b18e45"
