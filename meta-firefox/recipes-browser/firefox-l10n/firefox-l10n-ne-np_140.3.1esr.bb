# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a9b61b5d9cdf9504fd28d8581fe27dac"
SRC_URI[sha256sum] = "b92298a024a616e5df1d862a743276d1e7876ae4dffa8c28dac43904af207d7e"
