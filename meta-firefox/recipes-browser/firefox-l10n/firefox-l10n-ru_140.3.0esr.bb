# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "21f3178a32823f2a46d2e47ed99a6226"
SRC_URI[sha256sum] = "a07fb908f1a60dcdf34aa40a47db99a982ee7c120d75a232e4162cdcb334d5fc"
