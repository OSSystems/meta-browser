# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "55e1e89d4eda527ccded90b4e1cee72c"
SRC_URI[sha256sum] = "e8b83be1f76186e866f4519ed96dd7c983973c7a493fc1812c4e997c3779ffca"
