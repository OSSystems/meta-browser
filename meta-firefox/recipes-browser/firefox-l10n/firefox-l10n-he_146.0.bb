# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ff6cf0d0863a2d5b17893bc7ebb20349"
SRC_URI[sha256sum] = "0b079614d076578dfeed97c6fafdd5b5317a4719d11cbfc83fcdea51c0dc9c40"
