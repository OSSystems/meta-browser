# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5001274b815e0115139192c429528876"
SRC_URI[sha256sum] = "9fad2cf8dc0445000b2661816bb474686e00bfb74a40400ddee2a9e646a1d769"
