# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4882d980d85abab463ea416dff2c8913"
SRC_URI[sha256sum] = "81de985986afc8ac2c80a9a638640c0fc9bdde210000cbb63e7a0e2abcafa0ac"
