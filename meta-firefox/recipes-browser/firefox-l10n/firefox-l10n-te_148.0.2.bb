# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "62b03e3fa285675a9a98b69bcee1d14f"
SRC_URI[sha256sum] = "248ff35e8292afe0ad38592a8c8625e9a1e1b61d0ee94767dc0e8c01c24f8df9"
