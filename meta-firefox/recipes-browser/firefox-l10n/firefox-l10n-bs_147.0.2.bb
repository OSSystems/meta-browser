# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0ff3bc3c3e71a6b0b8d8f6978c824c75"
SRC_URI[sha256sum] = "640fbb5527e367574b9da4a0f2b4f2c05c2a3b02632eedfe06fdcec0fbe53539"
