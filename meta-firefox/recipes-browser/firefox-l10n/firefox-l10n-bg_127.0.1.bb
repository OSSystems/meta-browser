# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2b3449698e4570ce839c851948900b7b"
SRC_URI[sha256sum] = "15aa38dd496fdd7ebce777fb99b6cdea45370f79309e167f5c41437bcb553105"
