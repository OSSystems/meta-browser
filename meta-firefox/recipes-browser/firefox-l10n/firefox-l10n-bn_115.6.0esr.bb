# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8f973c588697cbd433722ec2acf50b3b"
SRC_URI[sha256sum] = "749e21b5dde95292b7ed252a36b5fcc5b5e0cdcc7460c27bf1ad243206b59804"
