# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3e73f2111da167215ab3477db4b5029b"
SRC_URI[sha256sum] = "9fef671e4473c435b91f4144f03e210ed0a84b1cc1aaf2240c09831e900cd3e2"
