# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "6d59a1a68de5936a50fdbbf1bac4d6efe8e011cff44c2eae66c8d671c64ef3e1"
