# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3846e00781a80d80f5a0812750a3899a"
SRC_URI[sha256sum] = "dd17be645fabb53b89ed09b4316cf848721fc29c53618d848e0385b82e4183f6"
