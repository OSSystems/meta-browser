# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6023eaac12f2a5323a9fc5e4dfa423d8"
SRC_URI[sha256sum] = "9a4bfed1568dbf59626bdc10cb2c8047799211d78a3560622b77d24643ec45dd"
