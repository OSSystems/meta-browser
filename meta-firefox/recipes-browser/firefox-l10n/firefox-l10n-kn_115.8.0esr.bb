# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b4a84827a11294c3391b083918e7fcb7"
SRC_URI[sha256sum] = "8fc06a38ff912f98c35afb58b393ebe8785aed1a0d8d4dc43d5dac8831fbfea1"
