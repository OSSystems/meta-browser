# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "39d5e06a4d7dd6110f27206008ff9d61"
SRC_URI[sha256sum] = "397610fbcfbe48430a3554cbb3b02b536832f62527aff406a7ea354f7c1c3af0"
