# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2231e8b59fa9cb775ab7cb1e2acad8a3"
SRC_URI[sha256sum] = "bcd04d47959ad7f2ed46518641d9b6dbeadedc66e44943baf25ca1a436aff602"
