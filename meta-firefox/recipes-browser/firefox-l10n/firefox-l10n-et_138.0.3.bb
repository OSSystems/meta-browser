# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "16f080bf0bdd0141c2a0b32805c9cb29"
SRC_URI[sha256sum] = "c56ea4a81404467ea3b3199bd92f0e1a956127097e2dd3b05c5d959a7b6cb3b8"
