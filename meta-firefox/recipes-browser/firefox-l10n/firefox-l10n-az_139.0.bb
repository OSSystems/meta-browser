# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6a5ecfba15b9b4ecea1f7043ed572a7f"
SRC_URI[sha256sum] = "55a4422ae4e19730a87620d7eb11481fd24e7569ca0e4fcb69362a7cf76ebfd4"
