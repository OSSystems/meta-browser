# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dcb7a33c3cbd3b9feff7c5a689678cf4"
SRC_URI[sha256sum] = "5e1eaf7db7f517f72fa443bfafca7cf5cb8ed92dbbf9688daab6d23bf67342c2"
