# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f736dbf2efcd8f0749e857ecc0b816cb"
SRC_URI[sha256sum] = "5528ed5e49efef071dd91955334c587ee036333df7c7c03334bff901f4408e10"
