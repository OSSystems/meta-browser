# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ee02b474abfe82fbd65e05769e6ca079"
SRC_URI[sha256sum] = "0fac94480fb07fabca0e4967497e9cebf17acfbd4ec0357d436e9521221af76d"
