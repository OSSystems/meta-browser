# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bdef9a70ee51af10e13d7411423f76e9"
SRC_URI[sha256sum] = "0844268077d260ddcd00940c41dbbaba2a7db68e4209cc04174379dd054715ea"
