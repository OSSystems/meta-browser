# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "da3dd27f23ff603c4acf7484ee3ee0af"
SRC_URI[sha256sum] = "49f5e4d040a81e68db726f9ee29cfcd07ca06c8d2fc0c49c187f5a381abf511f"
