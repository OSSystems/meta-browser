# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "79cc67547baa685fbe0e8e2f1c248a22"
SRC_URI[sha256sum] = "0a0cb7605cf3bacd7c2ccc7acbb5a5e4182c89246f81071bff8b5456cb6c5856"
