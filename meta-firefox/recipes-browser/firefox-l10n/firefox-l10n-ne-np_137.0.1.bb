# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "310719bccc1d6b16a92478aaa8d64418"
SRC_URI[sha256sum] = "5a5a671e59f5c018170439ca2ad9dc2f17dd1b7e8ed3cdf7ecd2ea76746640c9"
