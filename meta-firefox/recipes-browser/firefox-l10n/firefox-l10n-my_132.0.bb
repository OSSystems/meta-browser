# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "593f8d21870dd858af7440623bd4f7df"
SRC_URI[sha256sum] = "0d9b6f102e371bb476ad233c0d4927ef34134a866f2e74f11d9d900ad55ed3d8"
