# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3891f101e2ef3e5a801f0eefda5218b7"
SRC_URI[sha256sum] = "d67c389e081a92745e229e732e483976ef12856c622aaef626cf9da51a65bd74"
