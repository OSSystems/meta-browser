# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3494a6add7f1181cd2ef761cdc72b3ee05c6032f9d780378c8b3fda7e420bef7"
