# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "9e636256a6660c20691d6b51ec75c04d3690df72454d0d92a1989072530b86ce"
