# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "719e95b797bbb8369d9428c90c293e3f"
SRC_URI[sha256sum] = "6e75431d005bbf66fe5b731a0b43dcc507b859bae85bbbbb384a661bad0f444e"
