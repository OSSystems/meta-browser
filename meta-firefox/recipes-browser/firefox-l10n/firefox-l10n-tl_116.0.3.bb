# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "89e3dab484ae7a2966d8d8e328d7fc1b"
SRC_URI[sha256sum] = "65cd1cb918d697c7618bd902bfe93d1f5fbfc84bf5304fa0530eab9329fd2aef"
