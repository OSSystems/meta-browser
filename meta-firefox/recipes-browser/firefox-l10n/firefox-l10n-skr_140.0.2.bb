# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5495c703d2a81c6ccbf5cf043a48083d"
SRC_URI[sha256sum] = "93b7d0fb9fb1229081f23ff6384f33873c913eed2c0764dc60b1c05df677d126"
