# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "775b2d6b38aa651e3981bdf1880b287d"
SRC_URI[sha256sum] = "cd0fb1e3ad51b5f302849b2aba8596af4ab619646b98cf6203b875e3c3915315"
