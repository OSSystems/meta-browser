# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6b9451b50cc545ca61ffe51170180922"
SRC_URI[sha256sum] = "1f6e03b24e4fc0b4dbd20da4dd0b9b1af48690376a96ec89793749a0490dcde2"
