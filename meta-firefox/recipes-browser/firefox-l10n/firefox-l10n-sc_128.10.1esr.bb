# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f71566eac0df1ee0f4e8baf559d27dd0"
SRC_URI[sha256sum] = "c473ffb17e57cb31d387e94d4a33f3b115f295375c68bfa212ad75c05796eb9e"
