# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b95eba533eae23486a776a470e367919"
SRC_URI[sha256sum] = "fd8ebc3679c4c52662193327242b41228a6e7120d4775ecb306cbff4ef7d4927"
