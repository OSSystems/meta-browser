# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e7d2fa7ad99e9e3406b83c51d3dff86a"
SRC_URI[sha256sum] = "b28aaf482452a21659df10f7f6372a62672eecd50fa1ef46f6ef10c5987550e2"
