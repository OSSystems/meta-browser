# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a175e4cab623ba038e2b44acdd7d1cfa"
SRC_URI[sha256sum] = "a4cf815e17f7a4a50094f55721ac119ce59d58f1914b01930b2271dc9d5bc704"
