# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f5427cf45fcb0fecfa84ebe1b21fa9bb"
SRC_URI[sha256sum] = "d995f5dcc34f1ff521c64269fb16fc53612327628e7df56a122d99acc2e29375"
