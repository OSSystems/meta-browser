# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0e78665ab2564fd28a6de22efd8e40ba"
SRC_URI[sha256sum] = "64f140d5cd2b164d437c244bb6e60433e646aedf75e1abc2d05f51913a90f1de"
