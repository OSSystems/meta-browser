# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "84d7ff70f63825d802dbcc82b0feffc0"
SRC_URI[sha256sum] = "8554bceee207ad121d6936347d082e4b955a52f7a459274bde29e66b7fac2346"
