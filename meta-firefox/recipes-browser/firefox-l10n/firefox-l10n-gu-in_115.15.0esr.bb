# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3ae5d62ab93e6747f0f78c4341df8b23"
SRC_URI[sha256sum] = "a449afeeb773544a0d2bfa391675f23d2ee0079d188b60fc936f2341e1cb7117"
