# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "871a32cfccccde5a33d15df3b9ef689d"
SRC_URI[sha256sum] = "769c1ce4e55353a3f9839f1039433b5010100d86b0be52fb32aad10633c2348a"
