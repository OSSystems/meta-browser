# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "28b1eb07b53ac6f76e73027548633bff"
SRC_URI[sha256sum] = "45fdf545e7e9d5402a30a2ce6bae9ee6a7a1d0b58b31c56517680cfce01c0f24"
