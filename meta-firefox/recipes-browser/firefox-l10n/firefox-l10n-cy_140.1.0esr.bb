# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "58455cb187247f8485f42f6bbc219db5"
SRC_URI[sha256sum] = "aab78c64b2fe0e22a1112939f09b123d29367916db1f68461c52ec433ffffbe8"
