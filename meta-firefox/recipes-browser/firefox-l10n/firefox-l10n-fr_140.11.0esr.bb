# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "77edde51f98113db5cd6d62b9052d58ff9458878322c8631e4a54d646fe96b82"
