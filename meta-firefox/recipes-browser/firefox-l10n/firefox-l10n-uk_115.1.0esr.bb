# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0be48d39a6503a696ee829edafac8c7a"
SRC_URI[sha256sum] = "c97ce30768b4384fd7403cb5d278f328968e7cf3459a60af37a2ac29bf980b20"
