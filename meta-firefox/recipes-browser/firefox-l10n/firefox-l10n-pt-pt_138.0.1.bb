# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f2bc4b0cee72550642ad18aaae9c7c08"
SRC_URI[sha256sum] = "dffc11e4b7c7c7929f07dacafd30fd37de65662521c06e3a6572fc6d96358120"
