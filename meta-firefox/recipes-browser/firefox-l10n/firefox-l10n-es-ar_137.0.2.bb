# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "716843892fe0325606e861c06b4abff1"
SRC_URI[sha256sum] = "aadab205eeec5473b9d6cefed30c7fe935f7fc655ba8c36645ab5a4ceea301e2"
