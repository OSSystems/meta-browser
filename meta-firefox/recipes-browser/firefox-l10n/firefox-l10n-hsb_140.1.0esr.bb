# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d322c159d609bd261d9f7a16dc34af90"
SRC_URI[sha256sum] = "23f208d90541d49cfc09fd08a364f58383494f62e7ed5133aea49b9294551400"
