# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7fe13b9ebf7c215f7aeb42b21f93d7923ba62338cca48c1a42dc75d917fd8d22"
