# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a6126c36c62d313e7ec834ce076323e8"
SRC_URI[sha256sum] = "5ddbe7ba9a4e8e5d112fe0fc0c325512d49331d938e8fcd7614d53c6adf7a703"
