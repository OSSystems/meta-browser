# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "bb7a7661a96c3546ba599e5eb6fb765f19d72d576e007aaa406fa085529c13e4"
