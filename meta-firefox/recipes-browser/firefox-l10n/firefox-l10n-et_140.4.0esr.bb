# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d90d5a3fff3c3daefcdc39241be87fe2"
SRC_URI[sha256sum] = "0efee2ad6dd43a9888cf73dd7903187222fa27e745482f6e8c9032a252b2efb4"
