# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d62a4e7e87ebc2a4122fe00c56203d06"
SRC_URI[sha256sum] = "28f0d0af6692b72730d96ebbf14c0d640de6f799cb76ea9197facbb78b509b54"
