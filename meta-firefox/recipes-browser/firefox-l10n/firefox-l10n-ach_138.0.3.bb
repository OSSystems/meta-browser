# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9d7b6810afdcf96800f1e2dff4932aa6"
SRC_URI[sha256sum] = "d4226233b2bc7e9929d61f0cc9050e2423d69c0033d839b51650aca8d1aa0fc9"
