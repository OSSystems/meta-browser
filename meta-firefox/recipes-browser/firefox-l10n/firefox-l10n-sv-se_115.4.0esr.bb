# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b764375a76ae3781ff34d6931f87c636"
SRC_URI[sha256sum] = "31b94428b9550f453023e4373ff7c2aae9d5b117caeca06b7f02fd3aa0ee1605"
