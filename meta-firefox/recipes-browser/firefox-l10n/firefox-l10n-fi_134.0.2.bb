# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f4b7e79862e894b128595012214b3225"
SRC_URI[sha256sum] = "216f921b746debe5cdc2024b4be6ccbb5f2a905901a1187b84fc00ebd05acf29"
