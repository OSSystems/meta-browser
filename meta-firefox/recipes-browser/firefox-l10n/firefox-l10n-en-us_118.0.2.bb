# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "174809e9f56ae8a2e8526e806fa6e9ed"
SRC_URI[sha256sum] = "f9e772019f64d96b8a51c9473a77348d34e2f6210442bdad1d0fb3d7cb58a98c"
