# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "961e2c9c0365bf1ccf62093e4a4bf9db"
SRC_URI[sha256sum] = "535add1dc347ff627a15ad834cbcb0a45f19140aafc3d84c37975e887b1ed797"
