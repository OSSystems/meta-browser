# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "47658240851f2873a3aab0e7f8d65b33"
SRC_URI[sha256sum] = "4c5b12979eccf24ef0a8ca5d8bc22abdb6b43467887412162341b70dca429e60"
