# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "48f32b19f9e955088c81899fecfd0d91"
SRC_URI[sha256sum] = "2cf4afff607c92c77383574f2677164912a5ff1df737fcccef4b42eb179e41d4"
