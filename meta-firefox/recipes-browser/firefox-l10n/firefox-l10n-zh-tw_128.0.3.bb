# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "da99d19f72277d0f2c95377ea513504f"
SRC_URI[sha256sum] = "1e3ef0c79a70b42e07c3b7ed6e7430e781aa377134a9aeeb6582ddf151b1f93e"
