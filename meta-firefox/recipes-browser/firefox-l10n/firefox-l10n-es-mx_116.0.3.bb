# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "438d7a3518eb84784feed1278fd82592"
SRC_URI[sha256sum] = "e376d4268c15b94fc4b249028e7413810c38faca59a010ce7ab2266003132de1"
