# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aed467b93f35668336f63322fc580a56"
SRC_URI[sha256sum] = "56895041a690c294a2de7cae68bfc17ce9247b7c671a6f90c1751aa43c82ae80"
