# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f0a3ab2baae9f9d26c11cbd7bc321e62"
SRC_URI[sha256sum] = "fd909b0e4b6eb19a45d73f2a1ae26f6d752a12f32d0542c48ab225d68f47ca22"
