# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e477c65ffb9cf05afda86c5d3b44b716"
SRC_URI[sha256sum] = "cd1f1e1b8c6ca1515e89efaab3fecc346afc33e578d74e4fcd7dd46ba718bb0e"
