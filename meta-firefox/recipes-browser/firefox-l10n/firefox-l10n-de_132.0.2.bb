# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "feb1607e2f51d6c84f6861eb891385d5"
SRC_URI[sha256sum] = "92a3f3ff579b12b8a0bc08adc2371178e181c096803490b6a38007183136e098"
