# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5d37ea170d50081470e454a6b40ca1fa"
SRC_URI[sha256sum] = "cd3090bc31f259ff0f803c725c712d0e02e91ea46411a3540bf5d4d83d74a9a0"
