# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "617b19270468439a7c938219269c61c244a14bd184e70d6036a0d52ad4d5bb5b"
