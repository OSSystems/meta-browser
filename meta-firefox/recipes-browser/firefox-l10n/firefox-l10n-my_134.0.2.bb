# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cafcc6f0a6466cac2028946b2f59ed16"
SRC_URI[sha256sum] = "1571ea2e5bc2dcc53f0349b3df9dd9f9a8dc92aec01fc45c39d700a13cf9e99b"
