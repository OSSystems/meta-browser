# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ad4f0674273162302e4e4333c41b5e299fa3d23d1381a0e0748981619a5fbf8e"
