# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "51137a8a37d3db4ee40d4bb64725f457"
SRC_URI[sha256sum] = "36008945e34b8f2029f3ec9d63f95d38132d44a1f6cea2015f5daa86aac0e13b"
