# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3ffa81766e943e3d8167fa40405b9807"
SRC_URI[sha256sum] = "c95e9a6ddee66ff96054319e45dfd2c030dbb4201aee30b9816b31bd10aca1c8"
