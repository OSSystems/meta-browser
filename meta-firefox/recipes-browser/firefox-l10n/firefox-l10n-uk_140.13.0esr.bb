# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7e11e01309640acc8aca9b561b76684813b5efd158a0e2bdedc83b4ebe4fe1da"
