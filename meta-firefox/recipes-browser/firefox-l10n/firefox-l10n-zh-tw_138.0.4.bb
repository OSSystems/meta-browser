# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ed890028d7d02a2f22adf5ca1d96e3ae"
SRC_URI[sha256sum] = "10f564b99c87f6e05a6e4f73cfecae69d68417bd332a1605aacc4d3f4934fe50"
