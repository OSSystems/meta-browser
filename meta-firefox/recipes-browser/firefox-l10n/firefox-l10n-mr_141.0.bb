# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4cca95f827ba06559f0e19356c5d3707"
SRC_URI[sha256sum] = "71b244274bac2e5b43ba252b0553180cf99515e27837f81e2ce2534d8b5aa8da"
