# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d852a01a5b073afe681200aa4cd200c4"
SRC_URI[sha256sum] = "1d171027abf86af34c0fee2766a1be71c6f775522246377d751fb7a8dd2a649b"
