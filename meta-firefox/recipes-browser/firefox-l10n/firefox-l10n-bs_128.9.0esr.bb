# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3346e6f07f45dda088b30914a040e2fd"
SRC_URI[sha256sum] = "b477289ca3221840f883a197d99a3a1d3b678b7a50e6ab3767d86d49a9b04d8a"
