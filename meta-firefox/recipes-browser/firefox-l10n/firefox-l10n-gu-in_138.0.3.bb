# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "48f71a411c08bb34dd60270a2342a66d"
SRC_URI[sha256sum] = "24eb8a0ca42796d93382b0eeeec8539e46736fcebf1c03b075252b838248bea3"
