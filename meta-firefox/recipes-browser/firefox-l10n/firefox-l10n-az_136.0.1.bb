# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "10b885743358c9def9099f073c22785f"
SRC_URI[sha256sum] = "6fdc997107b49ba75ae370fcad6372b0de1888a50f78b4c684566577acf68656"
