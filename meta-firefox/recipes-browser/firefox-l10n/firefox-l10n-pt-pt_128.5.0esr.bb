# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "51df3d42414a8335d2cd047a9d590735"
SRC_URI[sha256sum] = "d7d98e1fb4c680d3aec6f7a3e002ee9c8c5e49c5dc780a2dbe261db33f352893"
