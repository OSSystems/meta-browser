# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5a178dc6443d91fe239d4d3886a2eb39"
SRC_URI[sha256sum] = "dd7ab9f764c34b4426db2eafff06856e720ad0ac5ec821c3ac23926572a97b7a"
