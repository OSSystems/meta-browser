# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "36c24f78993f4948c1ba221b573d021a"
SRC_URI[sha256sum] = "9b373a8a7b9f2f701494720c28292e8cf16d40344db4b5dd7709b5bc142c3b79"
