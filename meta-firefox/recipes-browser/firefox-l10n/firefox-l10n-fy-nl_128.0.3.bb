# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "652c66d85e0eb1eb109bb4b23e01299d"
SRC_URI[sha256sum] = "21e47f19ca7c609224893bff01d8c88a80825ccefa945c6cf0d683b692fe9101"
