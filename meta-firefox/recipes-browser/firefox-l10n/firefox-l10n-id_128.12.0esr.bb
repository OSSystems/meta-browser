# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5e61763d602063d76f00e9bd9c3902ea"
SRC_URI[sha256sum] = "870d6a33ad8e6f2278fd28aca7065b1be2b553d257e402c8cb77efde8a1700d7"
