# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ade6da6ca7d8166abc85af10a2b24dc8"
SRC_URI[sha256sum] = "d11bb32866ea744e6a2a44e56b326d702d84d3eaa43fad598a8688fd936b2939"
