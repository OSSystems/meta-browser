# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aa15f54a486c1671b6fb2cd97d304629"
SRC_URI[sha256sum] = "7b4169938aa6bfc849a3de8ab367bfcce46b4557a0ca91e06158867fcdb28e7a"
