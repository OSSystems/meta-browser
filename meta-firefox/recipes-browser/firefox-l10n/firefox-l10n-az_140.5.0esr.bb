# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "32ba53da6f20bf69f4d23f5d0ba6922a"
SRC_URI[sha256sum] = "480be1930654abdcfc26b5e9b088d9bd2d2c0913d7df51094ba7ca4b5f281731"
