# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b687fd9084f3eb64a089fde5c93eb495"
SRC_URI[sha256sum] = "39d448c44ffd92fdabe3f115a3af44ae28d7180cbbf840cb6b58104585307012"
