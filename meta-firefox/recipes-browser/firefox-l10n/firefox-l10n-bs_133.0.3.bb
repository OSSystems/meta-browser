# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "223d158639e55c94564f3911502dc0fc"
SRC_URI[sha256sum] = "38ead173869b2919b7bae4450a66b6776ab1fa177a5e6754538c18c6f09c3007"
