# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "69b265264a307bbdc2bcdecffe3a5144"
SRC_URI[sha256sum] = "ef5dde6261d5ff492f140beb933c8a3457cb0c1c91d8b50ea4bab7b94b01594d"
