# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7b82815ef1aad7deecbbb2b4f38ba884"
SRC_URI[sha256sum] = "12967dd755ee16f04e719b129071a781afcc673bac637684dd05d0a2b1897e89"
