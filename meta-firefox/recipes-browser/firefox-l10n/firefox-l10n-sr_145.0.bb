# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "96737925561d0c5172b147343db0d0a0"
SRC_URI[sha256sum] = "90940dc4888f719fedd3cabac3f4cddec1b97172672952b4f9fbb4aa51c60aa8"
