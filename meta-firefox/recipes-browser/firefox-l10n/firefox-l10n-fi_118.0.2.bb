# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "812298f09f5de1f865b9b9970dd399b2"
SRC_URI[sha256sum] = "12ad852c5905da2abbfb45dcd121c691c01e92e1339b3635f45b128adabc00b2"
