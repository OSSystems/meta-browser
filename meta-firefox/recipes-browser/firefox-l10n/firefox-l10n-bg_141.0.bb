# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "251e214069ee654231b61248a0caef23"
SRC_URI[sha256sum] = "b565b156762918091e6da93f6debd71f1895d1615a91afb0b8b937493402a3fc"
