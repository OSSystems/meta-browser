# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "34caf0f3446d4029f20b5be9b48256aa"
SRC_URI[sha256sum] = "a157e0ecd2c14034279f264dbdb382bbd02466f1c29bff260f16f8da95af651a"
