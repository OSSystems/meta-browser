# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4a805f0e4f1a18d7224636e3f61a5a81"
SRC_URI[sha256sum] = "fdc3c89fb9996b2fa8016a3cafdae0e8f7a67a937ea402e0b0278765d3b5b57c"
