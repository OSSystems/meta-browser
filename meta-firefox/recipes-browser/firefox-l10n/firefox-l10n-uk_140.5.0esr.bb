# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e2d130c11e970281c4a2937ac0367fa8"
SRC_URI[sha256sum] = "53178c9c124253b902d39eb9ae01fffd4cded830240697d9b8339551696a0814"
