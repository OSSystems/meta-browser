# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "767e897985b5556865ed5ebbadf30679"
SRC_URI[sha256sum] = "36048c62d8dbf7ed8f7ab26d11a6ee5db4d0209058ff9a0242241c1200300db4"
