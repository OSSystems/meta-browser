# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "012fdc20e3e19bf11ea4635bff874886"
SRC_URI[sha256sum] = "70b02163f582e0e3659f75331cd8a37480bb99a1a1b04dde2cd8a5c915a03dd4"
