# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "382fefd5f403e1e851ea784c4c9d5a0a"
SRC_URI[sha256sum] = "b7a0c9d6ef1691883b331f3571dad030f925a1b4e8c659f29ea4931062d47e48"
