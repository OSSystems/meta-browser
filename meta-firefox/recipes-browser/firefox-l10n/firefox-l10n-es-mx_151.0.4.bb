# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "648df95c41625c24ab400624059201aa79880b26737c96a564aaa0ca31e4a9ab"
