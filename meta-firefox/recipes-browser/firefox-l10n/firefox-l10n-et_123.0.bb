# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "39c765a1ed88955b355a25c82ca5845e"
SRC_URI[sha256sum] = "432d5e2bb16c1836cb3772fe5091940a2d9da2da80d9a4ad7a2109ad8982e97f"
