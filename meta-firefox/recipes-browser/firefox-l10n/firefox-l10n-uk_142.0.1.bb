# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e9e842a61445e21bfbaa2e2c97413270"
SRC_URI[sha256sum] = "9572bedba2bf3b532bf30f6359d1361182ce138dbb2fbeea40397384ac8a4306"
