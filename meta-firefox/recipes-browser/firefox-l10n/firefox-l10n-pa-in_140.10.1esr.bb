# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "64006a32fade5bebb936f3841eca70aedf346237e4bc9d8940e28ba6e8d2914a"
