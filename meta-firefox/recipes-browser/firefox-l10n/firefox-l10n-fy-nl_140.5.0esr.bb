# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "177bb2b9705499c9e83b3e3e0a54b628"
SRC_URI[sha256sum] = "f8966edad633d969fdf7ac6ca5fd4ea22dcda1c07a8ed6a53a9901ea7ca738d3"
