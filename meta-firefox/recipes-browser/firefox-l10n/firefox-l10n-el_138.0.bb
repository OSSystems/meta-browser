# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "235209fc2a4837fc0ad5968e0d2f241d"
SRC_URI[sha256sum] = "74d468b19d8a690a2dff9b628b557601dfe0118e05215b61178462d2c2ea617d"
