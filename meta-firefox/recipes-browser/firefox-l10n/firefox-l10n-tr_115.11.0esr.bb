# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "545db009d2bf1ef686ac520ff4b2d4d9"
SRC_URI[sha256sum] = "b5ab9ccfc52c3da3f2c2d2ebafb041d7f71ec71992785269b22ecc237e6adc72"
