# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ec911032e09b5be0f8f021617f8a5d3b"
SRC_URI[sha256sum] = "5b51ad6a3854c3fd3cfb9e23ec855ef8c58078e88393be56fb09e69a98147c45"
