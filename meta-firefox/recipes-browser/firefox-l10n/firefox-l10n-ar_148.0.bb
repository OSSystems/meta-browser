# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "83f2567dded6652f62de0534ae6860a5"
SRC_URI[sha256sum] = "6b6150cfc65e900903cbdfb92890db42ec9c331da686fc4592158aca3bf48cfe"
