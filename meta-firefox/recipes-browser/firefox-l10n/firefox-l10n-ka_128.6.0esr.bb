# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "772cb6832b1b56237ca83ab3d5a80694"
SRC_URI[sha256sum] = "fc4875918ed68aa07378d7b9d9a2ec558ba2b96ce2929b780810e87416d7483e"
