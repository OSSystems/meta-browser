# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3dc2f37df768e264a2e8ef233a30f1b5dc0d5a346851b5c6aa7b1f4481c08fb7"
