# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "35a708bae11b5def3494b7e5c75ce6de"
SRC_URI[sha256sum] = "b1f34ac3b8c253f7b842a374480212a8ef5663be53a4ab580b11be9f5d840b3f"
