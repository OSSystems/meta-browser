# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "505ce85b82df2fd8f8b93aed93072d0f"
SRC_URI[sha256sum] = "3dc05f4d18a992c6fdf9a46c320da856c7a00d8f49ebf35d848a9099c8e3f392"
