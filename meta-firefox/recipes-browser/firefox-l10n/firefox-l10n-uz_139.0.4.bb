# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5707062360f6ddeaa73e68a45fda2e35"
SRC_URI[sha256sum] = "f0eeeed790ca1275c716c896fdd9f0ba56f01c4fc5d46e63193ada54567d2c3f"
