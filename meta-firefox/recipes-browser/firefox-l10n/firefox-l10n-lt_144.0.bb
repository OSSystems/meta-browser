# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "53afb0b82016ce10bfd236ea12ef1e3c"
SRC_URI[sha256sum] = "78ed79ce47d17ade63f4279dc10e31a4f4b805317a270b9e475a45b1208a9d4f"
