# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "8c59f33bd97dced962df1926038043ca204a8baf2494c614b6a05c4a7bbaa9f4"
