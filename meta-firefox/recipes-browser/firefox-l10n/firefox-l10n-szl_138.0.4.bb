# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bd02a9c3adb6ab5ba5b1d2a49d130333"
SRC_URI[sha256sum] = "dbfa26807d1b3ad68e158e9a5ec5db16461801702b3d88b763cba4cd3b99ab62"
