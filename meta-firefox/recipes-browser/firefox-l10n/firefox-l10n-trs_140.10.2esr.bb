# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "126ee626500f42cfcb66b70804bec1ed7a22666373e0b7fb54f151bba363ed57"
