# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5513efb77ece437f3ee3d6140baca7db"
SRC_URI[sha256sum] = "5d3619b651ae799b170b65b85044781fed7a5c68924dc56ef3a226d652cae7d8"
