# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fbd86dcb0d84c0356e602f6a3d949387"
SRC_URI[sha256sum] = "65b46600487fa3dc832e73a685c645a1c2fb26c5f55b22f50e0a3e112680665b"
