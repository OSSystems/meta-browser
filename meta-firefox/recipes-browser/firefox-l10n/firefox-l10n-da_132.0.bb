# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "03bf4b4a5305def3876b9fb41268f3b6"
SRC_URI[sha256sum] = "394b837a3fec05cedd13be23091a1d125d4fc5e33fe50173975dae7720007f97"
