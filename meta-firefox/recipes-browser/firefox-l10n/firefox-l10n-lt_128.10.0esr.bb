# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6644f41bb53ef1d9f65283c61d3f875e"
SRC_URI[sha256sum] = "59ca8b412ed004f135ee1a196b12685d48481aba108365940fbb8e8b5b2b5cd0"
