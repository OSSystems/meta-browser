# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "0df96fc31365ddeaf1873864993b4e20eb6f4e3a21f0a8fff7734461a656a009"
