# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "48c2482206d92f98ad9ba4d393bc2717"
SRC_URI[sha256sum] = "f2cbc39a57e081c0df224ee28850fcdaed767801a3b119fdd4efbf1657e7eb8a"
