# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "91829fbae950bd1d26168ecee0ce576bf07ce5b5551834d7fbd887fb13addf19"
