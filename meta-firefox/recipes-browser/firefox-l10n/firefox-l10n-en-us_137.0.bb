# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6231ee3dd88a5e91bc0c88570be96fa1"
SRC_URI[sha256sum] = "a99940ea10ca6648788c346462fe958e64e31388bcdefccd1d520610ef62722d"
