# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "26da4c0dc527cbb1b0fb06710a96062c"
SRC_URI[sha256sum] = "ca6422f70e724ad4c399e251bd340608670fd75c14856f055e206c41b702d8b7"
