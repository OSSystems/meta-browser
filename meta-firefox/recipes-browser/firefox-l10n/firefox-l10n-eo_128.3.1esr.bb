# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a5fa0bb0d97a9f12715331ca4f9d4df1"
SRC_URI[sha256sum] = "1c3ad14d69449616aed9402e7335684aef353d6268063b2415a6ff847045fd0e"
