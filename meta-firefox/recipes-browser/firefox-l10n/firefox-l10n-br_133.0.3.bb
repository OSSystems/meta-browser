# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dfd9292792e544c9550a582ec6e3a803"
SRC_URI[sha256sum] = "2454de07359e2a4575587723f47829605f69e4d1c80760cde8fc0a0069dc9e45"
