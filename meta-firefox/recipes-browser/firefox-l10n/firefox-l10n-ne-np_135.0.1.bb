# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "109c59977b15d9b6b27c98dbf97b0ce5"
SRC_URI[sha256sum] = "2a57da6b165dea7f849adc47b5c8760c484f2bfb3580471ac567e17d87f0494e"
