# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "38a7b3928450f21282fe5714d6d19144"
SRC_URI[sha256sum] = "029c3abdea4cfa9c0f30102931cf0f56c15565d3cd3c6edcbbbbcda6cfc12f67"
