# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0cf0828c2ac5e5c22cc80f2a01dc7788"
SRC_URI[sha256sum] = "c1b2d1fcb71752fd327e4488120a802478e6c9a7dd31f8dab86c02123cc69462"
