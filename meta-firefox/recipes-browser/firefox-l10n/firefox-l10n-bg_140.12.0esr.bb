# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "9a4151e715dcd854411e18ce0ddab89ef4e79d7fa782afe382828fa5fb964b1e"
