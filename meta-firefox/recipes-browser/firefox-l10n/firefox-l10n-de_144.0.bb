# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "22072e398a776b92437c54ba48b1c048"
SRC_URI[sha256sum] = "219a399478cd360c8753b8e8ec1636da7b3886afb24c19272559b21ce175e7ca"
