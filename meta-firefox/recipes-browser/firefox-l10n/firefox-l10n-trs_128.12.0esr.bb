# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c0c5e823b758863fbc2040ce75c1d3d"
SRC_URI[sha256sum] = "3e8da52732333b1b7742b49cff0efd72b9583d52397822cff8b5db2a5eee8aba"
