# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bdc1e5e43b65ba348ab333782ddf9732"
SRC_URI[sha256sum] = "1d094b7c1fa88be92494cf2563ff6c7241c0d16d59b28c2dbaee7ac920568c34"
