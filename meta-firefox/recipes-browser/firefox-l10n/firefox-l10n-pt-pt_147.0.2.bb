# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cf4a24f6fcea45ea72d531b345af7bbc"
SRC_URI[sha256sum] = "779173e4d9a7a8148529637c9bfc5299035ed51a0ef6284b303963a40f6cf4db"
