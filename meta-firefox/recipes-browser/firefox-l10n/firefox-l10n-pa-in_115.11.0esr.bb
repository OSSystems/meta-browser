# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5515463b97dcad634fa249f4ea903c51"
SRC_URI[sha256sum] = "342967ad0bf3b93a9e6aa27ecbc47a3dbc2d8ddf0effab0bcdc41827f56e9be6"
