# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5ef05361528b8d2ab04fec3533200099"
SRC_URI[sha256sum] = "8463b97513b4583724a1b740bf1aeabf0c439638e9c21acc31cf38fc72d79b36"
