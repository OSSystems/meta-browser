# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "51d2585ba03664cde2dd6ffc919f9253"
SRC_URI[sha256sum] = "5f1642b2d456a3b7eec15308bff44e551daf93e090e30017a4d7bed31c12aeb6"
