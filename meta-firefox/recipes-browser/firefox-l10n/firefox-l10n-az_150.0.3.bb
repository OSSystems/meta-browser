# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e694e8a33fecc7e928bd9eda135bccea55b7f8bd081a26f09b22d031f82f6441"
