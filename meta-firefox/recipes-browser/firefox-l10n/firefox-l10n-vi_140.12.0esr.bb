# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "b7fb4a072531495901f6117e5c0684aeafc7daaaf65232a7cdea65748b3e3c33"
