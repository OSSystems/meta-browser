# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bf2bf6811246e5e9b4fb14a1c4275777"
SRC_URI[sha256sum] = "2c0e4e6ea04e3074d3164ad52a408e65b17a957e5f353c81e4c8fb8ef97c2617"
