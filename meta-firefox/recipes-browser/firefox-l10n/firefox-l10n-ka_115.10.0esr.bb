# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5f91e04f71b7bd8366f82231b9777428"
SRC_URI[sha256sum] = "cb345b93f4266c32f49925b75f420052f1bb53749b45ced140410339864a892c"
