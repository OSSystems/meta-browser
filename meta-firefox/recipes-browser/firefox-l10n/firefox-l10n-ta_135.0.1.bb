# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cb86c3a4c1885e5dded3517fa5687f32"
SRC_URI[sha256sum] = "e39e9128f13f868518b60617b43d800ddce586036379b2e834407a87ffa94eae"
