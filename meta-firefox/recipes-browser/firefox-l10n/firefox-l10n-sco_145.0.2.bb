# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "70d974b82a0bae2c7a71938a217ac7d0"
SRC_URI[sha256sum] = "0fb8feabce49d214c1fdb0aca80ce09cf7d9f02a8cf4d9528d9fed7d39f0b4c3"
