# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e4106a2742023b04f98225887e0a9de1"
SRC_URI[sha256sum] = "595871d78cba2cb44d23b54bf610061e27a6adf528410d8309793e7086b6efb2"
