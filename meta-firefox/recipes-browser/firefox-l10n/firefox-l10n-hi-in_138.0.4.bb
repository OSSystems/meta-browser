# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "41b90d942a12eaf3f033c58999cf74d8"
SRC_URI[sha256sum] = "024336f8395fab4bf7e2940f1a9c71ea84c6f3209f0c6040524fb6f72799f1cb"
