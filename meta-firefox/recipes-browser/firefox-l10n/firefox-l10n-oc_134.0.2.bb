# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "74be1e295b96df07126f01cdee911b1d"
SRC_URI[sha256sum] = "7be28496ce5a67da0a42587d0f6186123a7fe5eda07e1645792ea12b02a99e91"
