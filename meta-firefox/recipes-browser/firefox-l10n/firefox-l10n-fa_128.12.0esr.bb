# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3e9676642a3fa38fa49acb3923f4949a"
SRC_URI[sha256sum] = "d6be9314cf75c98e4da1c3e7b8e046680c49eb8870e090f315455a2632145aeb"
