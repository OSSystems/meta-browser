# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "4120a3895ee2c20cea514968418cf90b1a5d6233c2f873b6cc2718c24adc8aea"
