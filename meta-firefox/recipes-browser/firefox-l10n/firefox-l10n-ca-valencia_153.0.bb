# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "906d9040de2d6f7e77e9a4f911de6e4d9d5b8730818a20ca1444379e66d5266a"
