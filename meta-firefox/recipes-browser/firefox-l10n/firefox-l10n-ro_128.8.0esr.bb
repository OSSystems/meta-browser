# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0aafbdad1424ef0c94351f8f364b56ed"
SRC_URI[sha256sum] = "6f71b0c067c290b9e2c5d82672583f238c485f866094a1f5f04714f091aeef3f"
