# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fa1691781718a1b9af8faa67b5297728"
SRC_URI[sha256sum] = "b6b5c7b1643cf0b6d1528daa49cc16fe77d146226b8c1c3d81a0ee6fa868edef"
