# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a6d9a14475197accde46caae7bc340b7"
SRC_URI[sha256sum] = "8d725034fd9ef0355b5d2ce1273ac8db7cf8138e471ff9b8464b20d53d4bcbad"
