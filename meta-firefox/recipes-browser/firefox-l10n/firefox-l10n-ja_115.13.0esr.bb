# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3e6f278fccc7b648dcf0f845be3a0403"
SRC_URI[sha256sum] = "7f62560689afc1af705bbf5279112ee3ea8231bd67cc244949f8b4041365893a"
