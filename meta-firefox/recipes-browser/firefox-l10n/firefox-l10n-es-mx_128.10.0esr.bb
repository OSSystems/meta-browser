# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e321f3ca32a0b94f59b3d03de593cdda"
SRC_URI[sha256sum] = "28213084f79c638e4ac5b57faf06e98901ba3f7831cf47ca710b582fb43720f7"
