# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c3ad6badac6c1ec63976f25e281b5c0a"
SRC_URI[sha256sum] = "031827e8ca48d236ba6768a5b2e9a5ca9b8271c39b1439ed40765e58d8c83d72"
