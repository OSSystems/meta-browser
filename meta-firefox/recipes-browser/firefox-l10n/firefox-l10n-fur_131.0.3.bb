# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a7dbf1c1179cb1ab5441105baa95e51f"
SRC_URI[sha256sum] = "638f35d681d8003b5b62461a8c6dd481c64e696b52d16f4be81eb3a2bd5bc6e2"
