# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ab0ddfd324409255976aa8ef9e5abe37"
SRC_URI[sha256sum] = "be115c52d33c0f6d57a8b2441fa2139b5c56431760e4450f7957253079fb0db1"
