# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "de760f3dc8649a05be3be00b7a99f8ae"
SRC_URI[sha256sum] = "a90d0c2dbd48b1e46886bc9289c75aceadbce925d76c1a31e5b8ad57eb83986d"
