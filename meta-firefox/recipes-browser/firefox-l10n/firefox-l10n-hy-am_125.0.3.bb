# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "53668f17b8cfe034c80bd9712be78eca"
SRC_URI[sha256sum] = "6234616c6f251df8eeaf08ee4ca6bbcfe886cce31f0dd574db0d094eea7df934"
