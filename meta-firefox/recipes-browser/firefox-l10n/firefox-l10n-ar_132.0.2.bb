# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fa1e5bfe71009c6fc72c3de0bcfa6bb9"
SRC_URI[sha256sum] = "6c33f37b1b681d95255f22cee5b6639762701ed8508e1d5a8c5a67b788acabdd"
