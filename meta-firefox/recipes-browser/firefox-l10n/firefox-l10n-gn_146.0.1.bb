# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "16bce72a25724d09006fd09649e427cc"
SRC_URI[sha256sum] = "449b62b5c8e3b0819fcf07ba08a930a9439de5d655cc074817b8a2dadbc12fa2"
