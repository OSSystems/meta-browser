# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3f50c9c298d7fa51067256773e2f8a85"
SRC_URI[sha256sum] = "5a16d0362216303a224a179c90bd9a63704c0de16c0bf63562fca96918d5fd55"
