# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9042464da04223767346f1c7d4d80191"
SRC_URI[sha256sum] = "25f51e03e237246378c3ea014a91deb63a2819fe57d3974176f28c48be58b499"
