# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a5c9b35c823089bdf03716e4b15c61ee"
SRC_URI[sha256sum] = "181e3b11576c9ff3c98c70f4a8016ad3bed6ccb23b9953ff3044f5d9b477a98e"
