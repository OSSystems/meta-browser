# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "fa287d4fb51a3336ea0b5e1a5136a19c29d079650f6043618139ff4e23e01278"
