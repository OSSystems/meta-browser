# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7d9710bb571e24e1c7eef67679a95eb3"
SRC_URI[sha256sum] = "f28aeecf57572cfe014c5264483f183897c0576b5d78ff8c97ca0534ce20f700"
