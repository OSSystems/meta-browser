# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "739634c4ad77f1b2cad571840f0b2ebf"
SRC_URI[sha256sum] = "52344e05c1021eb3d94dd1ba0d3db6d10030ab6f50d874420c7adc86650e0c32"
