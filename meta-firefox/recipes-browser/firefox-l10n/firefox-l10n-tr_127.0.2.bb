# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0d14632f4c895d2cee6c93a6446121d1"
SRC_URI[sha256sum] = "e7bca9c404a759daa818eccfb478346c30f3b3432e2e28001d5e29d09541599f"
