# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "af13ad1a7fba2f42ae6a11153cda558b"
SRC_URI[sha256sum] = "6ffdf0332aa91618de94adc4f756a0a814422957212b5514068ccf12c3742beb"
