# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fc8cf25d8a0b6604209159f7ac820cb6"
SRC_URI[sha256sum] = "66978ce89656256bece53f89e794ca2f856ff4036c68a19d455653dc1fb205d5"
