# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "be327b38eb8cea1f177e3f72d6b42055"
SRC_URI[sha256sum] = "2d783a55ce108ae6f1e8e42bbad05ad9b534dfb85871b2ae6f2cf69a052c2be0"
