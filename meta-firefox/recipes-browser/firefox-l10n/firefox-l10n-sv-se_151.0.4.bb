# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d5d30dc85d5221891e7a9b5ae8331c30df1dc663f72061bf8f504d7acb758099"
