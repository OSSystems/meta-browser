# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6b98be52fd15e779514120912c71f776"
SRC_URI[sha256sum] = "1bff8d613af78186d38a22eb30807d4b320d2949cb2c45dad64a5dd660b2e8f7"
