# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "554461bfcea418cb105554d7af8ae857"
SRC_URI[sha256sum] = "d1a6d138e788e885cc6c810aa52823e1d1673126d0bbf21c94472502cb8c7cc2"
