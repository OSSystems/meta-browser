# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7935d446db6494899f63138d75dc4203"
SRC_URI[sha256sum] = "3ee82ca1d99a7029857797a441aaca88967c63fb323215af4f37a4b204c6e208"
