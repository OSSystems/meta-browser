# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "eaa3cdc5658aa7323e50bd65629206fc9000c393eb119df2d6de7d67ec30f833"
