# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d7f1ab50adc5f1795bb11a41546cca94"
SRC_URI[sha256sum] = "5454999dd3e46c341678f4a3245b7d608d12b775139dd40f353c69fd5ad0047a"
