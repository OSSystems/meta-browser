# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b76a2527689d799ae57094deaf1c6f1c"
SRC_URI[sha256sum] = "310922164e9a98d2235aa71c7b1ecba6183e39dd27f8b2c3664d4990021edf75"
