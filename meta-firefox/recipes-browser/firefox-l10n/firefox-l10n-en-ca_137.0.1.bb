# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7934ee08433d20c5888f287694ec45e9"
SRC_URI[sha256sum] = "e5ca043311c8bae1461a933ba8e2766e32c597e4c324ee0b37a5681f8d4c6ff5"
