# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "147d44d530b7c3509e3c1148c4ff74fa"
SRC_URI[sha256sum] = "e9fdbc2877790f7d11fdd32540432a0ff2e6d6df0ff49df52807b7e99befddb2"
