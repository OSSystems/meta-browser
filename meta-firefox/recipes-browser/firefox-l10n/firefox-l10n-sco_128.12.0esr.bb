# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b726e550b5aa2e70a62fab837625a85c"
SRC_URI[sha256sum] = "efd83322ad01da22c2c4e3212aa7503c764e35639536d24a048e0c6c21cd6966"
