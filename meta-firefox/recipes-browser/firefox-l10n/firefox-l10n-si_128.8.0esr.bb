# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b1e50d2366b68b9282f410ad999f81d1"
SRC_URI[sha256sum] = "c7451c5a1379287a2efa04d48cf9979faeb97c0fe9571e95e8bb128664c81276"
