# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5c7c4e141c4afb151cc39b14ab2c6b30"
SRC_URI[sha256sum] = "46eff678727fa983302fc86a1b6c2ca04aceabfd3a7ef82ea8d247901a4db7e8"
