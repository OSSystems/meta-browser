# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0420fa5f7fc9b23241b5d67e613066ad"
SRC_URI[sha256sum] = "0203b4358fe3c08e3ef673674270a1488f8265dbe71611449b80eddf1ca0bd46"
