# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2fc993cacf1f3ae38c94a7744c65961b"
SRC_URI[sha256sum] = "d9cf0de6c679c13172aa487f42c60e299ae81b835313134d9f7d5f3cbd0816b1"
