# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7d4c43f5c02ab02e727c1e3de5fcd4d9"
SRC_URI[sha256sum] = "61105bd89bbe4dc5a2da9bb96fe2b2268dcf031d406ba4dc59abc1364899e597"
