# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "0957af17b1acefe974789ac5e69729ea6aa00305ccc8e0a6daaffd24c1c2cb2f"
