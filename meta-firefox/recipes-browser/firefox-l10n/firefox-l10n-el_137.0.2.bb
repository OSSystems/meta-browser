# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "40837120e21243e577673e5812c82225"
SRC_URI[sha256sum] = "c82e8a0679bb39adc036a8402a519bcecc59b9c3cae041613cfc3eeb6fcad2fe"
