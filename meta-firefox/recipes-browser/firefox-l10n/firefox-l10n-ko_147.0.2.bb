# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2fa0764c4ec7d4ebc4f9a754c022dd36"
SRC_URI[sha256sum] = "66403adfa3ac0335cb31d6b71ea83bb9b640dd7e4e0d1969cb920564fefc7cfc"
