# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7e6878714e8ccc84e8b903bf5a468c15"
SRC_URI[sha256sum] = "4cd66424560c21593598dcedd4eb678710e706be41e16ff53eb7497d7b7cf20b"
