# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4983d8f852ab38a83e383d0f2e0748e0"
SRC_URI[sha256sum] = "53e96181b623b1542d315e6c2bdf3cc694c4f6886435d138818efe29f6d21ffb"
