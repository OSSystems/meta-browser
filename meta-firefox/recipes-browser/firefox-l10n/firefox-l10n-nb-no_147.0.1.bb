# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "34c63174be2d4abfe60c6391ca720914"
SRC_URI[sha256sum] = "2b464632efe24045f16fead0cb67174be7a09a98cf310ee8a81a618d2404538b"
