# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a166fac0d4aca3e7e8e0d6910cf33fcb"
SRC_URI[sha256sum] = "759cc1be21fa5357078b6afffef1f402e159e88370d91eae3695a74fccebb347"
