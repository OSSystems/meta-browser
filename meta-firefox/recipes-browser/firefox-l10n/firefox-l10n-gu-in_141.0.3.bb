# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3eed6aa9da002c211f7f416ccbf0bc05"
SRC_URI[sha256sum] = "e8bb4d588d155e0da69481ff0aa9588d2fa579fdfa4658d64a9473ba2d363cd8"
