# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ab83423be117d5c1b0c4cab2a0cbe3c1f80e8cbfb3b8cb485af819562b5a27fe"
