# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "02626d1622fb7e31df2b7ff5b272d871"
SRC_URI[sha256sum] = "7f58dd60d48891f20b25ea4368cd10810a7e0855f725007dff553bfce67e39b5"
