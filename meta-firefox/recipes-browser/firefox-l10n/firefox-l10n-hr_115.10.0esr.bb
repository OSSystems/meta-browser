# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5878ca04ebdc8426bf75c72d7507b98a"
SRC_URI[sha256sum] = "9d085b78a05fb89f528aa8537fcbe9b926e25e0aa169a5fa5cf2369c8203e4aa"
