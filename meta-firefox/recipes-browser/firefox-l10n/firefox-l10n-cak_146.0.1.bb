# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a387c9d09c9fb07b7809694aea7a9238"
SRC_URI[sha256sum] = "6e1ebddfe4bd44131d438c2cf4d93deeafb5fb30eab731b6f48ad98d89cea54e"
