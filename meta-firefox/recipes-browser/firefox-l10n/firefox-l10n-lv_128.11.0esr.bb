# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c396614ad4f81fa13a09c4a05c1ac492"
SRC_URI[sha256sum] = "d1875d82eb98c7458ca4b7ddcd1c245d5303216a69ad62d3c75d1943e12c3680"
