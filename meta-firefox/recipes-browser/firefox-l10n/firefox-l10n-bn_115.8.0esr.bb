# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "858cded5f8da87100ec57fc1bca3c992"
SRC_URI[sha256sum] = "df1990e7eb9f9cafe584bf76333d28bc1be841dae40ee16f1392b330ef441291"
