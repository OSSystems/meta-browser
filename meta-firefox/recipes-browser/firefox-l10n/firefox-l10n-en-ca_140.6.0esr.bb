# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "07cc36c956bc0b867d77f67d7c937df3"
SRC_URI[sha256sum] = "694e9889793cdb2e6043698243113ed74602b50dc70c6c51b594c76f5d588106"
