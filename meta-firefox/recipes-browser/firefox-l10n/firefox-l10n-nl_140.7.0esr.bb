# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "39f39bc4ea18d233f01ac31e90fa8d13"
SRC_URI[sha256sum] = "204fd13d133bc5f2bc860b1858187a3cdb5606f939af39a9d3ce5b733561b5d3"
