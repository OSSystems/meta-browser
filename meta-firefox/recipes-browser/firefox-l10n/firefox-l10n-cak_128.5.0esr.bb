# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c24dd6c8f9cbf20d0c739bc7ac2143e"
SRC_URI[sha256sum] = "66829972eb53755f11ff4610c4722228b61bc2c1c78cc4fd23f2cf798decd2d3"
