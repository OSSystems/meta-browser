# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6e42e9757e8fe21bf491ccbe26d1e732"
SRC_URI[sha256sum] = "9154158d01de5587dbdf336869ce64fddf875d743d90c59fd52f73c47f19affa"
