# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4e8086d626c4c4490ab53748414f5cdb"
SRC_URI[sha256sum] = "703e8bfea8a70150b7bfcce39f6e9385c76884ccf3f3da0949e40e4da4e3f232"
