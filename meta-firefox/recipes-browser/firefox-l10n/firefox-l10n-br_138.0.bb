# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "92ea1fc9f36dcd204f96b360e7b4b4f7"
SRC_URI[sha256sum] = "698101391f45f8e7e0cc2665bd0c05fd8e1d50705a74505160d9701b6c7af215"
