# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7888a48615a294068213a3a32f6914cf"
SRC_URI[sha256sum] = "56b59790e83774ee7e36379cd22a0fc52e372e25d5d6e25a3169a6fe41650fb2"
