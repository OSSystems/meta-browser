# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4d845a38d1d47da6f23d53d4a257f009"
SRC_URI[sha256sum] = "b532fb627941c27da4c99b10f0087d1c93cc62f71e5501d5808996a4c956bb09"
