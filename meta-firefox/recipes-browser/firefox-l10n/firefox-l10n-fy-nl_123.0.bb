# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ceb30395ae075d97fb6ad9b9d980a6b9"
SRC_URI[sha256sum] = "8e1975b895019c8081c2835a746b42f8e49c114e0e59d80cac009e0c2dd8397c"
