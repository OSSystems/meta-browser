# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "928f0db693271d04680a4f0f666d77c6632709bb8ca04aedfcf7a765ea6e15e6"
