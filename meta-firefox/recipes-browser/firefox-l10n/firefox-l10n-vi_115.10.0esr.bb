# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "15f748b5dbe17a7d750d8e998e56d1bd"
SRC_URI[sha256sum] = "b9b8ba1b6c72012adaeb8e289d7bc105734740b2ae9f007f60d849db3461cfd6"
