# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2910c595927d144473f42efa8abc2c44"
SRC_URI[sha256sum] = "9cecef002540ab3d5f2eb891063a68baf4defdeb56f867c358df9357accc7057"
