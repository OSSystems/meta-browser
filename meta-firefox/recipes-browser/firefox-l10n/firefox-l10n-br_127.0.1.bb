# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f3af4235791c232b29d34c9e2ac71c18"
SRC_URI[sha256sum] = "06bb8e1ac2764048439ff8f3b815ee90df0badbcf30a0e6585a7a14dae1cfc5c"
