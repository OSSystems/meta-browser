# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2fc3425b24fb7731173c87e3556be989"
SRC_URI[sha256sum] = "7afdd66b90cb5f5b4adcfb2e2c5f0b8ea01c1b6e2637864033f538600d9c6ecf"
