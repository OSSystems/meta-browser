# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a9fe156de1b44f54d377720894baa114"
SRC_URI[sha256sum] = "34ea93cc48e4f11ca2d9235dfa1a699a7376b836ef9f0069f2916b4ff1a957c4"
