# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d243d583c84c3413bb612917e8d34212"
SRC_URI[sha256sum] = "bfcfd811c2b905a3a50681f4ce43bb3992fbafa4a6d5cb71c0a40e539a1aa850"
