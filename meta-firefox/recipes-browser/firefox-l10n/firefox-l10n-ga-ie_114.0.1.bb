# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1ad178db36a9ba921b569b60800293b3"
SRC_URI[sha256sum] = "40a6b5fa737d29f9ec464eb506d619292f7fdff434ca082c36a809e0d0ac454a"
