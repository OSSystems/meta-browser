# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e202ab8fee334718ee60721298c0089f"
SRC_URI[sha256sum] = "ccd7fcfc0463ad4e4da4a76674a1b8c98db0eec54ccbef679ecdd6e5d7cd7576"
