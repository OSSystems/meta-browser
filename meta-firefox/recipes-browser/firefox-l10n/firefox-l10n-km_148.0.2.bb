# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2d29c82865e5f96ac6a296edfa842918"
SRC_URI[sha256sum] = "b846e5c40c86c3db8b1ad6372f7426b6f180ae8e46c796014bf3569c52c21d3c"
