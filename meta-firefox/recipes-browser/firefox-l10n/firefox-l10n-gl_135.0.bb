# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "990d50f11d7cf2bf0f9a21e7470e8d88"
SRC_URI[sha256sum] = "3ed1770d00e5c581bd3aa13feaf83dd575cda47ab53bc5729dc55d6bb86b5523"
