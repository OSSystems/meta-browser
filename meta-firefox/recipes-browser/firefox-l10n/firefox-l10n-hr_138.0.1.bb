# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "de05fab962328b0dda61721d10cac438"
SRC_URI[sha256sum] = "7e6f676c3852a649c80cade8e14b318818e468b8a783aa29a1a5fcd6be76753f"
