# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ba21c97477ddab1a45dfb4b7935d44b0"
SRC_URI[sha256sum] = "5940b9da1338268199793dfa5486623b9a843dba95cada3edb56c8b9e184d8a6"
