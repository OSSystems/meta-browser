# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1209d2d72f4704838b0c23de6c42d4ec"
SRC_URI[sha256sum] = "e6c348ac4acff1cd10251fca2b087ecdee04f2eb2f5006a29babee490d7d4a61"
