# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "91b15cbe5d6332572ecbaf8271b1a7a4"
SRC_URI[sha256sum] = "249658da837c7d036150afbaa98efeeec8ecba92552d5986543c2d3f935acabc"
