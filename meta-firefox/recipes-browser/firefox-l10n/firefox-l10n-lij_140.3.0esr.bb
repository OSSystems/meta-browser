# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ed84fe88bb314cded6410f7e37e15232"
SRC_URI[sha256sum] = "297e39e7697057370d16d169655f8dc4e907d38b76d6abcd5976b96980682737"
