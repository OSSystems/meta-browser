# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2fc09051b6d2c0561287c853f8e470bc"
SRC_URI[sha256sum] = "875b79fb10cd16ea272d47f061ce827e02011d6e280b42edb2c69861843f75d3"
