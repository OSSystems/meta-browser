# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "393505f56242b4bc9d4bccacf47ec3dc"
SRC_URI[sha256sum] = "0fbe00bb7f0e6f05a64ce4e0198a43d61056796638e7b3a4b98dad8a4ccafd8b"
