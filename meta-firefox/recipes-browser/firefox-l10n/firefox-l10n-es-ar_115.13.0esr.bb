# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a9b4d2c061b451902e764ddebf577576"
SRC_URI[sha256sum] = "593bc094a959d1d2a343d8dc52013d2cb0046e5bd2ebb09f4738308a4c59df1e"
