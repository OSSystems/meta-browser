# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0b619ab09ed5d5346bea9ff30d6b8322"
SRC_URI[sha256sum] = "052d64a845f7232dc1b2ef059603d16bd1d9e6814f332fa0d8a5c7a5ec38679f"
