# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "30993785ef51d853f84324dcecb95d69"
SRC_URI[sha256sum] = "81fcbd7291867f9a282fe14d4201ad8013139b01783bed2bb3bac4bd874e7331"
