# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a893f3fb99dbc463b382ea4777896846"
SRC_URI[sha256sum] = "ed479f659b5756ff2e8188648822f4a95c3d3440e9fc0417c6f1777cd17cc8c0"
