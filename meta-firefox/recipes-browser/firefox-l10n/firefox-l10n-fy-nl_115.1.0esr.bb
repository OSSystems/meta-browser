# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "161ffdd5fd26db2a6692812a3e49e916"
SRC_URI[sha256sum] = "e459d6aa54ec439d1a3dee75462939be38a04a89137a7d4c942dbf1c9647bafa"
