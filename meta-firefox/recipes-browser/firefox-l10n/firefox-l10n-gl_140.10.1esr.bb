# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "27f7f4cfad8216e752160890a54605c6f3a6965b94f03619b8fc3dace2653339"
