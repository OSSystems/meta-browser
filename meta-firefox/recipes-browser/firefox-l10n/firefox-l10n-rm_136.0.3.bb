# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3c83ba160c894b16a8df0ca98a1660a6"
SRC_URI[sha256sum] = "4503b9b7b46ca1e33e28187d29148dc62a626ee4e4ba66029e3a43c6e1b32f2c"
