# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6c9c6fe2b862f9a9453062356da187fc"
SRC_URI[sha256sum] = "990329e001f33677ab5efac583df29e1ddd5741eb80be9a5df2913f704f93f7f"
