# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "145851a916bb5e80005a009eae2d3cf7"
SRC_URI[sha256sum] = "89a83bdd4e6b8a6cde54db35963bd1f3bc5fd7676d7924a62bb2e8e297482579"
