# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e55b8497e2c4ec278cdbcda5a349d754"
SRC_URI[sha256sum] = "db2dfbb7cff71c2a623fdac57a1c2049fa0ef2bac4990f38f7ecae4c19a8f11c"
