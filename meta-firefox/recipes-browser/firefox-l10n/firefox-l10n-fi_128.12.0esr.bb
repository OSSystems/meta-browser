# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "336952ffd04d95a58968d506aa574c4e"
SRC_URI[sha256sum] = "0b28fbad1af955599e191d8ed03cafe23ee53a3624edeed07d746bedcc396dc3"
