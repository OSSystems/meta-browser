# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "6b5dbd44b4e95d1ae7ae837245b50882d8be20dd0413d3ec86cee04cfc733c58"
