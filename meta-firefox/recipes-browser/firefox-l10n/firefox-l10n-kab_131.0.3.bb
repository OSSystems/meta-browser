# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "688ed4bcdea222c00f447337c3fe83d4"
SRC_URI[sha256sum] = "def7cddcf85036f87f2814dcbd6d3abb1ec430f0864177143f6c021938d4b63e"
