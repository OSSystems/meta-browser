# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9fb8301992bbb4953a8cf5827deb8f1b"
SRC_URI[sha256sum] = "3d01f948e1db848adada16b48b8fb6e7fe4c1df4d289d77b572c43becad4adba"
