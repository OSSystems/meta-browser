# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "07bf8b4df152172dbed0800c32b70071"
SRC_URI[sha256sum] = "318636d62929788f29ec9e34ab742f6f307ddb31034209cd9e1284c3d6b36568"
