# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6854c0e8018a739158a9da05b309790a"
SRC_URI[sha256sum] = "cc2fecccb57c480850bea2340bec47087f15ee464fb47853c4977be07b15c3f7"
