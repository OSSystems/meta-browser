# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3a2eb2b17cd5412b0249c82a87434aeda49f2bcb0b7295b5cc55785694ffae8f"
