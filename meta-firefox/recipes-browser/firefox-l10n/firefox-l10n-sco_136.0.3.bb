# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "36a09581aa4cefcb0d3239d5a9657cea"
SRC_URI[sha256sum] = "f134addaa63f65fd08f3bc9a920b7cd190924ee442bc07a70abfe1f6a4b82b94"
