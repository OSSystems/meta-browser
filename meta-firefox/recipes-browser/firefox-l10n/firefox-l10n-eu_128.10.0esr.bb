# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3c33727c62dda0c760157e21b925ceb4"
SRC_URI[sha256sum] = "d9a6d616c8295f2b5cfb05c677cfd5714c9456d3b9c2921848d4c65b6df940b6"
