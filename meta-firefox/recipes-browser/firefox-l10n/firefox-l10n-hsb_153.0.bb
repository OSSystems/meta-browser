# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "a211d7114fcb75c1f003f4e29b1984ceaa23b1954add830f320b1c2adfae744b"
