# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c0153dd6fd894aceb44e818102196f2a"
SRC_URI[sha256sum] = "1887ba395c014c9a7bfeac8758cbb2c37a06ba2ffb8f8b5ee18a9681b18577cf"
