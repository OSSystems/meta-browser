# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "08f1c5e6f5342b983dd3ac76929c7e14"
SRC_URI[sha256sum] = "0f610d3cd6b50ff12ab25a81560d4e0fae2a75cd06b521d9fb34f1916d59fd5f"
