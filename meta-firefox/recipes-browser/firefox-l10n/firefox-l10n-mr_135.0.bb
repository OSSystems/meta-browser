# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "129552b55db48e46a7a8389f72a56243"
SRC_URI[sha256sum] = "7db65e3290978690a76a49dd02cf81af3d22f1cf46069243e4f80ff32ffa1088"
