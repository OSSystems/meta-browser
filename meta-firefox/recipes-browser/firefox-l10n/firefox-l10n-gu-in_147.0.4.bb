# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f2b6ac39840bb715791b2e66f716cacb"
SRC_URI[sha256sum] = "8c6467db8cb95a2661ed613bd215d1c245521368644d3b828e31ddc3724c599a"
