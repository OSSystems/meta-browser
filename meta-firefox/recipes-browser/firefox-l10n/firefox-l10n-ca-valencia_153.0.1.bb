# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "9e43eeee2045c0726c9fef2eed2a8e0e3c55a821aad7856423f2c81c58f3f971"
