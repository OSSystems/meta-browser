# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "52762e893f7fd6133a7948d4bdb567cb105c65d5a6b9237cfc8c8eff828a06a2"
