# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "46737b096e4cca1868e21dcf79412001"
SRC_URI[sha256sum] = "13364b597783432162eed1db17f4322319e5e861da1b50bc1a139ad0761e6ac9"
