# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f7fcc8d71f854f94c6f20757eef67b26"
SRC_URI[sha256sum] = "0ca9a22ee261c96ab526ba68d17ed1a2d1e52e45d1c920e5980902c17522490c"
