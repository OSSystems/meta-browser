# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1a107594fa0f3eacbea68bcb0d076385"
SRC_URI[sha256sum] = "b7a3bec02c1e3d91d12be2650e326452110b4e0e9faa204bcf0cc8434e6413d1"
