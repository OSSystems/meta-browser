# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d87eb2ce93ffef878556f88f9006d2d9"
SRC_URI[sha256sum] = "1c4421f8e319196fbaeaecf8d87711d1d27b9417d9ce8014c71a4d405ba91f54"
