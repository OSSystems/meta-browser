# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "af5fbe0d4c8e16d3db08e3b8c86f1621"
SRC_URI[sha256sum] = "976fa4e036ca3ee71a011b09dc97b5f7636648167c16345fdf45adf529ed0069"
