# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b02074f9426ab832f019860e63d832e4"
SRC_URI[sha256sum] = "640b1445789e34e776d08eb0ad7448ef0e79f05e612f9454ccae69e93facd79b"
