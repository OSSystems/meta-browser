# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "989c9430e66b1297b2de343245e295e3"
SRC_URI[sha256sum] = "5c16b43047146704249ca2f5b412b7304c4c2fa9c4db1023dc89adbb242c3972"
