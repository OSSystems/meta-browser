# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "45718d828bb2916d7c1c53adb90ef0b5"
SRC_URI[sha256sum] = "457c7361f244bcb0b8bfdc811db24c4527ea3d80ab438e5ca93325ab235bf219"
