# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e45cdf6586dd2ebfc0ff38d55b1a8aa0"
SRC_URI[sha256sum] = "24183ffcb935e6b1d9b6a0761e6b4f7b66ef3bb6621019c70cce7b88a988dc0f"
