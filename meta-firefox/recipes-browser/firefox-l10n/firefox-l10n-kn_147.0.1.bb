# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a8177a5dbf44b134faae0b3c99c069a7"
SRC_URI[sha256sum] = "1102a7b39ab705e7886d5d65ac3d886aee21bc7e7980adeb5c62ac369db8f50b"
