# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c05194b94a1afd8297ee23ac0c408f27"
SRC_URI[sha256sum] = "623fd2a11ef2ce572ec324d7069f6fbce0f28714b8752f398b57ba89556f1813"
