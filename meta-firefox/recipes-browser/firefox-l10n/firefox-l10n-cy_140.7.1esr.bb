# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "be9d102b6e24f4d41fbe0e0a42661555"
SRC_URI[sha256sum] = "8038df7880292c8fb208f52b317a054a4abc08693d040e0b72f750122204d943"
