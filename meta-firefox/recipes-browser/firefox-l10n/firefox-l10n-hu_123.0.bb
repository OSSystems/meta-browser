# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a2fa6f1a1496227b90659c8d6775aa71"
SRC_URI[sha256sum] = "2b00bc3b78001cf572d9134067592a875b88524279fc75a35462753f064d296a"
