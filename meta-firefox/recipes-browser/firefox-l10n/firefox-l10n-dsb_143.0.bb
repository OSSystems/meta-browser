# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8a1803de9edfed7c7c0264e86644be41"
SRC_URI[sha256sum] = "15f51cecb77afd407a6d9c7697954b066822c58454655df24d0108ea65aa81f2"
