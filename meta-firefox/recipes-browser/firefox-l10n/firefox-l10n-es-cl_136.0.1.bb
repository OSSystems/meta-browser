# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "81a7d2bf10c822efd5ab8e6739ad66fb"
SRC_URI[sha256sum] = "6fff35a19927c44194573efddfa4fa3f23600e1d4769ac10f672b0e3f742f518"
