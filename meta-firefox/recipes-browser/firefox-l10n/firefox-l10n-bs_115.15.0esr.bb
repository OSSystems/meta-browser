# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "137422a7c29c9032cac494c2c67d1225"
SRC_URI[sha256sum] = "ebf9b6ce23d8ad378d0d2e9fada12c6a556c85e113c684ff2302054221954994"
