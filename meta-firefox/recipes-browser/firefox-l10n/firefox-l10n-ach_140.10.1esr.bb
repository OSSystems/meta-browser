# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3effa119297595243a78516fae3eb3bbf9af9f6d86ddc0c14ccb93933bc6b273"
