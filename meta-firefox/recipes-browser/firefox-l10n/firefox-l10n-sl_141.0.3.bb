# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "23de4a92f10c617f5bdfd11ff1c42200"
SRC_URI[sha256sum] = "a5fc036dbdb93979c482b0204fd369248cd9a0d0e53f0f16717a4e100a544a69"
