# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "46587690c2b42ff01f963a100e540dc8"
SRC_URI[sha256sum] = "be73ae9d2e40745537b649f441be5e0c62f10d07efc721fad34ee8ed2fa12670"
