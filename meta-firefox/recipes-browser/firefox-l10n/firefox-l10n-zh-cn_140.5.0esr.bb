# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5fa762e4a79ebfefce575e8d66cf3fe4"
SRC_URI[sha256sum] = "97490db9b1bb000687911cd16bdc6e019243b9b11b4aa2efbdd56256a3a06c17"
