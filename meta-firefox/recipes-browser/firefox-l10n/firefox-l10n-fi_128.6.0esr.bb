# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "062b12550629ac61e0b5bae7c591f4c8"
SRC_URI[sha256sum] = "5c5bb01f3374db7f26e9b572ff9e1e43869388e97c2657a8c76f72af97603708"
