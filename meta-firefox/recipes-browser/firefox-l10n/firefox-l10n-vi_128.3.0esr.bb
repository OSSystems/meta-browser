# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "711aa8cef0bebc3bcf8e455a4b1ac6ae"
SRC_URI[sha256sum] = "534b0c0953e7718ce0c64a84dc5b720de655c1589d251e33196229c88ef96fc5"
