# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d7f4111c0d4407a5717ae21283f2c401"
SRC_URI[sha256sum] = "d3475a013c844b39686eddc218bb417d7f323d57b15f0f4eecba252fb5af5b31"
