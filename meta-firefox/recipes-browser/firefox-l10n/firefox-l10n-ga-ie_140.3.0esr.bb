# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "00337ed97dea2fe72de71436e0c776e3"
SRC_URI[sha256sum] = "3f46a0161e01fc577ae5e2768299091d7b960ee5e125df5724035aa8e26bd300"
