# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6f7b49ce961ffcbe46a9a13ed6a99d6e"
SRC_URI[sha256sum] = "9310b1efc6a1d31c9f58ab3fc8729db8ec76c9dea227bd24e5a5880af922e45b"
