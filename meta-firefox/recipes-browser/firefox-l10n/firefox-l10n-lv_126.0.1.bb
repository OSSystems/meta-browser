# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a8b09504e03f642809c3e6481cf77490"
SRC_URI[sha256sum] = "8313ae3a076981eb81e5101155980bd7c7b641ab96cb094be9f163ecf2c526df"
