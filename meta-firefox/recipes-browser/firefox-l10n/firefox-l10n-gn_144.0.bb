# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2c28040ffeaa9815d044ae20a87d68c5"
SRC_URI[sha256sum] = "0203f011e486c9864cfcc44e47e34e051c4bfd978da2423438c0d34cb501c914"
