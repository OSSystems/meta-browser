# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e703736c2381714f45ee91388e01c674"
SRC_URI[sha256sum] = "c78cfc55650a119cf144937b8bb24f5df2bee55053ec3ffdffcdd16a489da57d"
