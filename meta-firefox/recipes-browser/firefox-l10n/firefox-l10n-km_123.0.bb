# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2f9ab27a4ede002eafe5bbdcafa7386f"
SRC_URI[sha256sum] = "eedbee5f2600c9e1a43924687286ab8b307b71dfbeb7a10e8e2421febabc828b"
