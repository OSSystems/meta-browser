# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8d2876e2d58ce80c3508e69b110f6d24"
SRC_URI[sha256sum] = "e17a36673df4b06dcc288209cee60ba74214a50f78726526215531a4e8fa1a6a"
