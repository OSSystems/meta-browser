# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3ac9aa6eecd506535491936eb0438c32"
SRC_URI[sha256sum] = "146ba950b8d5ebae1179982a98fb7b83b8464daadf50ffc7e305badefd9aa7ae"
