# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c7d1352bfda62dd7e6998a10a2a7cee7"
SRC_URI[sha256sum] = "726bc6efe72b510de9e0f7c618346f2c151ded55c231f8a252783a99374b120f"
