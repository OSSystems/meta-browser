# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4b404af3c89d53a9cdc3a609b85250eb"
SRC_URI[sha256sum] = "399a34e600526ca7f509a7bf81f85756d810848a07409a3df77fe9a70ac4433d"
