# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "848b7e8ac3c3c75a2ca38bc714bb828f3b56f6851a6c157c153b198682683c55"
