# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "28367974c63b061ff1710f87a64cddeba0e44dc73d5c204acd42a097d2edc7f7"
