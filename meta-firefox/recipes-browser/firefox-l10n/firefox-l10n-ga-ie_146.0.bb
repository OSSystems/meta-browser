# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e0d88f80b5b31119d8863c4182463269"
SRC_URI[sha256sum] = "9b9bca06046672ea86f4abeac1fbf9aa18656037d62e80e9642a128add833a58"
