# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "132a33ffd2eada24f629de376bdfa9ee"
SRC_URI[sha256sum] = "904400591a4bef1a26d4944c0653a78a0a62d8eaecf458559f69eb686e45b49f"
