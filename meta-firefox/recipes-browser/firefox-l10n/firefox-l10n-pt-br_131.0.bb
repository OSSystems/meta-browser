# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c315d84282966dd2701e235ae134363a"
SRC_URI[sha256sum] = "7e8b78260f07511350bbab66d0f2100e603705ab6dbef81e112d185b84f9aeb5"
