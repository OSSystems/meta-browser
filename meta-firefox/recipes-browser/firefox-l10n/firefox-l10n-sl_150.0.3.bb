# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "086c7ccf4cac55c59e0b650b1c1f02e0d2b8ae4c4cba7c2e1bea4d6d7833d248"
