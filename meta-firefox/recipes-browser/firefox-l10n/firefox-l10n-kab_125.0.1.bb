# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "184b927bc94a6c18f21cbb6d9efe5198"
SRC_URI[sha256sum] = "7e99c990dd3171593f8c923765e331bc26686e42cdaa79873c6fb86eb9dfb28a"
