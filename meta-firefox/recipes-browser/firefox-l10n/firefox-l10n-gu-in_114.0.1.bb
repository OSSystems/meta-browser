# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c0b948e467754c36ce3943c8953003bc"
SRC_URI[sha256sum] = "3b5fba36beb29efb1ec0899d7ba4710edd62f72bbbc3bc2cefd6f26a3b880f5a"
