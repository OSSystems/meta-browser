# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d580ba5c737be3312baea37c5d5d1559"
SRC_URI[sha256sum] = "7894cf9867d0ffdfc4bab148fa3b91c290c79eafb31de147ed38219fbb519720"
