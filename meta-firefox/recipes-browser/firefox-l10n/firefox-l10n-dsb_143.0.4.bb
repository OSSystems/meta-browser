# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "75f4bcdcea25a533981bf3b4f089511f"
SRC_URI[sha256sum] = "09282615a1813f358567a845bfcbbfe2b2be46646561bebac1f265493f4bda2d"
