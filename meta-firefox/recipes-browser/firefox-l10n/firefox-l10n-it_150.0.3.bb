# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "781d5c2965d7d68d388a46b01bc32c5f677f965f01c2d03ae6b64413cbd5bf08"
