# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "41e0a2c4f0abc7228e1e7e971f8bedce"
SRC_URI[sha256sum] = "79522186875a48381cb142d3d46a011718e6930203b6e89ce508368e7181c3c2"
