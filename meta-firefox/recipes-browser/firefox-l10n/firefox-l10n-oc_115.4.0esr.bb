# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a1610a2dd67ac5283f629e40c184413f"
SRC_URI[sha256sum] = "98fa3440fb93cf1bdee4056a40ded6b3b5a735221c192772a62adfdd4c28029f"
