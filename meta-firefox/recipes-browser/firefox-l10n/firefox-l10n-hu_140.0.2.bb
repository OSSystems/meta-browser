# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e4dfd5b8b2ecf7d9cf2d8254ffa51b56"
SRC_URI[sha256sum] = "cf6cf1361a0c6b54aff59edd075f5ee4c91cbaf2e6e032e594971d28344fb270"
