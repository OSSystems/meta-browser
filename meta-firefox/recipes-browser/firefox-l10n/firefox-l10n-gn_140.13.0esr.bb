# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d169ac41326c1769dc6b2e2608261693e4f299fcf9964c1e8fd4263d14b9eb44"
