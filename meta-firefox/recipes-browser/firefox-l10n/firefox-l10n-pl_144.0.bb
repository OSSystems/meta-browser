# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "96bbec0bfe84e6461ac2f27586f69a67"
SRC_URI[sha256sum] = "6651272ef27273b089cdfa6f3c3f21d313f80281661b6afa3d8aaf942ae14b28"
