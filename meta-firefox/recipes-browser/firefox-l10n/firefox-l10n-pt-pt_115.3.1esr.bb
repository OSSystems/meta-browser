# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a4a6f627f39c9f78bad29fcc8e982291"
SRC_URI[sha256sum] = "dddf8f7e2330ea3dfb800a4b852b42561ad354b16103aae17b0ce0f402be8a47"
