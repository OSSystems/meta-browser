# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3bc0b31366bb7287ce51ea23a321b30c"
SRC_URI[sha256sum] = "7e5e7ad67974d7404560a428f4a58b307c7a5975c1805d8d242af6d0dd80831e"
