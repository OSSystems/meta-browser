# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c0ef14f3f9ea575143c947219a008d6d"
SRC_URI[sha256sum] = "5403f3ba5307812644e82e94f4bfa394881bbc2e28222812939e3445ce66bd99"
