# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "850f1dbff5613943f9f2aaa657a84d3e"
SRC_URI[sha256sum] = "f675300a9deab6d57f27780bcc9beb24f1def0af7ea778482d626afea06d9fd6"
