# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b336e4a6400d584ee96eefa651cca0bc"
SRC_URI[sha256sum] = "0149211ff6fcc3ab65b0909fa72adb21325e9c4d24446d33c0ba76c044dcd996"
