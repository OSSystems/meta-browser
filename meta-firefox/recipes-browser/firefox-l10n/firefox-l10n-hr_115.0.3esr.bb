# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bfbf49b5641c59d832c68f28f33fc726"
SRC_URI[sha256sum] = "3866139fd9132ff5b6bcc106b440008a41411168725352da4a225b4d5c8aaf43"
