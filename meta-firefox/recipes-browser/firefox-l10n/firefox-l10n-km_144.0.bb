# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2f33c612e7e0108e77a6880f1d019c1f"
SRC_URI[sha256sum] = "d27fc2e6a436492b1868458a5b0f4b4ac72a07e6690a6de7d85ff8d1ee5d5971"
