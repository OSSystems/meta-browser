# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8140e7c6cc004fb6a147782912a06533"
SRC_URI[sha256sum] = "e04107f54fa241e396cee9e485ed15e178fa0bb51ef58331b7c24ab0e550be38"
