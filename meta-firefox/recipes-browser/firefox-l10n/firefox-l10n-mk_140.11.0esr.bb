# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3d36a5dca2a37b12328665bdb1c38103185c804595f0c0826bbaca8da7501295"
