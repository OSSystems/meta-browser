# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5cc3ac042da42f8f9cd3970683b1b00f"
SRC_URI[sha256sum] = "0a7a0b4ce84fd1377a68d05fd17e9c16b3d8f288ffa4f859b6863b84461fc368"
