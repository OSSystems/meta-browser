# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3001a0c0d7f8e51d47239e068898b907d54d17d9b786b55d71b94c5c42179cc7"
