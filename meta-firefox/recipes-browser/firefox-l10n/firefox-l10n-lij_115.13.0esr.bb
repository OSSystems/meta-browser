# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9676a0e4cece8b6debbc2b6affcaf310"
SRC_URI[sha256sum] = "d0c79f9413c729fd8bf45657e5a10e31fc3c4bca50bdba5ea038c466d55694d2"
