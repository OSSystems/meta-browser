# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0cbf677a6acaf9d9f73d02c025ece620"
SRC_URI[sha256sum] = "47538f6cdf9ca1a8bb1024378ca2cd21a3fc4b2851cac73938ebacfc56051c27"
