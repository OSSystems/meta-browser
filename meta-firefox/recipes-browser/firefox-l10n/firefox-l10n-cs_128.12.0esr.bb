# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f42a4bfaa5054d13097f0028d4d7fee1"
SRC_URI[sha256sum] = "ce2e47462ad105723b5cdeb43b84f85216756c52d2d59f3cfc5ed38b518c2819"
