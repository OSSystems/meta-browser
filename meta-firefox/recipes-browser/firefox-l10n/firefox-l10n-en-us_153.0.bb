# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "1e8940f0f1510291a029963f92e8a41b6a8a8745507eb0d6eedfc4ff4aa4d97a"
