# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "97e36c705feba6f667c6eb5d9bfed994"
SRC_URI[sha256sum] = "9d5f7b1c43588a48c9628ad1e1089fd89343a51b8f288a7054b25bf7cdc03bff"
