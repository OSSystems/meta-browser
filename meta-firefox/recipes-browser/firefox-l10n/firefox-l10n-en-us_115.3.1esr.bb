# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ae9fe9ea8839986d577c91df155a63eb"
SRC_URI[sha256sum] = "256d9d3d56d2ce0323056e77f0edba20e3dd0d967b1b7ce32688fafb263d510d"
