# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "29d5cca41ff6d63358ec0b0bac4eab65"
SRC_URI[sha256sum] = "e088afbed9db7fda5f9b2f9fb1962135bc614bc8837dfd360a155903af8c7896"
