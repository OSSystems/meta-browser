# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dfdfeedec634e021da39d1f95ba2e55d"
SRC_URI[sha256sum] = "b4d33729f65da72de9ee00b0cfb1c4dc7c1ae983e8f9153f71942d93961dd959"
