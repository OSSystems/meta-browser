# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "416a284712760e7b4d9337bee4b11d27"
SRC_URI[sha256sum] = "4b0bb0db6a29b9d63a72719fa78e40b9318f19e53b4d5148437ba5381c2b78a3"
