# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e4d4e56c585ee63236246868fce01b77"
SRC_URI[sha256sum] = "af45fb6ee0e85f969d45b45fa926b0a34505adeb593902df5fc16752266de03b"
