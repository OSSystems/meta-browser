# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c0db2cd21b66e665b849bf091dbfd12d"
SRC_URI[sha256sum] = "514a6d1e9bc11a139fac6dfd260bd7298f65128c2316218febb19ad9c7bb3b61"
