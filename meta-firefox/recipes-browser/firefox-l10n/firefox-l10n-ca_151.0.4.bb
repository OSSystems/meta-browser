# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ce74d55ca88b70801152bdc592129c36010d1184f54c5fe860b3c7adb483fb4d"
