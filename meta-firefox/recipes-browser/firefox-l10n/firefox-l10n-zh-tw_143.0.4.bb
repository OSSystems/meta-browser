# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4f478dd3ebe5dc9b68165f07db9b29ae"
SRC_URI[sha256sum] = "972567b810d1bd1ad6168bb6cca526facf82d81c4c78d44aa4141f649d10e99c"
