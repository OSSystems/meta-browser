# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1c900ee76138374e1276183117484278"
SRC_URI[sha256sum] = "84f5ae5c93751b7449acc97fd118a9ed61b90fd23d4a3ea63c284302b05381f2"
