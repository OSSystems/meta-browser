# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1acc21eb01bae0dcd6d20ce1ac5ac6a4"
SRC_URI[sha256sum] = "2176e701f8b942b8ae626658f7eae31a9a93740ef6db06ba325393f561b622fd"
