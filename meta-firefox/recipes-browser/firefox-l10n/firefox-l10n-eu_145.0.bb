# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "84277c077ac78e62a0ef7afef332eaa6"
SRC_URI[sha256sum] = "787158fa9f79aafbeae2b28c1777f05026330ddb9fae4bfa447684b882f6b53e"
