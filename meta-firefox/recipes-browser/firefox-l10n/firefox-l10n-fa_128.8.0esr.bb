# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f78a0b02a2deddf937fe277120a5c001"
SRC_URI[sha256sum] = "65350dfcfb439db2cb420d13b4353bc105c6f7326b2f2a42e55beb7d0973b705"
