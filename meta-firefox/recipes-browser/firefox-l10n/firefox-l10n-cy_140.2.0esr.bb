# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "20c61ba67e96ea046f6f3960a7a093c7"
SRC_URI[sha256sum] = "b1a6b8fb78fd00d584c7a89117d78bab398a3676430639bac37e743b644870c0"
