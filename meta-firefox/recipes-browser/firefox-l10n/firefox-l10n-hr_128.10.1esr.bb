# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dfab77abe5a80f856ed06840ebfa2150"
SRC_URI[sha256sum] = "c2949cd8dc2ae0c475536109c91c4210ac76a22327356c3972a47bb9c079fd3a"
