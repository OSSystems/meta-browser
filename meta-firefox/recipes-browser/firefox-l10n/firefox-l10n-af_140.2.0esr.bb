# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3a488cb6f191335e51b53e08ca8aecc6"
SRC_URI[sha256sum] = "9756120c293915e9e6c73450a7ccf30d76790b5ee881c5f9fd5f4bd314fce465"
