# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ff4b878884fa76f73c8985b7ce14c737"
SRC_URI[sha256sum] = "cdb3e352456d73c30ac4b5fddf0354995a13371665848e600e1a32151ba8fb4e"
