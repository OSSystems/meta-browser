# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "1bc5f0b1fb1b1449af3fcd448aaf7c7d879c1a796b80da046341f861c5ac4c36"
