# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2b767917cd63e99942f91e89ea23353e"
SRC_URI[sha256sum] = "c0de93c1461cc559cab70944699b4bb55fad2fa7c54c4f4f6cf063be3e427d67"
