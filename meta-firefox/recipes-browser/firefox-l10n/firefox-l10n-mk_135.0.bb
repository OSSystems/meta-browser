# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4a737ac1f4ee2b094c20825137023470"
SRC_URI[sha256sum] = "6bc6a9b95f2bdb2810c4843023bf6903640d370c72b2ace0edcabc12359d2126"
