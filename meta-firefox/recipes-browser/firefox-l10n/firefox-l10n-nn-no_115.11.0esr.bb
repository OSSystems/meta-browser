# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "243e2aed281ed27ad6846f9784eec9ac"
SRC_URI[sha256sum] = "f93a8c1b3690296a3ae041199a77bea8d8eedabc938ad468e863609953bbe18a"
