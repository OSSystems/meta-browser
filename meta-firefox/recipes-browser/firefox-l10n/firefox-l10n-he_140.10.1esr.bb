# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7071844a20316c652f3002777776b3ff7c7569ad851f25e527f23ef8a8ce763e"
