# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db7d7a5e298e52d989f515d9c66dd6da"
SRC_URI[sha256sum] = "e2b7a586c54eee333400644eef701d2f26810716ec94615ce70917fe872abe5e"
