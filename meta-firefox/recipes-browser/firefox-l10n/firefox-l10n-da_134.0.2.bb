# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4e00d83248e711667909d71dd4e99ade"
SRC_URI[sha256sum] = "e9d0ad7e62e91c7708bfaad21691e17945f382a44a041947d88ada1ba4dcc19d"
