# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d38b85dda5791d48ae60b06f35d8f0c1"
SRC_URI[sha256sum] = "9173ae85b56ff15748dd2fd822bcdb7ff8d26675e5b36da26cc90c831d81e3b0"
