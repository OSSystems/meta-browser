# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "925da468140046d79369d49d33997cd7"
SRC_URI[sha256sum] = "1a8d6b178475d4fedd50be8734af595fca0db2433930aa69dc1794e6632b32ff"
