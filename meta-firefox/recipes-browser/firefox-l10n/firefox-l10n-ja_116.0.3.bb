# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eae4521e90aeb4e8b45391918af5dc14"
SRC_URI[sha256sum] = "5ce87fdede3dc3a0f36bdd00b43d744cbf9dcdd31dfecdce1afcb0de9e76b691"
