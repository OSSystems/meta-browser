# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "acbbdc86df5f267fc7e04bec09304193"
SRC_URI[sha256sum] = "85aafb2fff59e2de98756c76bd52f5195b0cbbebad52c5796621e615e89aeca1"
