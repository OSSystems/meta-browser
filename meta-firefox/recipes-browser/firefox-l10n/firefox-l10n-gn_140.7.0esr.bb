# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b87465e4c37f92157b124f291ad16c04"
SRC_URI[sha256sum] = "c76dd7f8b0c83038b4b3a04c111bdf3dc07a182d58aeae63b27533c29054a4a4"
