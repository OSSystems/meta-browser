# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bea768af51728eedc66f3e55942e69e1"
SRC_URI[sha256sum] = "27bbafb753cf0df93b86e27cf1721bbf74986d830766c8924910f9d7fe51b1b7"
