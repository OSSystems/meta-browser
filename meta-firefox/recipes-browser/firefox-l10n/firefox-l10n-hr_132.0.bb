# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9a36e9b3eef3e63e26fb7ef39c121041"
SRC_URI[sha256sum] = "39c7a566401d0b5bdc3cfa7f759386c5fd4534f7ed952b46a857e4269b2d6cea"
