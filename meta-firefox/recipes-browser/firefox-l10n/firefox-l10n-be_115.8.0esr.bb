# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b670678e59506cbc2a3829e91105e7f5"
SRC_URI[sha256sum] = "5d0100b4dec476aed73821fa60e353b845e28ebe875cb98484d273aba6660160"
