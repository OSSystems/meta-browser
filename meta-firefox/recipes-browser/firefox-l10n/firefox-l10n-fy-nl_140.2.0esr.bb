# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "900d054f6924d790bd17596897f81f63"
SRC_URI[sha256sum] = "da6804a6127c8bc108c4cadf2ec079356214752a42c21a233c61db83269d3122"
