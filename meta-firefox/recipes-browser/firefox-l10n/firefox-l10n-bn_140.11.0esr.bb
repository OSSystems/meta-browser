# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "0c3d0b3e9452cbca27f664170294b74e040cafeb01abb3a41815c06e5b06100e"
