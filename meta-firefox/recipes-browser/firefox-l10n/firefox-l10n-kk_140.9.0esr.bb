# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7e4044c9b463130034ddc9a1157e727b"
SRC_URI[sha256sum] = "63710008e7ac15ac6c71abc2dcd668421e2f710b9b01d2e6c7d790e5cf8725fa"
