# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "92ea63a0dea2340fb4af788bf996da24"
SRC_URI[sha256sum] = "095a02ffddf067c59a08d62559fd3492b50e293f5b331294279113e993f9c113"
