# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "57a0f9c0ef2abd7f3ea32d598b7844ba"
SRC_URI[sha256sum] = "9f059b90ed93c6a62ea03f0cd4081ee7b7f62ba24c5d17b7f02dafedb12afc05"
