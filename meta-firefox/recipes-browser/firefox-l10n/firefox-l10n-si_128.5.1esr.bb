# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "27802bf40432651e6d6da40fd6fe621a"
SRC_URI[sha256sum] = "e84b621898523b90d75e854c3de088a765e262bf75dfb4ef35ab16ec2d51a4d6"
