# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1bdb5058bdd40c7f359288128fe50e5d"
SRC_URI[sha256sum] = "b7a74e0bebd53fbf5b6fab83f494518bd3200205bdad1b053d95359a63b2c5ca"
