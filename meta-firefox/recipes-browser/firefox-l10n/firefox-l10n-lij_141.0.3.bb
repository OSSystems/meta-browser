# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6bc661cbdfe40aa68e19688e8bf09b4b"
SRC_URI[sha256sum] = "c5edb2c8aef67ec63eb7b117377af828a78e6a668381c690ffbe5e86c925ccf6"
