# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7bb2d03152f9eac33d40ce2472b48060"
SRC_URI[sha256sum] = "4941740a6aaa4f0b0da83e2d8eb0e6add3450ef269f21d829195d06af0c89718"
