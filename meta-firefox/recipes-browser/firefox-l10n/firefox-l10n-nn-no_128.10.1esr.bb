# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7f19bf7fa9942234ae4d86853479b186"
SRC_URI[sha256sum] = "742636c315d37584695b779e756ea2e8ff474fb5e978587f269587c0151ee375"
