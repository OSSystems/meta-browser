# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7330a9bf9d436046ff05f1ea9d859ffa"
SRC_URI[sha256sum] = "c28830551ef66520a766c1b2e5a4e60530a9fb6bc06fd92e3897fff22e25fcdd"
