# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d25cffd9b4b17f4bd811364d8398b74b"
SRC_URI[sha256sum] = "49fd27e1a8b5ffc529fa0e5c46577a6e82b413a2c0da3b26778dd37e133c9d2d"
