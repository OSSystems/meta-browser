# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "90b4b4026698f109996975ce3335b1ec"
SRC_URI[sha256sum] = "03a80fd4d6c73a06dc740369160f8c8b168a6a41493f56a42111612cab80d73b"
