# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d6d48768897ee8ff6fea1c2ef8c59291"
SRC_URI[sha256sum] = "644e0aac67b506b16ee3a66572fda539caa1866ee6657586e869bf35cfdc585c"
