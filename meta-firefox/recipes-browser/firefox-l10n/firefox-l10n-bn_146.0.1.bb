# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8b37979c790b969dadeffbd1173430ed"
SRC_URI[sha256sum] = "654907a40632cc4312eb4f0f7c39187d13557e83620437cb21f680af99c559fa"
