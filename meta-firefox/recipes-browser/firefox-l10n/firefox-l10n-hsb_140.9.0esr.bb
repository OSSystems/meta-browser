# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fd0ba2e382538bb11ae874cf2cd74dba"
SRC_URI[sha256sum] = "44a8979f9dac01d78822b6fdba2b10dbd604fcbe6c2b06d300c9cbdd5c3a77e5"
