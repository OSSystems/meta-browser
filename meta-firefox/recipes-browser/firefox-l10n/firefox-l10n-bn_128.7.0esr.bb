# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ef0782e3c19075ba69295eb09a3cd014"
SRC_URI[sha256sum] = "9233cb8174d9cc41077834c8bbaf7ff4eda50b6109db10054e8b83ff98a3faf7"
