# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5f21b547a98372d3c73e54bbb9ec1567"
SRC_URI[sha256sum] = "2e1e10f3aa213e54d162afbd233e1d9c6f49f8c0f1ac2267893cf5b5f65703dd"
