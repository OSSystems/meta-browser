# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c790f04047019b9bd0970186875115a90f39db84fe318b366b1d93cd6a78c5a3"
