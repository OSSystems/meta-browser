# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "35bad5106c0cf006b25ffa89a077db90"
SRC_URI[sha256sum] = "db6ac737d1cb9b4fcaadce17122f43a3762830d82eff1ca7283edb928ba2c416"
