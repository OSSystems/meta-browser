# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4afb523d8a798e26672605f883388c9a"
SRC_URI[sha256sum] = "6497e917dedc4e14f63edf721106c6f10b9789752032f1876bc419e7df8c8579"
