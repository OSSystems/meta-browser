# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4bc0b53dfee7dd03eccd46e8ef1bb2c2"
SRC_URI[sha256sum] = "b9bba0b645c1c051294437c2cc17a15b2bd06ffa274e84489d542c731c84e347"
