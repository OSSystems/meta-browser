# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "60ae321e221a74f20da36f5bad057d1d"
SRC_URI[sha256sum] = "5d54c10c1fcbca62989c99e720631b30633d7ab85a9d7e304bc3973394980094"
