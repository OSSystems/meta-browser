# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2dad2e6b50650503ee877173aae75cc6"
SRC_URI[sha256sum] = "0da00d1632418ff56edfbc9162fb09c2d9be8a886436db9c4af0dae257ee549a"
