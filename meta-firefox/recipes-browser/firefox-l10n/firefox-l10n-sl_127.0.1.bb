# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bf5aef4e565fc03eb09d37abc460dbce"
SRC_URI[sha256sum] = "0221727f7355e196b84f3325562eaa44f920be4419f0274012f0b6dc184c7002"
