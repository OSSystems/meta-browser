# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fc268bd8d7410e6c2d5263f1cda5af79"
SRC_URI[sha256sum] = "90dc721b127bc08d8d344dab228a150775529c9f2c78c0f49fb82fdc4043e50a"
