# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0d89b029b0fe832ec87a51982efde35d"
SRC_URI[sha256sum] = "39b03aa5d48cb1ce3b45242821e6b554ca6abf39479a6ff0004c6d2ff8c9d74e"
