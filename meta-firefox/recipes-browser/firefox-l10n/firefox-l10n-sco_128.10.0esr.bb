# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "738cad172773cd91d711132b6d069acb"
SRC_URI[sha256sum] = "4baecd997608761adfa22cd86d8962d660f2bfc7441f9cc694374a15b4c1354d"
