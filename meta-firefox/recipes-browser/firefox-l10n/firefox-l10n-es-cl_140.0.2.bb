# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1787afd725921ba405821fb38b368176"
SRC_URI[sha256sum] = "d9440d35e4f1f15190959a27a0a6b9e6284f18eafe98c6586738d2012d3eb325"
