# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "27f4ba6f8368639fbd5f274f27853604"
SRC_URI[sha256sum] = "574e91d145e938ba8c023a75beedb4abc2fd48318a901b513c4f1fa8e6f073b6"
