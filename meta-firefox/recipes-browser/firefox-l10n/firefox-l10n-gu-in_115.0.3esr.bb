# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "56f9eb633c48bed5c4d1f0af9acaac90"
SRC_URI[sha256sum] = "78425f2c6dd1b3315ae43ece0092f8ff07e114022027a9a291c60b6e15ef56e7"
