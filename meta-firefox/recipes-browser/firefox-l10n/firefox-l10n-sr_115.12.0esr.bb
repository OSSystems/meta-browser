# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "70833554151a12701fbd44648a8f8606"
SRC_URI[sha256sum] = "df3dc102f11a3d1de39af62b3af007a6f782956e39fcfb88415f1dc10324ce55"
