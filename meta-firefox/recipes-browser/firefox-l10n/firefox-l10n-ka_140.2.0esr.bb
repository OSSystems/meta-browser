# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "df135cb6361821a3813ee7920a1fcb58"
SRC_URI[sha256sum] = "6300862959b1831b0aebbe58e152fe861c1eb3ac1fa8a8fcd9f7cf28ee4bd3d5"
