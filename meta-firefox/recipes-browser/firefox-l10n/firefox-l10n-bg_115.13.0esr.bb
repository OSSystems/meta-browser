# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ea08a65b07759b3322c431b848bb49a3"
SRC_URI[sha256sum] = "82996a6bcc74ee390ea9768b8e8f5c22cb763b6e36ab720ffb88e640d4662616"
