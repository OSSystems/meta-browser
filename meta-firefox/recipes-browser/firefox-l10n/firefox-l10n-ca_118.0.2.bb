# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "62bc1c4a9b64ad0c2f1aac103a96be47"
SRC_URI[sha256sum] = "a60fc2e47b42478c3830f430b16c02e6f81b2f0cecb2464ac98ae435cbff1b55"
