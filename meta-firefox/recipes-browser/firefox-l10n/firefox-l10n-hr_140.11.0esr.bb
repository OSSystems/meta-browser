# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "cc54a8af5fe36205ae72b16dd270531dd2bceda4a11f3f4e8f7a634a0604c7e3"
