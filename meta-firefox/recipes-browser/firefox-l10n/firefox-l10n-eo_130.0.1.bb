# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "72647137fc806971769bc1abc01a815b"
SRC_URI[sha256sum] = "3a53244afe691e6d5306c31f237a4900758bc1f9d962f1ff29e9d7fbc8b0cbf1"
