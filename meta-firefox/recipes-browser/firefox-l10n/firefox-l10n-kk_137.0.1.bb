# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4a0320fa556123437294fe0542cd3be3"
SRC_URI[sha256sum] = "5d646007eca3b239affa7f508048be0c394ca1080e55921a96fb30fed418be24"
