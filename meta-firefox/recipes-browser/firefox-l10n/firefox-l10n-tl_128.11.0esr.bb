# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "39e9ffd96adb0bd228e04b8ccd9d2263"
SRC_URI[sha256sum] = "3301dbef00d9c4b12a6ea97935e107ba0f45a534b1155cc987fe7eb022db9330"
