# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b4bb1bec98a964567940e7582088ff36"
SRC_URI[sha256sum] = "e2a950db81292c3f4fb18c157eb7341e3f7dcb9ebfc72543016f1249cd4a094e"
