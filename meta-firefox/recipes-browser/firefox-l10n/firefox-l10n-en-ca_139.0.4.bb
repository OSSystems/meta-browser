# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3b647660822cbdf79b8a98108a6161ce"
SRC_URI[sha256sum] = "3b097c276fe319d6abc74cc773a442e788e0f8732c5e8b0bd2d6982877bd632c"
