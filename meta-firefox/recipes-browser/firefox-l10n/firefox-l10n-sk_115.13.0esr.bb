# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c03fb594562adc52a651c282cb6f8eab"
SRC_URI[sha256sum] = "90fd0c26e42ce48d06ba3fba6f7f43e4a44098862bb9884ff668f7a28ca0b0ea"
