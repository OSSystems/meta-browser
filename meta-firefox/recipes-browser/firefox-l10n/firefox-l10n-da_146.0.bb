# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9b9c1816ee39a2116a86ed3c3cde3c49"
SRC_URI[sha256sum] = "8725071facc3b64e1927bf27e131185d4f34ec0c836fc3521f7d9e6e3b20e0ab"
