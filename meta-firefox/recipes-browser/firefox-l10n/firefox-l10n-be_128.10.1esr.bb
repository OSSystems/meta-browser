# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f00c77d07251513a39b9dc5f0d8c3da2"
SRC_URI[sha256sum] = "f59c16c6ebbb23649b7e40ac8d9fbae27d213cbf6d445d78ffbd162b9bf54dc6"
