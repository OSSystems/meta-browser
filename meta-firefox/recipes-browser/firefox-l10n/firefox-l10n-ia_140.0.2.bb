# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7b97af06e338813415b5d8044a854a02"
SRC_URI[sha256sum] = "e6be460cf5a2d26ea0e958d8dc5dd815ea1f0352553b292fbf20a662826aa73e"
