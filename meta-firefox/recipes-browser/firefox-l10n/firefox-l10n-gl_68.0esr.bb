# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f563173b3e3b89a4dad198d170275d53"
SRC_URI[sha256sum] = "627f763496d8b0f31b9276c424e49c13aa2565d7969ee30f83369ad0974a7c54"
