# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c201c87c05bd1a3affe87277607c600"
SRC_URI[sha256sum] = "22a5b67983f6241f37cde8b555814be256bf5cdfbd9335f9e911d5ce5c7743d6"
