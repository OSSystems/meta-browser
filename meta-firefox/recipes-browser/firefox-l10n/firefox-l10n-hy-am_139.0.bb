# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4e36cee26dfd2d33260b09ed6eadf6d2"
SRC_URI[sha256sum] = "ffb13766a95a549e15bb56eef90019e1891f0bb5fdfc64b8a6d616bef7833ac7"
