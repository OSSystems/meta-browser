# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "05054ad29331bd4de964b6350ad01cad"
SRC_URI[sha256sum] = "cc9d3c447b7995b855fba23afe04de090e8c442b912d1f6d42fb40de1e4fe652"
