# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ea1b0c18a85658d30bbd6b3eec099227e88b4bc5af2369b011c80b04bfeef12c"
