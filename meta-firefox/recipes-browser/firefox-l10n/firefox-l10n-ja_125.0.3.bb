# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0d99c7b367cf1d68bee37d284433ad05"
SRC_URI[sha256sum] = "83679be990eca6f0b0a4a4969682e79cd4328e77456dfa6c512ab6f5bfe0631b"
