# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "df088a3ec00a1f7406b1a3451b11c99d"
SRC_URI[sha256sum] = "1c6b5ce3273d1eb8f065cf57a23ae1f66a9f9b4301dba10f3541d28ec0b122bb"
