# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "28ad99dde5851d8843d66df754317495"
SRC_URI[sha256sum] = "312edd256d3215bd7fe59c84b8d7f50da6c72ee8b6de694f671945fd2ed9ca18"
