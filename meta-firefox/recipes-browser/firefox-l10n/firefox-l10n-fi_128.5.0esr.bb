# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "26aa2519a52ec96f1a464e1078dadd93"
SRC_URI[sha256sum] = "a0a68de358a4c3c991fdaa542eca8e7f759950080d8e4337c95f99d9e7792aad"
