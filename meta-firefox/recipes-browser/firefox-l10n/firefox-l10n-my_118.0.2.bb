# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "02e67f7c5b7c5416df9335f27cfe4e81"
SRC_URI[sha256sum] = "7ca1165d496d84a42506289f456ffaf1ed55c7cb4aefe6e94ed8ede73577eed5"
