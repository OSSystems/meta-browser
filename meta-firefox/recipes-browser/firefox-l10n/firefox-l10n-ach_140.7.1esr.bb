# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7e20a8d3dddd06fb9772496589bab113"
SRC_URI[sha256sum] = "5a7d0d93acae8d1138921ab50c7b2fdc114be54408cf08da5d8ee932a221cce1"
