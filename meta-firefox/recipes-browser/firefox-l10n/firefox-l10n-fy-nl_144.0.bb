# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c02a48ca38ea8585b2f4bb93625f2a3e"
SRC_URI[sha256sum] = "41a21c41740a3990f0f3f6b44c1e8c0bd7bcbb76b7728c30892521154f351582"
