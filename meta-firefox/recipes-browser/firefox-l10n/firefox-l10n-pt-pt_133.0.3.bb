# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0abd073e7b76d9a9ba21fb2cf6b56404"
SRC_URI[sha256sum] = "d1af88efe9282240421254dcea863c5fb0c08212533492554a63b9841fe1d59d"
