# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "736cb6290d78379b84423b1e609961db7e5f4d1505f179f262a8ecf87a6952e7"
