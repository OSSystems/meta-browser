# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "055dc9806ee0525feb382a041711be48"
SRC_URI[sha256sum] = "6bf9dd792d15f775a8b74682ec984961f85cfc5d2fffb3114591409c501ed6f3"
