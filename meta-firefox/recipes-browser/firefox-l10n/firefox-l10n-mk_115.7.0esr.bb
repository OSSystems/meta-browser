# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b8c5ef9feb598ad9aaf5487766c23888"
SRC_URI[sha256sum] = "af05e60e433ce820e3bc275a21ae1fc646ed9ba7dee3d2a614581225581c6ec1"
