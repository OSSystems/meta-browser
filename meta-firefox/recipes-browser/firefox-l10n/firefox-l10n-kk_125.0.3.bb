# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "59c8c7df191a3da7d58bd254cd6c2595"
SRC_URI[sha256sum] = "da76a19aef25133e60edc977df3f825c58d3bc7b0c28b0bb3ab7ed78026160bb"
