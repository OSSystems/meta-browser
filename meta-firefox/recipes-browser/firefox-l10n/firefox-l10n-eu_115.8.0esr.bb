# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d74fd87ef814c147744fad370d521629"
SRC_URI[sha256sum] = "7356dddee8b0eda9733e4de57c30a98d8b940e6a009d1609fcf225febfcd9e26"
