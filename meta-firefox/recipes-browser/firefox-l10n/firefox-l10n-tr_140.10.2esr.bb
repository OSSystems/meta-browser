# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7dfc3034534844f994b8fa239da1ddbaa5888a9610c9fbb196305ae5e1f5c3a1"
