# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "268c22da417130dd46f296d738688b40"
SRC_URI[sha256sum] = "f70fd1a925a12d738bac3d1308983db99f7740eca9d7e41d872aabf3436cf6ef"
