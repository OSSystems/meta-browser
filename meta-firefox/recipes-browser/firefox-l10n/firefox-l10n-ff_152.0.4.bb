# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "4b0243d2c501b79da62c099bc4a180ef855118b6b194f11d57b5f5a80e38005e"
