# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "afa74ab1cbdecacfba5146dac5017671"
SRC_URI[sha256sum] = "04c8eda91d363aacbfb75099ee4d2de7f3c1fef554b749ce6f39c6d24bf9a8ef"
