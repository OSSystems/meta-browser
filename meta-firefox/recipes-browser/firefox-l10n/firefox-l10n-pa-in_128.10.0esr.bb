# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db35c9b4a1650535af1d5fabc5e358c1"
SRC_URI[sha256sum] = "e014b2b16dc07b739956c0a245fb1a84af3db75592f81decb141c2e9c250d31b"
