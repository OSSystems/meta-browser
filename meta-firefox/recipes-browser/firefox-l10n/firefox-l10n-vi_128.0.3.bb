# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e8e51851bafb49bb37d6933332e31b28"
SRC_URI[sha256sum] = "323c1d2e1a88da5a4b185eea17908598bfd25673aec6db1c869cc425578e88d6"
