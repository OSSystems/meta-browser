# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0192edd611e159f94977cea98a446d66"
SRC_URI[sha256sum] = "d437d94513290af9e6d66dd4230b0914dd58a3ba612dc01f3cc84da6fd5bfd17"
