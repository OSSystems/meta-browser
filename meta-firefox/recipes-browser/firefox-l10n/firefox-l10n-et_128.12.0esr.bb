# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a545401f04137504913ef987f0cf1b5c"
SRC_URI[sha256sum] = "05e981530eafe9d5962c212a81f9e358ef1cefecfdf2bb388f12e204e917efc6"
