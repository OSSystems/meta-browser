# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0866ca1f7974499b9959dabbfb8a63b0"
SRC_URI[sha256sum] = "583e653c998e0508e0c44bdc55c148c27b0e5e908dbd1f182d59a7569c9ca917"
