# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fb09c105b37b27ca276989d206550f14"
SRC_URI[sha256sum] = "d980d9ff7a63d90259216935f570f0e7f110793abfba96e3e1caa18d54a7e744"
