# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "034ac0bb157781ac4e5837daef7e97fb"
SRC_URI[sha256sum] = "fa25fedc065fcfb945af4e7093963e4c5a4144177ed8b62a70b7f0ac0b0aedb1"
