# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "67a16cbecd9f7af0b492692da9a092dc"
SRC_URI[sha256sum] = "6746bc3b06a239b4b9a98974151c5bf2bd26222fcbf77970dbb89544e9ed81a1"
