# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ae39390bd5bdb9d16bd75e2c2270c12b"
SRC_URI[sha256sum] = "091af72b4f00fee92d5befbd00b65f658eda8b35e6bcfea5817aae956f3fd3c1"
