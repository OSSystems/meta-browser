# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4a345e3c21fbcc9fbb5f0928b311e409"
SRC_URI[sha256sum] = "06e1a523ab3e577ee2245f32defb50d07c237d98033ce017879b2921e3ecd093"
