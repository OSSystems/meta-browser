# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9107c3b456792bdf7f140ffc3a8df6f6"
SRC_URI[sha256sum] = "85c31fa884a38571a24ad7fff8701cb30a1351767c6bf0ded5811dd9b15a8b9e"
