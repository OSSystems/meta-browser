# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f63e031045060967d2a862cff9d110fd"
SRC_URI[sha256sum] = "bffc42f87a78184fbca2082529794400035214a381a16cb6850020af7631f2e2"
