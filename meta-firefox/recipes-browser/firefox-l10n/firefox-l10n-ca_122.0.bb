# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a1c2eda2879c00b1e3fdb38707c854c7"
SRC_URI[sha256sum] = "ec152ca87745fe4c38f642dd0c918b2543c99189f1fa6688723625bae1174ac1"
