# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "641a88d431e3ce43e6a49d73d6caa6b7"
SRC_URI[sha256sum] = "82d94982560d4fa4b4a5d83325c48b727d26412bedb2cca8da482cbd3e15c33e"
