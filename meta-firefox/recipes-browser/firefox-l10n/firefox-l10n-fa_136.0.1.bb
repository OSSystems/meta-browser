# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f2b3f1dc13627af57256b3825cfc83fa"
SRC_URI[sha256sum] = "230d0e5c4233ec1b082668a74795d83383b03716273ce4805d310c39247d3bda"
