# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "684b12796ab3a309ce36e8420afdc179"
SRC_URI[sha256sum] = "8c80a80c6dc10e8bd6d906d01c84f9da53d00eec888e8ba68cbc4b54a735d7e2"
