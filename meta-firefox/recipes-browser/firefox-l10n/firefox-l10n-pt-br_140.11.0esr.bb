# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2f0081be50dd3a91a84051a3b9f5b8cc6563ed87a34c26d595d808e81bde4345"
