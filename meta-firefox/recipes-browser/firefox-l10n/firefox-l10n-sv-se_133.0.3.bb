# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "43a5e78308eb7b7bad60a3d466711810"
SRC_URI[sha256sum] = "8d850a2e3faf89a5e6dc8b494fdcaabcaa28298a3a2d8a88070b4d11dc1707d1"
