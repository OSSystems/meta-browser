# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c1e201d31409a7b13810303ce79c2234"
SRC_URI[sha256sum] = "98ce5c7a1065ad1be0dcfd28e32f20a87539bf840e1b1047adacda241536d5bd"
