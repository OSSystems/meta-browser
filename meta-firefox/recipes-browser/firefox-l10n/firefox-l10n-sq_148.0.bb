# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c132d8eec6ce4c73a7a8b8c7817a2851"
SRC_URI[sha256sum] = "d7778b58a9c86b935d70bd803270f290ddcb24a9a42cb14b7b8eee3bf03a4840"
