# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "573e2d6dca9f82be1c482ed4a2a465cd"
SRC_URI[sha256sum] = "e691c72950cfc1ccebf0a16040bbc3c48e8639421ef47ec12ed0447cb48d5eb3"
