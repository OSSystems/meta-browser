# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "62f4da8e5d1fe45df8f01bcbb58ce4b6"
SRC_URI[sha256sum] = "8b87a5cdde238d217b196cb349a5f99d15ae38465fc82b759c7eb9c70a0778a2"
