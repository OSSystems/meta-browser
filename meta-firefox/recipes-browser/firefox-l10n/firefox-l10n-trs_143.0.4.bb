# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "06ccd8ba502814a002bd119e0b7ce81b"
SRC_URI[sha256sum] = "d6b7148d71432bb2549931240c3ef289a59a1bc758284375654f5ebcf20a52f6"
