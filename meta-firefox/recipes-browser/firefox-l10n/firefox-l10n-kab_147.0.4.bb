# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7864665fe93f59cceee144cabf7c883c"
SRC_URI[sha256sum] = "2377af7acea39d956b633c3053240c62b2972e3627a007107f7db35f0e84a540"
