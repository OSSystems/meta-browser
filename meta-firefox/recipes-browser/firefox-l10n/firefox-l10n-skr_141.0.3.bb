# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c566d69addcf4c1978f2a05e6de52833"
SRC_URI[sha256sum] = "acf2f8e5f0e46555373daebbc61476f90e34a2dbb6be0186cc4a9fcb5aefb8bc"
