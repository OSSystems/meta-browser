# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "71df19692e6d778d4d1f476c67b3a242"
SRC_URI[sha256sum] = "30be6bae76e6aee9ce27a041a1faef5831e597ca7e17aa8d839db62eb24781d6"
