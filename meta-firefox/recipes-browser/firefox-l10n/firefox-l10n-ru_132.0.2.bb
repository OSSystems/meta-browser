# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a9f6beacf082f09b83d4b82fee94c023"
SRC_URI[sha256sum] = "c186b77cc48bb53d64db65c0aa892c9dbd1a00ec1a0eeb1fb9f23e4080c0750e"
