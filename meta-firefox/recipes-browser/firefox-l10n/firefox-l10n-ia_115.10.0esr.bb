# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "706265c6d61542437ca2924f8ebc7800"
SRC_URI[sha256sum] = "dde41e556149c5b1df4841440a0c97c90a8922dc77e8794f9e9dd07df79c3f95"
