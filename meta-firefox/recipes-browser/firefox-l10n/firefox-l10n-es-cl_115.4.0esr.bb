# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a0d3c7a3c76240cd032c358ed1d29039"
SRC_URI[sha256sum] = "245b60630af2b514020ed978e7b9c280d2ce26a20fb3a610683b5f2a577d074a"
