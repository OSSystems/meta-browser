# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7f7b44bd9768720782e1217e914f44b8"
SRC_URI[sha256sum] = "cb6773a4e26877cd4181fbf604a4a40941820281cb1110b73c3ca104a6fa8509"
