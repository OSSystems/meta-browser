# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "359a26079d8998716f0aff650bbe13c4"
SRC_URI[sha256sum] = "42fdbafb48c3f9f267e9a6b41104122d588c270862bfa1dc794a9d4adfc93263"
