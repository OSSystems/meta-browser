# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f53a30560aa4d320db383ca4729fafbb"
SRC_URI[sha256sum] = "c922b939a4921fb5a02a1ed15c88381370b0db3e12e58497a6df59fb02fd3225"
