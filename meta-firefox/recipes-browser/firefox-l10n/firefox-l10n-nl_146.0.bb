# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "705ba17157d5fbb9fc3d9533616d7f98"
SRC_URI[sha256sum] = "a057a3d45069c524de2296cf60288298faec16a593c1dbd4edf1b2a037f3bc81"
