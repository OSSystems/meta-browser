# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4b7c35796c8cbe0230e2cdc113d5a076"
SRC_URI[sha256sum] = "b08047d64a8f479871390082ef06fbae46275b95926b6c40d8ea5c350d6d29ab"
