# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "f824ca4f82cadf141304ba7d69f52852c7a255d6a1a1935ef969668c1008252b"
