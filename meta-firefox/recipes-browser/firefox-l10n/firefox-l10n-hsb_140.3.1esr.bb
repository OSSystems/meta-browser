# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "98dd413f7133b8957a1b0b4be015a8bf"
SRC_URI[sha256sum] = "b585aa96c1a0812ad5a58872f9044e3bbad3683840cbe7239b7951b20ea7790d"
