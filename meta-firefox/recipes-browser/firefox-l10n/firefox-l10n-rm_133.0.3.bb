# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fb79c864e2bdc2c3773ff6dde65432aa"
SRC_URI[sha256sum] = "3af823abd1c36c67a435a52cbee5f72062998d4fc02fb67a674449bbe72988b5"
