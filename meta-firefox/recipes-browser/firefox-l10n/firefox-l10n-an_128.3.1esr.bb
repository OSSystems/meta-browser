# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a0754ae87620b386154f5dba6ab6d3ad"
SRC_URI[sha256sum] = "c101476d94639d9f40fab19012e53161c8b908c981eba4b61409451de871cd0f"
