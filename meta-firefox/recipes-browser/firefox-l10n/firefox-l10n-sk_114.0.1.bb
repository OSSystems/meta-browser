# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dcbb64a2774298c08ad40b26759ed96d"
SRC_URI[sha256sum] = "21a4ba2655e0eb2974309f00e5c1cccabb0b40d9e0491d10a4087a4f85053a9d"
