# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "186c5cb31216818c49a89b58f46bff05"
SRC_URI[sha256sum] = "53aa4f662763da3830bbacd486430b5e48e09d9e26017950ec54135469577680"
