# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fbb6c3c7f032696120a1f333d1595fee"
SRC_URI[sha256sum] = "7933fddf854783d51ad9950301e5230a74151f53446c2243c204a8cd68f5afe6"
