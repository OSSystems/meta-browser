# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "b6764650aaaa0197bc7c6ed70aa495c1cf826862278528ac8ccea2a78895c33a"
