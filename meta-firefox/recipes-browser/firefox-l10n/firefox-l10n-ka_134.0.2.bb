# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "17eaa2bc6faf60b089036545ee704eb7"
SRC_URI[sha256sum] = "900125685d29a9c16af801c1e4433164b8fad6e51e6ead6fd9f943da23298823"
