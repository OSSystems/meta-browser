# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7e4a2d0efcf377d5903162177a103c67"
SRC_URI[sha256sum] = "5caa89c5fe0185bd28fab5b40867dd036de5bf22d79b42ff3ee66e6770475bcf"
