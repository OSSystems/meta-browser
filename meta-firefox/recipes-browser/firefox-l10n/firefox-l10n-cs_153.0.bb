# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d3efb57e9d4389c1f4af2f3c629c51845873aafad6cb71ea683ab6b7ecddef4a"
