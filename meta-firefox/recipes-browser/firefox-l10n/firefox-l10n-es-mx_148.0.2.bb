# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4aa3a16c4f896ab53bf1601c4e8e1312"
SRC_URI[sha256sum] = "6bef64cd20359710fcb39dc17bb1bb776611ac069992c9e189093e698ebadc61"
