# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2921d8ce1dcc42d8fcbbac4907cf1420"
SRC_URI[sha256sum] = "ee29d099cc15c093d6d3da96f191e5b6caad12f9fbb422727a963860fe48ef90"
