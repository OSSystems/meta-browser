# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a6c705e25a7fb2e87da5545b5e037709"
SRC_URI[sha256sum] = "797b1a5e376db20659be25af2283cedd545ad3c3c5e27d8ba6d3bf233a481157"
