# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "55dd5edfbbc80d1b484ad7a79a14b918"
SRC_URI[sha256sum] = "db17d2025ed285fbb8f2a61cf15fb6f8c7c86bd0631180e94d140e58be11959d"
