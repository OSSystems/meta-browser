# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2347b8ad3629a0c0ff6b28d10319e285"
SRC_URI[sha256sum] = "6225a944ef28b21ef27d69c6cec650cdcc15f5b783bf5f497cab278d41f9be0c"
