# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "27a658b9a7dd072adf7267e64f37447f"
SRC_URI[sha256sum] = "9dc305ebff9159ed6ddea7686f155d551af7d587d1ae07c0dd3609f9efee9a99"
