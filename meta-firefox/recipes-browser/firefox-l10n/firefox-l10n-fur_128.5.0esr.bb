# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fa7336d54851697a8fa1e3f3066418cd"
SRC_URI[sha256sum] = "dbeefd94328f46007fcc268bfded318d345260022bd8c6fcf65bbac7958e6b7f"
