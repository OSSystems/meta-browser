# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bedb5e62c1e4beb6883f13c59041c28c"
SRC_URI[sha256sum] = "f5f6826be7d98edfe7926dc3bf8849d1cf0a26207e9c6befc1afb499d703035a"
