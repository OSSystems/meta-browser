# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "45b947b096afd0a3df33c4f9f838f563"
SRC_URI[sha256sum] = "4b88379e65564bd20a6cebad727ddf8fd3854daf17d301f8ccaad1760ca4670d"
