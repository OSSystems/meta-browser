# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "6908e83fc9382163d32edaf0aa7c41abf59112cb66a2679f5fbf086532de5bb8"
