# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4136c507e86e3c8e84a2b41a177bc4ae"
SRC_URI[sha256sum] = "bf69d92e6ddedb81be90626161c2d56d18585215a5eeaf9875163c1fa9da7c3f"
