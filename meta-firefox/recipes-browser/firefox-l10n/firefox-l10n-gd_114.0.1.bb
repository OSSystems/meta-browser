# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "751978cef2768469f23e18effbaacdb1"
SRC_URI[sha256sum] = "7e2b9d53e0aebdc9a986cd319d23fd09b7a6b93274a8a074d8bdca219c1f6719"
