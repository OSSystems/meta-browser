# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "19667f45974a20dcf50aacb561ab020f"
SRC_URI[sha256sum] = "179f65be3044a0510f829e4af8ef4a3fa51b82e3a355bbb1097631f72d881baa"
