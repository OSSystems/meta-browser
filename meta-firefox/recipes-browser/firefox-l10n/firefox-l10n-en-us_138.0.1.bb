# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f3be9790b9f2400d7bcee03a0cd96eda"
SRC_URI[sha256sum] = "5bef37ca2d4aee2a28ef8a0a3f94de399e34bdb4f54fcf8a8605f017b63c36b2"
