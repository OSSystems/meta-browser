# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f85f78d1cbe4b15cd1b2a5fc6847b615"
SRC_URI[sha256sum] = "c354c90ae2bd737206087f0eb082e439f5ce96c983787b4e0a207508fa53d1ee"
