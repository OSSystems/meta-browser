# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fcd9fc4b9b51a967d8c2b6d316feef6a"
SRC_URI[sha256sum] = "39c45cba8134c94c84b6cd70a7b24bd309f2f367fcfca29dbf93fa36e111b0b0"
