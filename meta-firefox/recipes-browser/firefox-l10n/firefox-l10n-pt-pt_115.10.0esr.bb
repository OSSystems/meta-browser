# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e5229d7bb2b96a417187bde206a3092c"
SRC_URI[sha256sum] = "a9cf68b2ebf3c96a55d6425794821602ad7be4c0dd3c710c56a635da0df39689"
