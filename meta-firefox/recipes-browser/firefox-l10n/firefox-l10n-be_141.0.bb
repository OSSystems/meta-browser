# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9e8b0879f9e9dc0913657db93bbe9452"
SRC_URI[sha256sum] = "2381ab42e0a6637bcc17f05fe9c9eded525374a8f68bdfa9d03d9d5a2d78e620"
