# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "03113a594330d0d6eb77dc6240393803"
SRC_URI[sha256sum] = "99180072a2bd96f183f700fba635570be577f49ec2dac7d3e58d597abb2e0108"
