# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e0fe5a39e9817398c9d8feebcc0380f4"
SRC_URI[sha256sum] = "ebc3df2d869bfcd33c581cc75990563c06a41a279ebd2efd32c6c13b5b7f0ebd"
