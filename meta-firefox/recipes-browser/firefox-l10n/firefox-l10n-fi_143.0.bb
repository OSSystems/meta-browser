# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d85a2145e1589f4ed3f224dbe75bc8ba"
SRC_URI[sha256sum] = "548c14d4c8b66ebcaa86e293fccdcb044382e8e01c18b49138a3f93e84762ac4"
