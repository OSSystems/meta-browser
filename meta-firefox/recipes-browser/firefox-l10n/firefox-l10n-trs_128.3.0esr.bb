# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "df2bc470e33036726c4bac7ce6039b6d"
SRC_URI[sha256sum] = "165f1bea55fba8d189ed1c07874bd2994b23f5544ae83a2760a2b159fc2a0675"
