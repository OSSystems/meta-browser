# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dede4392ec2c65a98272422b3f9b92fc"
SRC_URI[sha256sum] = "068968182323253f08335ef5d1f3ff8bab4a31cb93996e397c072b969e503c9d"
