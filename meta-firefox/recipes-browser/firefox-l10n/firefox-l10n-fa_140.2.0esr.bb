# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7d8e9d5e6793df5c000efc0b09a31923"
SRC_URI[sha256sum] = "b4f14f38e1137bcc51f0dd60927e8ced62b0e19b137e75ed810541f4b839308e"
