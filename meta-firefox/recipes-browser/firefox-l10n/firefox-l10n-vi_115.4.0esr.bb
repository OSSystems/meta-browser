# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d17ff621bd357b1f4e4a5f0ee2a57342"
SRC_URI[sha256sum] = "6b75d0f36509c52c0cbd719c10172d7fe60c7e50a414715400befc66ac5b68e0"
