# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "62e2069df37fc848d328bbdd3a9ee863"
SRC_URI[sha256sum] = "2c741e227512a6307fe8f23f25c71a2d43f612181b748aa53c9e3fa13d437422"
