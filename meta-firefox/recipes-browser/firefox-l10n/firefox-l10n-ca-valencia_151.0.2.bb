# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d9d9c0637e902725672fcf9e057178d6b8a8fb6ad86044f16a07d50974303cc4"
