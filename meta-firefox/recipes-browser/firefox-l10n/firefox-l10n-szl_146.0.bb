# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b914a9a458421398d96fcc78e761275e"
SRC_URI[sha256sum] = "48688f911566719d1cfe1b9c2e56990daaad81e6444e8afbe2c750ed7d4cdff0"
