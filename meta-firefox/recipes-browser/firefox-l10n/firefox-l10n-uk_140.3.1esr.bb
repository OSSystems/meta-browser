# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9dc6640a0327f7eaaed4b00768783980"
SRC_URI[sha256sum] = "c661e041c5ea72315b5aa6f4ed805a650f4baf7089813fb1b6130466088d1d39"
