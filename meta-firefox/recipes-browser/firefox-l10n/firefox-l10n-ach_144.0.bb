# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fbaf1cb2c2da856f35669c30e04ece3c"
SRC_URI[sha256sum] = "ac4baf6ad7d380c0594e7f6d0e2830f14aa3573239315a45bdb0346ab072ffc5"
