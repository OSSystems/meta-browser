# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "619db66009f7464d7e966398c73efff225809cce135b7fbd451cc019923a7a45"
