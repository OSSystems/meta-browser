# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7a07357dc6a303ec45ad2eee62d7406a"
SRC_URI[sha256sum] = "485db7030a519edd80339e9e9e0660055254640991f51aaa32e38f8d9175bef8"
