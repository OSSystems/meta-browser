# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "817f5f2fda3b341a1f19b7bf196fbe58"
SRC_URI[sha256sum] = "7bedb38a299094b693c6b7c429564dd2f2d02f1c94e3bf836dec411320274322"
