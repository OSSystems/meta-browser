# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "852a46d8ea9c7dc9317ffe87d34b4f82"
SRC_URI[sha256sum] = "c0f11bc98350e49c01be888a2125d608b3bb75127dd9f1767e5e58c7b2215000"
