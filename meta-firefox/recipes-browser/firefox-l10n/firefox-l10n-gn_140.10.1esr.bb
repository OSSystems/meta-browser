# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "30d2afea647642218d5f9173cf4727833d6f0f6e7303a0e51889dc29bad6cc9f"
