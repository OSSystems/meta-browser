# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bee42501205d9f6cf281ed257f288be4"
SRC_URI[sha256sum] = "a5fa539bb322690d4bc65a81923bf276f51affb7b90cf02bed7a5f685d5e6f3a"
