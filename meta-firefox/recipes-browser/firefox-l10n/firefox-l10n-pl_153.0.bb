# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "cae008c7b3290fa9e301ff29ea0afab07f1c61769be381be60668214595773a9"
