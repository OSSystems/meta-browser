# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b014c560dcf17bfe7cb6b82d5b426740"
SRC_URI[sha256sum] = "a4c531fc51a9f966dc12eba2734e8d26df3ccf87c9da3a6d9f972a7dca938dd8"
