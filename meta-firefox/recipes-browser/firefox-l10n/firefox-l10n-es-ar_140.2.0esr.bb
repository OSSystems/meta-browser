# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f0626870fa555f41622a77358ec05c7a"
SRC_URI[sha256sum] = "9d50096699354e6ece5722009d932908f873bde507daf5ea83592e9da566aed7"
