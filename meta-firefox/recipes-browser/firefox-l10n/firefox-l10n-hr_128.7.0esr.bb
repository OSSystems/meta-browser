# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a0e72b4e1ea3e81645bc38cc461a5396"
SRC_URI[sha256sum] = "930f449eb23d103fa61a2bd99d93b5d0da467a191216d8eafcbedd6f61c9fe5f"
