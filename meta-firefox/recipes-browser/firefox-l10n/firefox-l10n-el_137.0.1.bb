# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8fd035c4ced4a09f9febf2366828a543"
SRC_URI[sha256sum] = "a4150ce1f824b25cb441eee5873655087b79955cd9aa7e15594b3be55c8f0bdf"
