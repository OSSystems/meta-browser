# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6d0157d1e5ad2b329690fbfc8de10feb"
SRC_URI[sha256sum] = "cea82a785798b83a6dded25d2462b03de6b713e629b4d65b81dbe7686af9ed1a"
