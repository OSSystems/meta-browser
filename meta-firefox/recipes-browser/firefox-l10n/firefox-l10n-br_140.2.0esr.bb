# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a21771d9d7ecc08ff781e82955e68f81"
SRC_URI[sha256sum] = "fccb1efed19d745c2e5ff5f23fb665b194045d75d9ccbfea3193065ba47bc04c"
