# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ff6bcadfeb9d429da92bdd5a8dc4ea14"
SRC_URI[sha256sum] = "347378ad6ec5bf5b178cf82967298887e66b2c339faec609aaf4e29df736459f"
