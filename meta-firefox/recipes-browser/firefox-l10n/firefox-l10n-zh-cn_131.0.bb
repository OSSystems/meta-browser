# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "688e278bb67993b54df40594f42fae3f"
SRC_URI[sha256sum] = "7e37450b571773347df757dff14f173b8bc522d5463d6f4d32b9215d9870ef53"
