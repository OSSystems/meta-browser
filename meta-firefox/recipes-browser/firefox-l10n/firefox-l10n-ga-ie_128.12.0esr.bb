# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "785758876a278a8f508c1bc306311002"
SRC_URI[sha256sum] = "f643a233932a0da7c1e68e6c5136b72670e692fc5b6f1e33849ea3f56e744f11"
