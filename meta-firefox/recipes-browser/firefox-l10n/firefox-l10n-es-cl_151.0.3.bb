# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "5e5d1cd89297327394ab9e68cb5a747db8ea0573f2a18a8ad40aeb0e71beff60"
