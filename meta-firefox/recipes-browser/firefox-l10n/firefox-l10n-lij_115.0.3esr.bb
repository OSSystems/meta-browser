# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7583548d540b85fbdb7f850c003f6cf1"
SRC_URI[sha256sum] = "531a91c5926a0f2519c38a0948f7838e335a22608bd807949448b844e0215706"
