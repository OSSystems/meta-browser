# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "67d422ab9334cb3ec33dccfb6eb7680b"
SRC_URI[sha256sum] = "4bcd81ab068638eb3e4bd1231585468466b5e39db5489455ac4aeac9f65b9d51"
