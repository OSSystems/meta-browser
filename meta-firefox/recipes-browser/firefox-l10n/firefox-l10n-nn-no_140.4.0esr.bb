# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a042f9edba3f3681b67a21c6abdc081d"
SRC_URI[sha256sum] = "aab28994d9f03fc46c9380bd175bcd89968190bf673dea39d8a53a834473f809"
