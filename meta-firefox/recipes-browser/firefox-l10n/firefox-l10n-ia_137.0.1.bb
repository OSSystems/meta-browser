# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b6ad9280beb0ed61aef887f24992dc01"
SRC_URI[sha256sum] = "5f9ba57347fcafa5184236a37cce3e1e3439ca69fb883b2ea5e7384c57339d97"
