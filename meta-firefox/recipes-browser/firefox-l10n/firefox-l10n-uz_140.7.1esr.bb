# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f2bf9493a0b38079c3121a996139189a"
SRC_URI[sha256sum] = "f1a87971bb90b2e9221c3243edc5fafae882235bc321a4f14b806beef2a003fe"
