# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "97c3ff481fa24d751a48cae5c14539e0"
SRC_URI[sha256sum] = "d35e6a6353400a5afe3751c23e938e01496d5b91da17bb11e32d274d0ebdf372"
