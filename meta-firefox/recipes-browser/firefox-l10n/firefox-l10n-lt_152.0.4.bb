# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "15cbadaac31c1b75e612f860eda6f604169d37502c053db3ed25142247d44bf8"
