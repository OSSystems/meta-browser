# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "506a8de13f532d21d7462d435c3da085"
SRC_URI[sha256sum] = "6e48efc4ee206e439e51976cd58d4d22d5cd6195f333c7ecd9b214a1dc5b612e"
