# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "852c0e10a048dfb364dce156843d04e3"
SRC_URI[sha256sum] = "c837bc79d3b2cd045b0e804d633dd5f9e0f593866ec033c66594502fe864095e"
