# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "32831f70aa921878ce94dfb131902998"
SRC_URI[sha256sum] = "df034219ef3fdbd539f84504f6f97fdcc92ceb8d8e3ac8dae0386bc0b6698f22"
