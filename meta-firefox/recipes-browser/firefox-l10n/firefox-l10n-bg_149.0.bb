# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0e5a22c888c551f194f1e567b3b4244a"
SRC_URI[sha256sum] = "492e62c40087f0f470336803dc67b013fc19149aba91e35428b6fa4ccea7f400"
