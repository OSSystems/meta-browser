# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ad00f5d8b311fe2a68acf221b4553383"
SRC_URI[sha256sum] = "bab997fa9c59a5e371490cfeb02598f4c712eb0e2fae86275e5b1feaf09e34fe"
