# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cbea19077551c959c50ef1ed7d8cc599"
SRC_URI[sha256sum] = "e1455a8ddc13c36b31c272ae531014b99c0458c244a007d864cb63792d20f8e2"
