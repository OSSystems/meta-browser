# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "214e66b0c56810a1f4dee44541048e36b67af828d571aac0606845a109050aad"
