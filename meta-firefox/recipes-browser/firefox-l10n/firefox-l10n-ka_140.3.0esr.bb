# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7b0872f2ef31aa3b487ff6d4aaf8f15a"
SRC_URI[sha256sum] = "37a828131fa65d86626b3f757d7e7cff4d67741a92a652b313e1a46343275c91"
