# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "5e1048479119e7f8f6750a421c245ad825c9698cda6183c125571ca686b3a3e4"
