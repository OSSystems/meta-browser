# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "59e32067ef0776c0966958ac27ad46b6"
SRC_URI[sha256sum] = "3dfa6387d13ced19aa900e221c91f3b09c780dd2458c1fee4481fa9c890be912"
