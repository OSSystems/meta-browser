# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "992c538531cac6cc8833ab9933c7037e"
SRC_URI[sha256sum] = "7e39186d1ef6db3e4021011ef773589a8bf32ef320db84330406ee0f78c02b8d"
