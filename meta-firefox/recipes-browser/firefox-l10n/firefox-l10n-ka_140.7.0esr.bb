# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4b9982c4ca9db3584a9f22548fa37cc1"
SRC_URI[sha256sum] = "3715c3f6d9f3e7bdc02db3113bf90f147a02b1a696e66398b5d945d5d7f2c680"
