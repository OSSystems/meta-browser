# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6f3dfd65dd8401bed10566132f227e41"
SRC_URI[sha256sum] = "f1bd71921576cd6992855520246c76a22ce79ca4281b3c0d0450046cdf1d5bd6"
