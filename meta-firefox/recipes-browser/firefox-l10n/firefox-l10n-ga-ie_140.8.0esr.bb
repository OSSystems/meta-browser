# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fa1ecdcd0194e3fb6fa0b084a5820dcf"
SRC_URI[sha256sum] = "e1e61680102b39e50ac58a848e75bed13ee7ef2691b4869b07d0268bad516c74"
