# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c03c7b28fffa77e3bbde5fd0212f3e71"
SRC_URI[sha256sum] = "59a00112683eadfdcf0ce315968ba64e79e11197cd04ad4047039a567207ec3b"
