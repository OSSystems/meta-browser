# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "76ba75f7efface98df8f915ce2edfb2095aa533f0a564c262166de09f5d3fa4c"
