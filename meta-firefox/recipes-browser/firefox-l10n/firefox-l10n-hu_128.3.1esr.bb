# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9a2b1094c706476fad3b25860c5010c7"
SRC_URI[sha256sum] = "c94db8c3a440c4cfd416b058c620263f17e34de62b35661390ab78cdd92ab064"
