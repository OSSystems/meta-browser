# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "441f538e69799b04d285d0d7ebcdb5d7"
SRC_URI[sha256sum] = "8ca90326beaf95bdf986a9f7d514cb1936ebdb1e2a7fe03e4ab85c0792ed2620"
