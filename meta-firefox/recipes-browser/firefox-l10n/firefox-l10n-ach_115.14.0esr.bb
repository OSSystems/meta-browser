# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7c983f26749d07990a39364fdda7af8b"
SRC_URI[sha256sum] = "f989bfdf313cb2a47ae5bcb356ac9c4fa502fdac29631d74fabf930f45c8aa20"
