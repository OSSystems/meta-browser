# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6d0ac50a99692bf1c2bc5f0c5134cc23"
SRC_URI[sha256sum] = "8ca71a1f9cadd60199f3f9dc1559249be15c54fc4b48049d1fb88793f6fd41ed"
