# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2b8ea4fe52bab63ce44a8681e9c89d7b"
SRC_URI[sha256sum] = "dd26163b29a2b5c2b187d00b846c02839f041b54e462486cc24e902a5a57534a"
