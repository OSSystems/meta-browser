# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fbc614cad3723a706c24baf68b15c799"
SRC_URI[sha256sum] = "01361775c9c25eef394bb52845e683f8cc48e76de83c66fbf9077b510b9e659e"
