# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4d30a1f22b12a0e96edc72c0262a643f"
SRC_URI[sha256sum] = "13d8d6cebe24a11c0f719529fb02edc7594fbf4800c41618fda83f4ae3a2e4fc"
