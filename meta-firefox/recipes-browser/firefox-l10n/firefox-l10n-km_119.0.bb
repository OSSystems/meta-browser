# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "09c083fa4c976fe0b2d8b54ed81a48b7"
SRC_URI[sha256sum] = "1a9a262b367eb4c097ce5cdaaad34781992c6f1075ef66c1d82a6f40d07f936f"
