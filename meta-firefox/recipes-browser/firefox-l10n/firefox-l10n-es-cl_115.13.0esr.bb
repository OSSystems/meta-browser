# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ef58e3172b1feeccf5e277c229c95ebf"
SRC_URI[sha256sum] = "c4e292f5c6f189bd6d1bd1bca9443be79821eabfaa907ffadee6ed65db84ee57"
