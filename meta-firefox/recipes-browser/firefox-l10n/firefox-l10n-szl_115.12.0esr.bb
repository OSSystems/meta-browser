# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "85d89ca9fc004e69ffaadf1ed119868c"
SRC_URI[sha256sum] = "b3f36af6c0b0872b6b11514ce58d834e1c1d05a74de8d1fb241adda7cd0009cc"
