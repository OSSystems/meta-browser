# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "04654038a557a586491b4bf0912ea5b9"
SRC_URI[sha256sum] = "90b16260bc2b4701298969daf527aab236f4ac4685d2b63cb889ad86424539f9"
