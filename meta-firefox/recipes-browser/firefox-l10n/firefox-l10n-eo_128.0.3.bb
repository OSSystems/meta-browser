# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9cdaacfef23061b5e8888e2fda004f0a"
SRC_URI[sha256sum] = "00217b6573a6e19a60af9b1578e68415d2c561a087bdc1abd0c111c89284b4c5"
