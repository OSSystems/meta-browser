# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7e2c4716e499739fe93b18c78908768b"
SRC_URI[sha256sum] = "917b89100785c880de413661e17801f7377979bac56f92af86726297217384fe"
