# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ccf46261c7e94df8045689399c074107"
SRC_URI[sha256sum] = "1774e5757303e18fcf201c3c15ce4300aa0762e015d6102dd8b5e2d6bd2c8acc"
