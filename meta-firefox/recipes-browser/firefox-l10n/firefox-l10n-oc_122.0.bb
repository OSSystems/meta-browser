# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cca7ccbc4af170b7caf8b9c835ed0c9d"
SRC_URI[sha256sum] = "672ff11a03da1b1a3a4f28c33e13eb13c7e77ecf8b25227992c5fb6d4415be9f"
