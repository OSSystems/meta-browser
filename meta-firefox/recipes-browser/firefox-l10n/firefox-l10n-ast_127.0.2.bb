# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e1002c6c4fdbefc791978019856d75de"
SRC_URI[sha256sum] = "9610cf76e21cce2a7e8077df31c01056d931abcdc5f41f3ae75c5673e5f476ca"
