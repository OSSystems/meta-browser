# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "fda2ccd813848cd1af50fdafdcd51fd9bafec80e473815f65b9d90073433199c"
