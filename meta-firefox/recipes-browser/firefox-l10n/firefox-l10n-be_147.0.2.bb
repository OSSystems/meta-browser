# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5bf0daebbd8a4bd8847a128f58cb6207"
SRC_URI[sha256sum] = "d4d1e08d8272eca3e545192b4ac5b526a41823849ec4b2e6f3717238a20d662e"
