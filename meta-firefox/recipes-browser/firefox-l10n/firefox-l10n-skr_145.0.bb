# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6eebf5c8450456774cfe35b92b8f6bc3"
SRC_URI[sha256sum] = "71f58e9133662bc03a8ee474d78195a884c3be1e068d9f87795e9035d5f27fc7"
