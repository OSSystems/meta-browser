# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ad18261ac4d5cb5e39085d910c2c6fec"
SRC_URI[sha256sum] = "2b52b9bbcab069ac4eb5523e2b062ffdf22e9797bddc254bcd12b53d58cfe388"
