# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "51c3375444321cb46fb5eac539ffd5a4"
SRC_URI[sha256sum] = "557ac113477da6102897cff19e419d0114c397d782bd0aa300cd33c672d21e36"
