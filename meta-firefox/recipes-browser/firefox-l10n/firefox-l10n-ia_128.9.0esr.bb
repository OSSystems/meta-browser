# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cfdd80d03833ed2a312e21f174ebab9e"
SRC_URI[sha256sum] = "bfebb756c2750d75b9e452cd874f8f94abc7b7d445c373e6edbd017eadf7e7a4"
