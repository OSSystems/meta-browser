# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "117bc4d1097e5fea1414adc8f6381481"
SRC_URI[sha256sum] = "b62b650b749d584305dbb1c5b22737de2b89267565c8d56c966c919090765bd1"
