# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1cee62c23a4c45c81350f7b36ddc4c22"
SRC_URI[sha256sum] = "a693b049bae17140642307b5d25c1122cc11b5fe48c66aa0a9c5197bf0263c66"
