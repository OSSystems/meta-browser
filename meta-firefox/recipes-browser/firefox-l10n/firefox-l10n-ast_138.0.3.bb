# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7694b4b2e923b0c6aefcc61dc5db1c94"
SRC_URI[sha256sum] = "a66f66351c552b71c61207d7c823931ef456c5f35a779df385647a9854b956fe"
