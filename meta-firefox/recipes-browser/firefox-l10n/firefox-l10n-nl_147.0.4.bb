# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e1d245be0e755622fd7c68bf4e5a78c6"
SRC_URI[sha256sum] = "6b06430179c5c9f9a51631ba88e3fec52f57ced7ef4b42fb9268088a5c101490"
