# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1cef9c1d4f8fe0b338aa42804bc562c1"
SRC_URI[sha256sum] = "71d335ea239931733ef9e60b36430937ccbc0a05bca614740b477dfdc8523064"
