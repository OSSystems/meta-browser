# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "904ccc5b6ab9b6926a8e453c230b126b"
SRC_URI[sha256sum] = "06f52c8bfa81201433369235043bdaa5db7c24902f2c667a95c4327689476e90"
