# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e683274a7bdaed690e1c644d3ea98e67"
SRC_URI[sha256sum] = "ac0394b3ba8a21185b00109dde8d1f4a7138abf683f99474a53b6524d9487857"
