# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a33bd55cffb67548d984988daee7de3a"
SRC_URI[sha256sum] = "47acf0ec630d2af07efb214e8125068c689f878f658fd3cc8956cb5a83b48252"
