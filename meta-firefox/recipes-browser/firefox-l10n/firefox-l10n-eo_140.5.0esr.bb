# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ddede7259de49896da44705ff6f62be"
SRC_URI[sha256sum] = "86f02435bf969133b575b2c6a7699b70c084a1c892764b1e475d43daaca09380"
