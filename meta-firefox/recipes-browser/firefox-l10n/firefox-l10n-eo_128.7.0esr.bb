# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f2fa9db2dd6f2ce747ce9d9e2fa688fd"
SRC_URI[sha256sum] = "d863acf93187666b1b96aac19705e73537e8b1ad24b30e82819fbc27a43eb523"
