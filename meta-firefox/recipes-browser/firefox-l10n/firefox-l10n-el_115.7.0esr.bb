# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "06e700741545c78faea6389b4dcc9c25"
SRC_URI[sha256sum] = "dc2e4e489be12f7a676c9bf5424ec6bc79cdb5e18ea6475f4c206cceb68c0e27"
