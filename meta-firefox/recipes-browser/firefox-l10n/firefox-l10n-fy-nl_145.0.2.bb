# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "539cfedf3afc6ebe7536a049c850d526"
SRC_URI[sha256sum] = "47b4f55cb8b2a4bee47758a4e13d801524278c48d21d6cace418781da895bdea"
