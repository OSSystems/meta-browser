# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9f14438f2cce452e17e9f957fb72221c"
SRC_URI[sha256sum] = "89a5631c0f959c7dc54c31bb64d0c0edaeca061692cba9fb24832906b37331d1"
