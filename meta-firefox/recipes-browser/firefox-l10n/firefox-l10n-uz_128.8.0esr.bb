# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8f93006d28fc92e608c7991af455217a"
SRC_URI[sha256sum] = "b9eb9daef054c96bac4ac32d0b195c057c6a4b11ebe4adc3f01090a3e7d154f0"
