# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7da27e87e7a2933873b3d3977b0559a6"
SRC_URI[sha256sum] = "c7bca97b5ad3ed6a3094e787b38912363fbd79fab72b596a79759f8fa983bc57"
