# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d19abf2dace05f51b7ff02eb0f87cde7"
SRC_URI[sha256sum] = "896f7e064b20f1e4ff6cef44ca951587ba8beafeed08a74e6f4b0fc32feff172"
