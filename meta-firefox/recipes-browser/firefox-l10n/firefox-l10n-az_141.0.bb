# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "21bfa6d770ef4faadfd4eda099d2c611"
SRC_URI[sha256sum] = "b80b1a62e5ee012b28dca6783b2bde30783687616df545126f88fe48027dcedc"
