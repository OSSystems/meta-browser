# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dc9fc0bedc779ea0d128639c70e85793"
SRC_URI[sha256sum] = "667c7b871e8d8bd7182509e10210a489ca9cdad0df34c038e285afdf9984d411"
