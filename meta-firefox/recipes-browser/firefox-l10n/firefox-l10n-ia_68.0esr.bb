# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f807c18b274286729ace2db9dc4b605a"
SRC_URI[sha256sum] = "488e71277038dbb9e43d0c656d41fb9b9247992378ef7ae11529e2cccc271200"
