# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7703729b5d4d9c44f0c57b0e7819af450b93109a406fcb6c3ed9dd1c117f791c"
