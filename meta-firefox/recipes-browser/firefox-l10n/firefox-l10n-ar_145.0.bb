# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "34b192d63cfd2541c38ef204e4c0a7ad"
SRC_URI[sha256sum] = "75797f05fabc6cafc5f023f9c7ea38c6edcb66b222c1fa132637045797cc0b10"
