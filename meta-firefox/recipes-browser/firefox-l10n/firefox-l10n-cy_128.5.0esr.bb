# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0171fac6f7a56ceb5449ccd62e4da092"
SRC_URI[sha256sum] = "4f77af95e53082871bf766dba5a2f453b861e2987a3b49a0c4b485cfbd7e1167"
