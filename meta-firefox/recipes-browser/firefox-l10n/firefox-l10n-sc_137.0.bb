# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0f2d385ce1a1ab85b8c4ea974876da51"
SRC_URI[sha256sum] = "610dc47e6300c92b117177fa8d1db6615ae0749f5b305ffe2066fb68afa6968e"
