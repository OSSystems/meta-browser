# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9b2dd6281f6c27affc16300af56c4e8d"
SRC_URI[sha256sum] = "a65c4be8c5164c8f6c505589a94870726455909fd6268f55b98659b2aba55ec0"
