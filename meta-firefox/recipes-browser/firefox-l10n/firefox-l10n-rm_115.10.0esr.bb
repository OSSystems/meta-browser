# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e781359acb8734350710f604b18e52ce"
SRC_URI[sha256sum] = "f3d8144aae2ce33b07de9b56f1285ff3cfc75c196c61f3179e9ca5b904df2ee2"
