# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "490dcbce524027d3b7d4dc7eb47073b8"
SRC_URI[sha256sum] = "f0f0fd603c224867324269bd426b431e2c608833b9eb4a5eea244f1189019864"
