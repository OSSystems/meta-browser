# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5a44c7f0d755c64bed70a2f0ec1894f8"
SRC_URI[sha256sum] = "e05111434e91cda14b41db7d61c7304c6b03b38c4974fadbc3ae1bc8e4ef8653"
