# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fa49f59135810c775dd37a8d3affb372"
SRC_URI[sha256sum] = "de2c49b7207df67e5ade30803e0e118ad41fa8beb61c544fe25a2b993a64769c"
