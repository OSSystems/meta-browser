# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a97176e18b293e24b7883c5edb8e8fd2"
SRC_URI[sha256sum] = "147b4570be7ee3525761312a3047b5c59f95360c809eebffd3ebbc1d1ae27a79"
