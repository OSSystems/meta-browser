# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eee0e10e38b0857ad585d28c659b7475"
SRC_URI[sha256sum] = "b18fe4d6486df6af4787c565555894876fcbe96f0c0a82682112b13e5273f21b"
