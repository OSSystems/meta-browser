# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1a766d8615b7b101268837520a98e34c"
SRC_URI[sha256sum] = "33ffaef3b90b1f2afb1049ff0f539c5d2edcdcea28d08f28fae242162a92cba1"
