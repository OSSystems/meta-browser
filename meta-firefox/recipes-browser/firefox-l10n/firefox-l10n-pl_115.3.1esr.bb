# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1ecd133c1aa8567f87b07bb4ff0e912f"
SRC_URI[sha256sum] = "43963f67764d526888239bcb8b758d5ecf3fa3bcea32c5b6e38e3f89806e3da3"
