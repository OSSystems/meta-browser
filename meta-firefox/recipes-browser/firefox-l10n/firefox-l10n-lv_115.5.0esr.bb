# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "63cec0613730d20ebe1927ee1523de88"
SRC_URI[sha256sum] = "9c7e8fdd3fdc796851805cfebcf63e1a8c2dc907151d14ea28d571de5c083340"
