# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3f2101f2fc5cdef8206530e7700dc6cf"
SRC_URI[sha256sum] = "77c16f1177dd5b26e36bc4845afb30ae050917875a809b589aa4d4fcfec1260a"
