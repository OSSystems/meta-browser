# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "8d150e7305c4028afc1fe71eb76624c6f2262d4237ee7a45828e8d5560db89cb"
