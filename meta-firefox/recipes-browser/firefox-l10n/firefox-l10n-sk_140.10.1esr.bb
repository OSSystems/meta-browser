# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "1fd319c14c7e3bf7c51ad633d45dd54e4593f632e71cd93f395a8be8a5a26cca"
