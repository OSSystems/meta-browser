# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "abf9f63d457df0b18c8c6ca0815cf3a3"
SRC_URI[sha256sum] = "6530eee73d98e272d1ac1e714a6588079371e181f67d99088b8aae5506314aca"
