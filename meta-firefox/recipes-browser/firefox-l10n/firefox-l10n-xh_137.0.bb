# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cc31625da6367544e308dfbf0e3dec08"
SRC_URI[sha256sum] = "bcd4136832fbd999c15ab3ca19feee57d64d8fa1ccc1cc940af252446b7ee2c7"
