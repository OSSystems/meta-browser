# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "456af4fb384c0cf4608558004d1e5362"
SRC_URI[sha256sum] = "033f8ea943bcf5a9890c3159a11df22723c441656b6ea73dee64f4ca90fe564b"
