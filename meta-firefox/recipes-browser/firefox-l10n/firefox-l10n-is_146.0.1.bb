# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d008a8bcf22795a1977197df71b126b6"
SRC_URI[sha256sum] = "cbafbd2ee6bd3807871c156be8948b0a1e040a8adb9153e3110d7782ef6b479e"
