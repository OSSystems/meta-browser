# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f6f5af19c4a39ff29eb6e1e90dba15e6"
SRC_URI[sha256sum] = "d4369bd84c97d28d030f373bac7ca2874c8a6df93cbed3e2241c6d437e6c98dd"
