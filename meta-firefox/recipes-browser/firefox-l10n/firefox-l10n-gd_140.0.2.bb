# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "84d8fde9a6d67bcb8947cf0eefa35c3a"
SRC_URI[sha256sum] = "ae015136867821bcc5429728f866bca0bbd1f5d5d479115c5ab7c8e508c5f388"
