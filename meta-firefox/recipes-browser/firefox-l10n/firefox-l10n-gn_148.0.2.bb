# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dd6d899d25edb228c887938c1d8694e1"
SRC_URI[sha256sum] = "b476bf020331801026142133f855c99b1fcc33dd6a6e506cca64f5412cef20fe"
