# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ab1efc6aa7022c56bf32fbb31ccbe80f"
SRC_URI[sha256sum] = "a858976e9895a2ef5568e4bd4d2c08193d24ceff1f6aa958c4b4494ecc33a6fb"
