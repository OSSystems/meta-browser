# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "822cb6f3afd6b4f6d28663dd28a06426"
SRC_URI[sha256sum] = "e7f824561b1b5dfd8d4822a38e91e7ca104299d66b8c98064567c20cfdb5ef24"
