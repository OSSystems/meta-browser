# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5adaeb7b74bc8d5230fd9b080216191f"
SRC_URI[sha256sum] = "27543c345a1933513377cf6120f8f7da50795d3e600b3b83abb9ae708c39c7e3"
