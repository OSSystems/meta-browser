# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f6122b3fd20e6d0dcf00a29977b00b8e"
SRC_URI[sha256sum] = "e9e04f846d9f98a7d2352b4a9fb0d2c782dd853d9a423b1e546ee2c90e27376c"
