# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b664c391478d94f519121261d059c6eb"
SRC_URI[sha256sum] = "7fcf206c83e004f0c4afcf4636e6e73033af2e03895438933e79b810be3bbe21"
