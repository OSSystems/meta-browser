# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ff0a7f30193bcd007b1d9c96fc734ff"
SRC_URI[sha256sum] = "febc66cf4f678e4eca9a76260a35ad3b27c7858a9b05b33875c6b723cd43aaf0"
