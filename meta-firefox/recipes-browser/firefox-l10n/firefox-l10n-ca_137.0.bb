# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6bf999af1ca7ca74dbbc5b952b860b74"
SRC_URI[sha256sum] = "22db0a45fe91ed3a95780ea9ea1c4225e2daf9e2b0e9db40733e6b0eb99ef254"
