# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0157ac4dc5fb7fe425b5e396a56d591e"
SRC_URI[sha256sum] = "f67b064554735a1cf8e97ce09d865f0798c40a2395238e921222b971eef217b2"
