# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "daffc0fc3e8ff1d6eb22751ea21d5618"
SRC_URI[sha256sum] = "1042e3681825a1848a2a1454115851015bea960a0024587a37a64d562ca54ef2"
