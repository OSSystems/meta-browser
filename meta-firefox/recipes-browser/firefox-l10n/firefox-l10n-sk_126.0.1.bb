# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "68cd7303fe44afc84aea0b71a81ab5b5"
SRC_URI[sha256sum] = "79e199d63b068c001701fdef8f17243d48da72dc8bf663a8e72a2d37b8535edc"
