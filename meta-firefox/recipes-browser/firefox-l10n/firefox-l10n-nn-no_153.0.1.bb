# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "5fff4b88912d7eb67fc7e6913e9430de2adac7c2f4ff7a3415459477ab094fb8"
