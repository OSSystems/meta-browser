# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9b09f6bb5b5640431c4d305e7772a79d"
SRC_URI[sha256sum] = "f0ea93666e1e97a18f7fc2e01d1ef74c3c0bdb1ce4be667f7f671905fea46d75"
