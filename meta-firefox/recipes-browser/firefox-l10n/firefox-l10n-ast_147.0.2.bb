# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "203c365b51291a2006e7a0f464d8e2da"
SRC_URI[sha256sum] = "fc26b1510101a934732a6fb6784090a3b2535dbcb7297cc5d67b7d9f2b8fff8b"
