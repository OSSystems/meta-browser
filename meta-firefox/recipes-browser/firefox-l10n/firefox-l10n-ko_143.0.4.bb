# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2a608bf28cfde8a7cd137f2554951152"
SRC_URI[sha256sum] = "9c26d18331e78512c903ba7a499503ca848022b280787c03aeab62dcb6a8fe21"
