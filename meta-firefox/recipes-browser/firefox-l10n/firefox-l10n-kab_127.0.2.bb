# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4cde5c5f8a615dfd5aee1d2884a1ca3c"
SRC_URI[sha256sum] = "221b8f1910de65da25a8fe001e0a1206d3b679fbf4d4dc9dc1fe51974139e671"
