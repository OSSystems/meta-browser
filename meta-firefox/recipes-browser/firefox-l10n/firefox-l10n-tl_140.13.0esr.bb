# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "213bd96773bd6f99caa4a1f4c74a6eda1c0d30696ec3438aa62453d2873f3887"
