# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "03df55a029e528d4a925065f9ec87ca1"
SRC_URI[sha256sum] = "59846e929e0e888e3e361fe13a9a155e430076643d9cd6b0cfefe69fca0a7454"
