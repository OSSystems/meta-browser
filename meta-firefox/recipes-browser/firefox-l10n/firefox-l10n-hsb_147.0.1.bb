# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6dc1ed7ed0843b223cd8fdf20aa67295"
SRC_URI[sha256sum] = "9eb22ef48fbdaf117f7f8883e619143951ace0eb01e23b4386c012c2bf1a8b69"
