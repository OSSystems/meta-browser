# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cbe78395e9d62e8f460d77c9eba85dc2"
SRC_URI[sha256sum] = "2e1be1b47cd715a9b12a0fba23878e253cc6179618ecc3304a78f27613ebc091"
