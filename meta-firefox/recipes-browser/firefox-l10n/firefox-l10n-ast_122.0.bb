# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1eeb035c948627c5abad696a2efe9f86"
SRC_URI[sha256sum] = "29fedd9730af1a9cd5b7b3b5f1016599cb8909aaa8171cb27a20e020ef9263ad"
