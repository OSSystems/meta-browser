# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "deca0e6d142e1334198ab78018721dd4"
SRC_URI[sha256sum] = "6e27804ec2465ad3ede8d9d3af804a5ce9ac9c6ecb9f3aa8aaef20912b88f393"
