# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b23029b88966f0524a1be78d4786e8c8"
SRC_URI[sha256sum] = "a8ba9f01985386b9dbf5324fc49168e82af1e7fb13e4f9753c336c33dd512434"
