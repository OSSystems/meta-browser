# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "252f27221052e5a6141c9d6e556d1982"
SRC_URI[sha256sum] = "5db2efeff18d0f5273bdc2f27eec12adfd7e661e30ae3b64c79011e8fd404276"
