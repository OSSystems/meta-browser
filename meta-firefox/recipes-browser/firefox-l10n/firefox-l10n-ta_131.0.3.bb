# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6dd86b6a278ad6d66fe622d5fdd5160e"
SRC_URI[sha256sum] = "7da36d928168b9bc4bd2504cdb37443a3bd880c00a8a6b6fad9537c20590da9c"
