# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6aa92acfc5c5e44bdd8bf816fcbca5e2"
SRC_URI[sha256sum] = "45cf9326214757645ecef9475891997226e79e7b006ee56d73467e9c8ff4997b"
