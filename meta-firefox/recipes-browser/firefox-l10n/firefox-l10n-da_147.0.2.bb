# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "24038262e15008483d8c4c71e8e4faea"
SRC_URI[sha256sum] = "1f1c5decee6f790e6a49b316df6bef6344c4e02f339acfe1c248c33752858de5"
