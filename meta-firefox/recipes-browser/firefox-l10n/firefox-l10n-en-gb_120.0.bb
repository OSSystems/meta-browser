# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cff14a4e51104c53814da81b944ab1db"
SRC_URI[sha256sum] = "945283e8bd1f2e4963d17e59fc23c0747843611a3ec740f95017df12ac095fd9"
