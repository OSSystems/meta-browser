# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f691797c7b5bdeec12630d2841f9393b"
SRC_URI[sha256sum] = "953fa26ca9f722d75d50431f6b2149d9cfed73a9e8c843091da82705957fd61e"
