# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5a7031d232539484579c822499946b7f"
SRC_URI[sha256sum] = "1b98000d5e5cee063035db15c19393399fce4d3cd9c41043cbc0d2e26e9a15af"
