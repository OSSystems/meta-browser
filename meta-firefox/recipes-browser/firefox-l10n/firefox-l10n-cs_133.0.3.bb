# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bb9b3cfcc99c0e3060312b460f0b81d2"
SRC_URI[sha256sum] = "c2c88427f819bbe75c93a77360987aecfde8c2aa8db9f4c8849f2f44d62d9f6b"
