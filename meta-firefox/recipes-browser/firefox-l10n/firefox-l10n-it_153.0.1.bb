# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "fc5dba1896fd31ef81706c334660ace55d193850d9c951b336f14e7b873c42fe"
