# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "25fa6f34aa016ea86667cc7e456ae5bc"
SRC_URI[sha256sum] = "739d0a87b395e05b37a5b82baea63d85f16dc6ae84c4250dff4de64879b75867"
