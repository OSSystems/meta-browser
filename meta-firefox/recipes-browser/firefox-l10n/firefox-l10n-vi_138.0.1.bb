# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e042e55acd3d0680e96065b418a3e2ee"
SRC_URI[sha256sum] = "ceebdf23808b7a542e5983250ea94119d184c163cfef755f9b4dee44ec48c962"
