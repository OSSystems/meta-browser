# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bdad2cb4643f48cbf440fc0ee7209b2c"
SRC_URI[sha256sum] = "eeb38bfe5eeb22865115a72b205685057e8e3b5e12feccebc5328ebe6b48558c"
