# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e9bfa488526b4e78e73c6302374a1564bfe51f4fdeea30d8601f559a1cc787b2"
