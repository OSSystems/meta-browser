# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "afefe1a2a641aafc15a8357be99ac528f7cd5d0b9ac09bdf129259bf3df5550e"
