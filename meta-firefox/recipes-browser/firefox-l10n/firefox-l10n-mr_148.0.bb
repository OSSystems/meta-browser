# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "75d2ab5b571970cd0f72762dc1e1ca21"
SRC_URI[sha256sum] = "a0ec6cdf48ee9def1d29792f2dd886186c932724a4c8f750e40d8da2ab3b558b"
