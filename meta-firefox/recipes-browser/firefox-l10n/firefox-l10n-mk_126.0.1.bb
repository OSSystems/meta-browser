# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7e36f33e049ed2f29403ab5670260687"
SRC_URI[sha256sum] = "299fa857b669edd2eecac6c71c7e1c134134ed00e54457cb51c08c753f18f179"
