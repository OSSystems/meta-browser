# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d32bbf605e62287a78598ad6341d09e0"
SRC_URI[sha256sum] = "16ded0905a4cdd0ecaf87e5ebc6f73ec536117abecb7797f1998ebb01a59ff4d"
