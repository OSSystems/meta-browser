# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c6179e553f323a0ba673b7f09baa195d"
SRC_URI[sha256sum] = "dcacaf0215be0fd0623c9c67ab8b7d5203eea39be82c8d68b25f69c462808be1"
