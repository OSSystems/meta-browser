# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "92ac8c7079ee3f0bd0ce0a6d69ccf123"
SRC_URI[sha256sum] = "5565a2f51a2db08e58e4c033e6a7007616ebb75f37e2d6dc2eb4de1c9804469c"
