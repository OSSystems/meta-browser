# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4662cd4a6ed0ed23c07b604b95c93fa0"
SRC_URI[sha256sum] = "643fe4116c2df2ac82998bea8104a671ee82b9f4b103a5aade3748a0222661f6"
