# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "55ba73d24de06acdf80f2bab5e2f4a4c"
SRC_URI[sha256sum] = "a9f1dce1d723e569d1a7c2eefe2c8c3d73862fbcffad1f26cbda6a9025649a17"
