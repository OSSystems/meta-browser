# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1ed105f46cccb1548e2c5ee31d85d288"
SRC_URI[sha256sum] = "8e44eb4418d92b3205961d22c1b0150e44a098ac7f22dff6a0d8dcf8d4958cbd"
