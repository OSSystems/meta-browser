# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "243adcd16af3c01c18e67174f9b09def"
SRC_URI[sha256sum] = "2fe5a975573403f410ae2820cf8012081141c027e5c8bbd96b14ed5b72eca31a"
