# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1d273d476f7267581c597171c1e42881"
SRC_URI[sha256sum] = "b84ef813c0e32d523c1ffaa22b9851f2f19d3fb84452b78706c068f92a08b985"
