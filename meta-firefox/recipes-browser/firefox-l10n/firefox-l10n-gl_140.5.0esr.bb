# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c73e5f9071cee17ab0384d9a371cbe1e"
SRC_URI[sha256sum] = "c5d7a49d691015754bcb022a661582702afc08f099356bb1d8a53755a12485ff"
