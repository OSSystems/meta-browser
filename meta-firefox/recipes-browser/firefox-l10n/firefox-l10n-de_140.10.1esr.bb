# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "332f6d45646b0a7615909da92e051c8ef430e5b6d5a9abccab989c05d563d2cc"
