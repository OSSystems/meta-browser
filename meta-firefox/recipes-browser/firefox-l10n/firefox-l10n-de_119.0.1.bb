# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1584d48012837bbb7e2c46c1311b8727"
SRC_URI[sha256sum] = "5d6656e3d2031d3bfa305ca72c8ae6e20e1ba3454e8fdadf1ada8bb2eb085594"
