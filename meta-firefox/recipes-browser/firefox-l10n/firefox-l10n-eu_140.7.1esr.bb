# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "10d828165da922eb87ac67f377bc92a8"
SRC_URI[sha256sum] = "6d7bbf3e58f0c22ec1bc6de71dad3ebd09d3e652595c858495b3e4b06ab86f96"
