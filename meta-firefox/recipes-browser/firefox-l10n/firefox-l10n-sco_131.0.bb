# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5822316df267473795be5fe39397e4da"
SRC_URI[sha256sum] = "879bae69aa32e20c29b61bb8555ba9eb2eeee49ac7b7725c1cfd60e28b2e61f0"
