# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ac8e1fdce321794bac0bcf7946c07c3e"
SRC_URI[sha256sum] = "d5f1df62191e714419ea5f1c803a19fe60e68e8b07271ce3b6a1023fe3883f5d"
