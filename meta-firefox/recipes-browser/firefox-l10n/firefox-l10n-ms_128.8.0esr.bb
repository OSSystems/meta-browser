# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "830f25a352e54764ec9f2dd66acd98b6"
SRC_URI[sha256sum] = "e2e80154e943a45195ed6778ad99d0e06f72e33271fa6399c6962d3cba174c93"
