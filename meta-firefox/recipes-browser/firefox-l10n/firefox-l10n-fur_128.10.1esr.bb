# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "93a9c0fee708a7f76642bd0dbdc2254a"
SRC_URI[sha256sum] = "2f81c4c134f06dcc088576a5a44bd4b767791a16f4bd8357e6bb55c4e869dff8"
