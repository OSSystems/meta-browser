# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3fe3ba68ae012812ea48feca3e8d7ebe"
SRC_URI[sha256sum] = "fd5d281a354671395b8d9a10adf8ea1204aebea88ee8a6cf8909dc172061dac3"
