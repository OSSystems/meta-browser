# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "55e01ffe2e08dbe3f5cdd0ca1ad70edc"
SRC_URI[sha256sum] = "a52a303d4f6dd62c75004feff7ea9ef002efbf42fe85645df291e9ca1e2fb0cc"
