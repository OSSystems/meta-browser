# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9e97de3e16f566f6c56ff339d5cdc17c"
SRC_URI[sha256sum] = "f6e4f94e5d42b1976bcc889444ed1de9da295171131cf204eeda4c5b3da2df1c"
