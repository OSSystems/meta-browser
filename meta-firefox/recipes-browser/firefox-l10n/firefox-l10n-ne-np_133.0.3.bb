# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cd5f056a689ec7b964f5ac29eb818184"
SRC_URI[sha256sum] = "d4bd19f88d8a786b5e560e2cdde4dd7d27d8273512446a2b39e04e29ad5fb425"
