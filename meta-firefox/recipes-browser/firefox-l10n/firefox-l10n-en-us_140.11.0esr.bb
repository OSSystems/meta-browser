# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "178fa165973d9e2d4dc9d8dd9b7268f3b8a9500ccb0c2a57d9282106ee2b23f9"
