# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d3bc127befc4eb0aba125fb18969ce78"
SRC_URI[sha256sum] = "97eb49038f6cc16f4244eb21dfc7aeb86dd22e5069df43a9a8e93f62c0713476"
