# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e7593df002f1df8eabefbf6ada5214cd"
SRC_URI[sha256sum] = "3f95bd0d06c7690cbfe9fcb51cfaa8e9495fa93591079e3c302be64756ac1416"
