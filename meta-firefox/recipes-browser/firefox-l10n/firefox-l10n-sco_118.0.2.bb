# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "963c81ae122946c58f7f90954ada7f4e"
SRC_URI[sha256sum] = "28cb77a1769890d62ec03e98b8265ee9d9817cff56571a10b9ebda19df26150c"
