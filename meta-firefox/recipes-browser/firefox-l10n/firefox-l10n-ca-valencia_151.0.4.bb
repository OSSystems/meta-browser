# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "64a938791919e899b99a992536db1b0272aa9759ea923c2ab552dd207afdac0d"
