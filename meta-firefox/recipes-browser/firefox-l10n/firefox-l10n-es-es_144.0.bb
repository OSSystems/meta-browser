# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "64f43ef412e67e2220fa55b2b21df3a8"
SRC_URI[sha256sum] = "654c3ea6cd8a1ffaa07e57709299f08ad6ecf8d4b607a22dd74b518039ce2fa9"
