# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f66b4c1fe378e071f8c39a6db4a4a5be"
SRC_URI[sha256sum] = "ae2bfea513c78b4560967afbe0ec40d405cbaebc2436af924deedd804ace7105"
