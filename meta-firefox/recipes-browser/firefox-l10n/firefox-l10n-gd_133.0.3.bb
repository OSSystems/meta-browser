# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "189a92f7d70dad329bbabcf856492530"
SRC_URI[sha256sum] = "31e224750c2c995e84336762d705101a7941fa9e2a6d829320f5cdc1a6438cca"
