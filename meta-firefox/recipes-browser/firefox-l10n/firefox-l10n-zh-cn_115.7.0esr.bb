# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e9a44d7cf806e1e8a025a09a0665aca0"
SRC_URI[sha256sum] = "a1f581de3b3471eab4fc23e9601bffdb942bce0061701ae7044b3b72e44c91a4"
