# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "abe195e3f1b6e86bf50fbc94d0db315db4f3d6ff555b2328878840f1a1a247cd"
