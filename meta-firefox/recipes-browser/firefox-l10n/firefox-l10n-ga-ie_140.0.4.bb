# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "99ee0f0d77e1172a255520bad4aff0e9"
SRC_URI[sha256sum] = "f8925fa1c8634eea86fe8135667992908f00aa7e6f97967d7ef0fc76190351f0"
