# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cf694f0821165e314de6028cbed425d3"
SRC_URI[sha256sum] = "ef2aaed0047a41dd19fd46fa52c137ad1ed72610e251bf0f3e4f22e2512d85cf"
