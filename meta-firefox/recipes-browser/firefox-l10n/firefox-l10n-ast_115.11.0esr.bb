# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ae49194449455c2894ce7f1fc7ce2c6"
SRC_URI[sha256sum] = "3a0b969738b823efc09d9330b5ad1f6fb3a8543c0579ec9e57a6717f857db228"
