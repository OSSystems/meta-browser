# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f2156c7246df31ca3419a245c892d473"
SRC_URI[sha256sum] = "4fe1cf5c96da6c5901c5cd8a55449f44555bc3e33c32c4f93b7308971acdd55b"
