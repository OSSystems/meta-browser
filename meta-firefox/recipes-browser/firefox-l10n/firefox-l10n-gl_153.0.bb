# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "bb1d658b2109a88d6fe9289b082be223d0e43cb91eb2e117c68fa8c41c388190"
