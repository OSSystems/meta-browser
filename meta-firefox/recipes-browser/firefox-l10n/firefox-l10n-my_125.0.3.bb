# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "23e0ca5544f239d4d7bb1611adb0a96c"
SRC_URI[sha256sum] = "996deb139dbd1cad6a5200fc7e178ad04ed7bf331e97feab3f297452e2f01648"
