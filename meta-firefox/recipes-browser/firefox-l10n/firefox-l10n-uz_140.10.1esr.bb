# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "8b493035aaa596f6f8d378c328276dd9c6574073ef4d245810178dd47ef1a6b0"
