# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "41f897350ca6854f5d3914066f1c6748"
SRC_URI[sha256sum] = "7c5b5824d04a6085e45cb17c2f47e6fc8dd58b49765cbb09775b56910287b11f"
