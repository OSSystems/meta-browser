# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "de3c1b9754ae1509656b23043fc96200cfa28d7e8c148f5da5ee7689a8e378e9"
