# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b5bb948a31ecfd6c60e42d1476a3e4e9"
SRC_URI[sha256sum] = "0fd3ce2311e6077651c90254f2bd35a76484f12fef28448a82e22be34b849a1c"
