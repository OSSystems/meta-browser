# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f7aa1b2c6888f978a3248e23be410127"
SRC_URI[sha256sum] = "6e530eed49566ec6ec46d52edb64facb9dbf5193fe383aa55a70f4bdddf5b438"
