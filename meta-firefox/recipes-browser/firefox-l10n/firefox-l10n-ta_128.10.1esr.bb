# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e3f60b9daa1bcc4e3c28d12aa72bd3a3"
SRC_URI[sha256sum] = "d8166f1ab6cdf0c72db9b4795cba182733018bd02e540c6ee377bdc52f2b9358"
