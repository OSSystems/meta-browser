# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b3df13de74d1b743f57ec811f6f901bc"
SRC_URI[sha256sum] = "9b77f9653cf6804ef74b11a2f8ab4c9cabd3194b35dbe69fc4af177a558b09d5"
