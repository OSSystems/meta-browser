# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1c82df0c1070038a00d55dcf123d9ed8"
SRC_URI[sha256sum] = "36882b2ec7820e700fb9a81def225958cb12d3e4b8765b4248d710c85d0c8312"
