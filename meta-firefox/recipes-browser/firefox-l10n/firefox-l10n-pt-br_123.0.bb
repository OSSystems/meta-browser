# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "197daebbe691c3bd898686ef957c52b7"
SRC_URI[sha256sum] = "ae33d17b4b9f11ccc0dd4cfbcf1eb6bf724a451c587aca56a060ed3be75fb1f7"
