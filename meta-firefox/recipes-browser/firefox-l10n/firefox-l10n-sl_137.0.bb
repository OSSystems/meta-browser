# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f3f1c2be8e97073a599b71bd6ae41b8b"
SRC_URI[sha256sum] = "859dc9030d6df5418e8ab471331e25823150d2021e9f0113fa5e0cc6500fc047"
