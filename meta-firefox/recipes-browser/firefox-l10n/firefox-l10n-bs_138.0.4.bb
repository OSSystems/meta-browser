# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9e899487351e6eb5ef97bf3f53f87980"
SRC_URI[sha256sum] = "67ecdca03083dde6469259da80f110f23881ae7f54816b7222ea12ab94286e64"
