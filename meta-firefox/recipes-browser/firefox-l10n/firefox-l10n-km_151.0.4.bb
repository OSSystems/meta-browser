# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "cd7fd3531e67748bc686a0dd4069efc46160ccb5d06e3e614a1b5bffd2f9d807"
