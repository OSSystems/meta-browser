# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "6cb67430fbe892c6bbf937b94b736f036d25fa4bc87b48ffc314fa13a8856898"
