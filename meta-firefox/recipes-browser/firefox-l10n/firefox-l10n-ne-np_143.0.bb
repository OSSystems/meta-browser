# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3e9e372e7bb7863f1c2a61062eba6497"
SRC_URI[sha256sum] = "a6b83811aae2d9a28a5241d8b672888eb3954d83b5c53f8bfce26bcf8ac067ad"
