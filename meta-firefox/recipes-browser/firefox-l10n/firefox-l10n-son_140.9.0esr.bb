# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "699b37301f10c1c6b4241e12721fabf6"
SRC_URI[sha256sum] = "0dc9f4a53e21d25ce14af3c861230e0716936f64e1b8b7ad49e2c82fc18cc5ac"
