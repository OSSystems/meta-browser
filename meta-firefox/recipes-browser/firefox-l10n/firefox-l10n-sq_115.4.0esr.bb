# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0e0348da763149def58872c5366aabe0"
SRC_URI[sha256sum] = "292129f3f8a33f83bd5eb058b999636a267146f9c0fbe874fa29c78014a456a2"
