# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cc70eeac45b8adfa44ab30be86e46010"
SRC_URI[sha256sum] = "2c3cd6e56b9fa05ae2359e528a8be7fc4304e306f890f83874c88073031e4d4f"
