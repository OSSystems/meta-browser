# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8265201bd74e492ca23ded942f16c1c5"
SRC_URI[sha256sum] = "9db0e8514c06330fe8c1d008b178675db669891dfeb4a186b969d0acea5e83c9"
