# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "cfc77165cfffe92007de4d05ad4c45ad0bef38aa8ce7e92655f4f1e87a309ee5"
