# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b7a2b2218fadb8cb2d7b8a242ad7d23f"
SRC_URI[sha256sum] = "84a96793392968572f8d962f1a80dc35c70b9751c87c55840ed2577d378ffc9f"
