# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d95737ff79d3aff62358ad9857ba9112"
SRC_URI[sha256sum] = "387732e029ad3271370c6a25428bff4b1591cfbc74207e74bdb437de4fef6afd"
