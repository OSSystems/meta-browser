# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "317058d2676fc20fc60b25019c7626dbc16b693cb813468c94a63ec7ac35d2ea"
