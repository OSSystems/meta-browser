# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "90d9bca070c35ed6f483a4748b6644b3"
SRC_URI[sha256sum] = "2ae34519439a55b6d4428d477b71648a36169d42f7555adc2fcc57198a85ee6e"
