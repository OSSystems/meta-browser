# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1efbe2e95b38639ed53d97c6a3cf8c15"
SRC_URI[sha256sum] = "48370d76d005e63a7d68be853ab3cf14f392b0d67af391429479a0d2c13f6d00"
