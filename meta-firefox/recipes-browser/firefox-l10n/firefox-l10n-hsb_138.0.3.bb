# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a2564b2bd9803aaa40c74e247c1fbd9a"
SRC_URI[sha256sum] = "6afdfe9d94984ab81e6e7a25a4498b7275def70425aa97d99b5ff059e97323b6"
