# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "50e568fb1d26d3e2b3eef5fc0dc8962f"
SRC_URI[sha256sum] = "8c07aa1c425c4bf6c4809ead1ec86cb6e44f2bac60f1b307e7e8996d52e31721"
