# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "17b661d0f637b7315e6a1ea03f2fbc8d"
SRC_URI[sha256sum] = "c8833d38c797e8337db09f2b1974d248adc8b21294f02f3eef7c6c6d43e73a0e"
