# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2e9f700f02d86ff4b2e5ff852e66b98e87a0f3c693346e016ae3346f41ce2484"
