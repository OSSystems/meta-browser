# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "41b0a765ab2b6e374e1c048f5e8750b8"
SRC_URI[sha256sum] = "8b4c86e24566683513d4e800dd49b7a184363cbbd810939bb58ce6c932caa375"
