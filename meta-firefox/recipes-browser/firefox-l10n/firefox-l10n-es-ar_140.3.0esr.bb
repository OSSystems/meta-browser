# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7c1bd7be2552774dfa8bf20badd07d62"
SRC_URI[sha256sum] = "5064c695205e41b1b8fe250dab2546bba7e8af72f267dd61b10d068951cff241"
