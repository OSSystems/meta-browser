# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f86312db55f8ccf3bbd5fbd690614edd"
SRC_URI[sha256sum] = "07bf4f190966a165f8b25dc744c2eaf7d7515af906cdb0a6f0366c40c7ba3e53"
