# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "51aa0ddf6adfc8a75143efa303b7b947"
SRC_URI[sha256sum] = "8cb190236dc8e332b66ebf4316caacc7f8b011fd4a39324acd72ae920be82a30"
