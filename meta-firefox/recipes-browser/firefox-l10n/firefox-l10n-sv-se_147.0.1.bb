# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f6ff3a35c52835999323c60df821d425"
SRC_URI[sha256sum] = "c34df05a55623f11810b4e891b66a061bb45f2b0c0db30d167599f6d2b4518f7"
