# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0fd8712fb948c03c808a891b16b6f08a"
SRC_URI[sha256sum] = "c656fd24b474151d59e8f2677df0d9e8d9d5930f48778d94cb396510162f7510"
