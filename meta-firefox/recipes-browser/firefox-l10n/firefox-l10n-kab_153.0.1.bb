# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "de738aef95931cb451b3edbda0c55c20b6b5063b9a6b727efa24d20e193a2bf4"
