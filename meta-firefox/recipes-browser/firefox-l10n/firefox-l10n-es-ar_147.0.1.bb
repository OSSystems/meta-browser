# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "df039a1037142cc4cb994a1492318be1"
SRC_URI[sha256sum] = "66329ab0879b4541e2a61b53505021cc607e99f3a15cb6436dfcb80508fe9eb4"
