# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "11d59b241d375ebc7fbb4dceaaf26064"
SRC_URI[sha256sum] = "aa2752afba88507a59b2ed755be3be89bbcdc1227aa309803ef2e16c3e3889fb"
