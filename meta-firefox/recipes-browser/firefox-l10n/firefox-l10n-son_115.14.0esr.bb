# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5d713f724894510afe7fac7437f7acac"
SRC_URI[sha256sum] = "2f5c366c3ab1df4e674029e2fa1f31a0844efbca64a66ce382aef4e47f060e2f"
