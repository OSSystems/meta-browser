# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "6de1aa555bf017946e1ef6b0ad4ccd1a5cb5cda4d2eeacbab3e620eac457c2b4"
