# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9be8fbd9077da08a98301f228cd3e575"
SRC_URI[sha256sum] = "06541652bce54ad0be869ec8b09e3dbc63fdce556e2398063477ff2957993ef9"
