# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f196ec9f97a77f74f9b5ab3e44ca27fc"
SRC_URI[sha256sum] = "45f45eeab983c1e8dee0e716e34db4c571adb573e0403af1cfdc64f4e879f416"
