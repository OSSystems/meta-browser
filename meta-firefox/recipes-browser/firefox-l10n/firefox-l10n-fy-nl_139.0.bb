# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "38f78816dda66d217d5bd5162a3d1935"
SRC_URI[sha256sum] = "f234b217d924972a0844a3c05a985032ca140f6d3ab291117a11e10e98ce3425"
