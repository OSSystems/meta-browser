# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e42c972f7859b5af1b633010f485913a"
SRC_URI[sha256sum] = "cea7772340a33cef7ff8f92b8be4c163f0bbe0bb333544fae4bd0b82e374f4ac"
