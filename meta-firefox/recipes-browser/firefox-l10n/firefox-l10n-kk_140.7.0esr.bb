# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "691758ade15f6bcf4286c8f57faf53b1"
SRC_URI[sha256sum] = "bfd254bc4b7d51f5e539c3316626f4cce94afef115a4d7bdeb50e385db212623"
