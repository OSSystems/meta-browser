# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "386a9bd2421183741400738c9dc4ec1e"
SRC_URI[sha256sum] = "8b8565b48ff4ddc657a7df6003905eb85e62e5d4d262db8d482632f2f27ac511"
