# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ae406ebf090182c6551d2e1d3dffacba"
SRC_URI[sha256sum] = "65291242ed6205f49cb752b263131ee262861eea5dff673454759e3bfd2542d2"
