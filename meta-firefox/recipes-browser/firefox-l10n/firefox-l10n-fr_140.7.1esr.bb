# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c20a9cdb149d9153f9b0f38b46519d57"
SRC_URI[sha256sum] = "8be64619512eee7e0e7d65212127490f3f7a6a2631ce683df4de33c3ac09a221"
