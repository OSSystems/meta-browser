# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "93c028553dbb69d8511c63ec43d0d5df"
SRC_URI[sha256sum] = "cbd4f60a2d1af94b9830a0c95a89a4f2a4ed46ff644e1872704acd1e04e73dca"
