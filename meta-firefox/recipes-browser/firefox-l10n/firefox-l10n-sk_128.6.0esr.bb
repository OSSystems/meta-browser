# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d6ad6cba71e2e23745de646af7be704c"
SRC_URI[sha256sum] = "d8bd6b032382d9dd153eb231c3cc1b75f0ae1249723ff837ec7e383f66020926"
