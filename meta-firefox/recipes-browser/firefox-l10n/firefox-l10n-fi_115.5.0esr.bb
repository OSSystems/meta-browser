# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b8af1bd10725b155fe871ee22b29cb4b"
SRC_URI[sha256sum] = "c67bfce2c9f5f39453a97b4cb39c84f8b39c9c0eebb751c792d1d8c07b517ef4"
