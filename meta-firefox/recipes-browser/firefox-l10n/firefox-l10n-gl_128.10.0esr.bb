# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ee5072b6dbfd396020a598186622321e"
SRC_URI[sha256sum] = "2d3ae7fcd1483cbe7e3467f28e0a5c1049fa28fa18398edf4554c7379b0d0760"
