# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9d5222de75090b9226573d9ea988e4c6"
SRC_URI[sha256sum] = "869873b0f69ab3e68c341d14357795bfb2f4a8ca942c7a1143b4df0f6675ae19"
