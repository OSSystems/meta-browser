# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fa4cb7a71bee0b44b111e9f401e1352f"
SRC_URI[sha256sum] = "8e19f03dcf07dd1d312eeec648602c259167b269ff9a3ee8626c28d5629a8bac"
