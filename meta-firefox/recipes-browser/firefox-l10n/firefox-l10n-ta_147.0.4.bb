# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2aef0a50eb6cd8bdf43fba7756913e27"
SRC_URI[sha256sum] = "bfa7d9d9b36620e3449b0233ccb847068d0d4ea81174f6b9acca61ce7d4b3041"
