# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a42fa7f29f8d18b90e1722a4bdbe29dd"
SRC_URI[sha256sum] = "e267de7debbb300356273de972b2b0ccbbdaa6601af9c8e9988c9e1762cac1c5"
