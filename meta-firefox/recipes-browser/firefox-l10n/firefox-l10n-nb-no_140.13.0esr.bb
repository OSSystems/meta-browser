# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e27817e90d8b26d123ce9930fe53d1880a7f1c2558120ec40260208d28cafffb"
