# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "617f32d7d623dc480de63c5299073e2a"
SRC_URI[sha256sum] = "4e2ca352c53ba9bf50cb2af4986f6f045687ed4fb0f807877bffca6a45793d7e"
