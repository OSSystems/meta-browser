# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4513f1642a2e6fd488f30184cfc59977"
SRC_URI[sha256sum] = "1a01fdac7b0a3a5654a7673001f455ff8c59864dfd7aa4d10e87a86d80cc5738"
