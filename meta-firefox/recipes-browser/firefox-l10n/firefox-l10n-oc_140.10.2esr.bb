# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "cdc895945158e58af682151bd71e178b37edfeda32f788ced03c2c0f2671e4cd"
