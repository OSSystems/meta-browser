# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7a3cd7cc1e9a3beafeec0f46a9b1556d"
SRC_URI[sha256sum] = "61e4c1f311c5740286ca1033ba43e6577c5165f60d6395c1222d3a24d4f50c8b"
