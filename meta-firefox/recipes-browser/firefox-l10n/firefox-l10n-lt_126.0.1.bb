# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b862ca5008ac0f30664c03a207f3b149"
SRC_URI[sha256sum] = "a9a06866308e02f51f1a9d87481a4c326f993866477b95ccc596967ec20c546a"
