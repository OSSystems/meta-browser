# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5c6e53f8dfba0359ecfceb11d13956af"
SRC_URI[sha256sum] = "815a5427a74f13ec0d1d7aa3bb87349a31359916929d125f13f3b3148fd287a3"
