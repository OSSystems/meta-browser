# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d505e48ef337e18ed579faad113c39f8"
SRC_URI[sha256sum] = "61e1cef8c7074e7d95cd54b1653ea9acd0fd9d5cbe317eceefc23d82448ba10e"
