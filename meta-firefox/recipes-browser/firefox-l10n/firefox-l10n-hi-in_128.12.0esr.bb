# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ed634ab1441c22a9a4516f122c141b69"
SRC_URI[sha256sum] = "7c668a4a2f82f62b2b4d9baa60312e123613ef33b151e090f4923245829e987c"
