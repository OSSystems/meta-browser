# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6e4a8dbfa9b17cea2293da04bfe1f0bc"
SRC_URI[sha256sum] = "95807088da7a5616dbe76ac30526f4fabd34958c4e5606fc7c3cdc13239d5f52"
