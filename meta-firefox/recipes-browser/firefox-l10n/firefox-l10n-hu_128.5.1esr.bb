# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d6f2750a660c60b3b4ffb0c0f97b6f71"
SRC_URI[sha256sum] = "eb7ac7ccdb4db704b26a54f6fa35562542a5ca943cd49ec5b634ee8e7d30f639"
