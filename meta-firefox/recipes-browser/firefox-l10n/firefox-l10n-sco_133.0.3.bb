# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fd8eacaae330ac92b5f7d877b27a1121"
SRC_URI[sha256sum] = "0fdaa51dade4f47f629a330451ebd7108efc4671cb76abd713e78a5bfa9fae5d"
