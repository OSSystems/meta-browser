# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a39ef0b687b5adf5e252e9ade3e7cb28"
SRC_URI[sha256sum] = "f203e3393c3fbb2b1fe896de5c638bf49a0580d6eb24a130012f2a531a4ba58b"
