# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7bf7c4a9398d83379af1684047c0c76a"
SRC_URI[sha256sum] = "03510873e53cecf58fa46b89abb2c4e114c74370500f5d225c9b19e7513578b8"
