# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0ea25a7c8f359cdf95c3fd0ebd74ee6d"
SRC_URI[sha256sum] = "a44dbea2c081fe356e662a0934694d4cd58cd4b01c57daacc177f76983fe9805"
