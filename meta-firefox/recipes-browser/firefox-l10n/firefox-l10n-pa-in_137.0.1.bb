# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cc48c091bad172f6181e634ec11a95ed"
SRC_URI[sha256sum] = "a2490cd6665c9dc96488c861059c40ceb46e24a0d65a43557ac3fc6fb1189df4"
