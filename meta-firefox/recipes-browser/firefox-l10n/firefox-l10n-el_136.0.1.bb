# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "75716cfdbcfef899b7724331233baadf"
SRC_URI[sha256sum] = "7e7d68dd6337ec92f4ebc28b973ebca9e7d8ce7f8f35c5faddd3aa35a9b4bd05"
