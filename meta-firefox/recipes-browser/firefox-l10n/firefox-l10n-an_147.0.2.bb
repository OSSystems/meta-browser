# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e7f6f5984bd621796bcf3c94be77f03c"
SRC_URI[sha256sum] = "824e655a582bedb3e22aab30b3dce83c050afbf356ad20d85f1a6e04444c431e"
