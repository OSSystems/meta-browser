# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "31644a1001e7c8b59ded332c4ade79b6"
SRC_URI[sha256sum] = "2d31fe339c9a479d8106664a264bbe9ecbccae12891fcc29c4a5ad3a6b8c9f2c"
