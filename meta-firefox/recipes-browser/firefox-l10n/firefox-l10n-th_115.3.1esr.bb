# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8d03b46918221c31c077f15cbc347739"
SRC_URI[sha256sum] = "1d91efae95efbcef644576da4cb1d366e31cbc4cc103dd1846c67b4dd0baacc7"
