# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "315d5184854c8cb023300f5f5bb6905be4938850e0bf05d4065076f994801c16"
