# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "0e598eab8089745f0f096a94fd356bc37773d5ce7b4a2a741265c09d12ec4992"
