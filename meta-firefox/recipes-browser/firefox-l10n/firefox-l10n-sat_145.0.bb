# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c5ae749ed6bc13536ff13af46bb6cfbf"
SRC_URI[sha256sum] = "0466e9e36bc4d9f7fd9ab1810c64c59765c09acfa5d4fca29819219a59c3f885"
