# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0ee1a9ffb7c9a4398147a0619eeea0a5"
SRC_URI[sha256sum] = "6724192b7802165911b1d6cec6f34ab98060624c9b21630e5e876eb65780790a"
