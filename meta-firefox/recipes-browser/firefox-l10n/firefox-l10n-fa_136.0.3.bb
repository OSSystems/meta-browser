# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "80a77db860e514cd87d0a7a13614557e"
SRC_URI[sha256sum] = "b28637bf19fa48fc713d71c5b5f3636dba68a75d8ecc4d7c6a8aabe8e5c00f41"
