# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "02b9151d92964436c19f999d155db7ec"
SRC_URI[sha256sum] = "a1a8fb0b431fdba15a651f298af5082ea90e53f50d01a38eafdf6cf209651a84"
