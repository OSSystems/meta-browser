# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d386e5e689efe88d05f8686e55867f43"
SRC_URI[sha256sum] = "61f73f4a72b41ad4ea9c1533f1d0c0fe083d93844af935f0d7f4d9c32e65c5dd"
