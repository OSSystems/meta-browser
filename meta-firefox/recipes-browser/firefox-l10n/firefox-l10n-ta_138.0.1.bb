# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f8761bed65da648aff9987ee630481f9"
SRC_URI[sha256sum] = "c806d6204ad0df75130a66f97349a146348215f7de691ff0db7754a083950e06"
