# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "edaca21173dbfb871a1bff3163914331"
SRC_URI[sha256sum] = "3a622115309b54ac8ad77568c21f18045c8143150d4a35af2d4f08b31426fff3"
