# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2d92d27ed8cea6708572f1120a6b546d"
SRC_URI[sha256sum] = "96233ccdd13c97278652946c44e904af59468b6a75b557d973411580b4671125"
