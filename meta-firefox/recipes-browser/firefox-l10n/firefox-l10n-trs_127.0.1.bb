# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4ec40cbc6a282594e42e39cce3658b77"
SRC_URI[sha256sum] = "c1f77aa3db652c990fbf9c24407e80e075ea8fbfc1325badaedf42d19cadc6bd"
