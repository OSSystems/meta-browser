# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3a418f5956b51146596713d286a52b06"
SRC_URI[sha256sum] = "d6de043603f5a6363d39c50998d143b8a52737f2c71da2a6ebd1be52f8d7116b"
