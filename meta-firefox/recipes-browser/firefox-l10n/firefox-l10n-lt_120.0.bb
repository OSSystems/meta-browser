# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c470fa0b2230c16cd40bc966e54476f8"
SRC_URI[sha256sum] = "4eb7e7b7f76562be63369bb284e1128622e6518874cacbd92f4e07eb9a392f25"
