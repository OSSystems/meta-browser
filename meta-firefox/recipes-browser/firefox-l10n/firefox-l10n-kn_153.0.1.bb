# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d4574cdaf1c7e16d770dcecb6c1400355b90daa4dbe9def2a6d5419a289087ff"
