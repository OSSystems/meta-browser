# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e584cbbbac7a81e03c77e105aacd7fb2"
SRC_URI[sha256sum] = "dd55875c4df73b0fa448e462668b2b672d38bce8dcc7d43d011e1a22fc2a2b9f"
