# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d2543acdcb57d9261d0ef46150516d1149c94cd6283e7b06bd647915ba406d95"
