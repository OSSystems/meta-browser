# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d4f789bd0005d4aaa3e8d398fb21aa8f"
SRC_URI[sha256sum] = "5411210834790cd6b7e37d02f46a1129f74dea8295d8ad6d6a4f5c83897d3d61"
