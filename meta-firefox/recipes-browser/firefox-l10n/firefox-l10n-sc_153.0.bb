# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "0ac6adea330065ea12d9694d3c5e60388fce6c90728bbafa4a1ee20ae46300e2"
