# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6af3ee9fdbae22d7daf5e69152083ad1"
SRC_URI[sha256sum] = "993247de389c5adfd17b9dd18b8585c009fe1cd2c093d37062a92840f4d5c2b7"
