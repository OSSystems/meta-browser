# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5c9604606a11e68be366c1861fcda2a0"
SRC_URI[sha256sum] = "d4ea7815a59d78b317c2932f60f6f7aa6a79445456f00a027c42bed172106235"
