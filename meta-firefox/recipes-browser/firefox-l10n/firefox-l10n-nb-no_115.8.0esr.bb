# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a710c337ad4737195056f5b0b9184cc0"
SRC_URI[sha256sum] = "9d73c7098708885217d45d71191aaaf796743e68fb9916ba25d6e7532a25c101"
