# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1f05f50d3166e282b6be2d38e3f897de"
SRC_URI[sha256sum] = "62c254fe6a57f6a20b6c1b2f90f2ef62a3a1213886bf29b3af8874cdc344447f"
