# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "fb13ecb27cbb183bebe6e3c24c81033926fa55787a246ae20351511e5b5d7cd5"
