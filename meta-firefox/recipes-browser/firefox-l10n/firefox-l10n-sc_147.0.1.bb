# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9b16740238d5b97b2e75947a059d1e6f"
SRC_URI[sha256sum] = "a767daf3d4a1dee78b6878ca216888bac5e68350c5ef1dda9ab59cf136f5c705"
