# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "737b55307228ddb4792f9d851e8de84e"
SRC_URI[sha256sum] = "1e4742db23aeea11cea50f59d5bc5cd065b6899dac35179f5c8ea926ccf12450"
