# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "48f0a8d890b8f768f0e9b59a0eca263a"
SRC_URI[sha256sum] = "00ec27da23cf17c2b24deacea6ae8ad5d8a967d6bc56e7d301a0d1aa07ea5791"
