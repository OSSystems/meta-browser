# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3d1b8f00988765cdfd43e5ffe7977f97cb4bd37b416e81523f2dab19f2704f14"
