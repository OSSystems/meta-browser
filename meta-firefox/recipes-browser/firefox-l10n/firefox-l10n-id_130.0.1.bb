# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9beb4fa0f904e0e922c41b0b02145ddc"
SRC_URI[sha256sum] = "2b3e9e62cf41dec393e9ef040bf3db313434d5b9ff381a8b56e2cc113b8ae9ad"
