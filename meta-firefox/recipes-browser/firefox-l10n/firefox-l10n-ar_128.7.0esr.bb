# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "74abae5bc6472484237c6748cd72a849"
SRC_URI[sha256sum] = "d3e3a04a6737f4518a3133af2a2cdf5027317d97064f2024301bf08d61354042"
