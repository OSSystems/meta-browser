# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4320fac79f08152d75d85a59e7436dd4"
SRC_URI[sha256sum] = "efe724d190ffbdd22d2da4fc923b5ab2a965bd39bfd972e12e2d7353077eeb5c"
