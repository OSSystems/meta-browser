# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b4f3c9a07ec862937305ab7d5e00f2b0"
SRC_URI[sha256sum] = "87c67b1a53f963ce33d51b6177c7d2ac7d0cfd3cd78b6d27dd796fd0ca6e861a"
