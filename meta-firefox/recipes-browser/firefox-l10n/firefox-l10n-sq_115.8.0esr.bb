# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6f1b5fadc75de2398b32574817de15ca"
SRC_URI[sha256sum] = "0a63c2d3f719c5e062326e5f3c187cd5a3a9843c155100b11a6c0c4d72f8c0d6"
