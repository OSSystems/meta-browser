# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "84eaafa2522dd066ff4179d8d30c98de"
SRC_URI[sha256sum] = "5bf71fac979cb2cca0eadc4e78a660ca765041aa905c07b4eacceb5c188610e4"
