# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fb256ee870b426a31e340517265e8b4e"
SRC_URI[sha256sum] = "f0542e5887c0f15478d26da2233b2080c8b3e2c957c5a978ea11a25c8e5f4db1"
