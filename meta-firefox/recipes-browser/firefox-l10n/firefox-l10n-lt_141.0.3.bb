# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eebdc765b6cfde63b6bca48566a7f369"
SRC_URI[sha256sum] = "a7531269260e062c13414433ce8b35e7bdc16cfca0858fcfee95100c75544e84"
