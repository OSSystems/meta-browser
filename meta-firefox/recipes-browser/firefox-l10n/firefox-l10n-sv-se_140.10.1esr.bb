# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "5907df9a4ad2cc184774100b89785c5b55e6f560851ae0c1c6806501fcda32a5"
