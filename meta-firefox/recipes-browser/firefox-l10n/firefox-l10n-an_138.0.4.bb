# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "676768016e754b735323aeb82162b46d"
SRC_URI[sha256sum] = "44fba86352745240f8c3264d0cd368fb595f37e5dd2c181089ed761aa85e7395"
