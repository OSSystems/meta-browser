# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "561c2d13bb67ff7480d88aafe3120574"
SRC_URI[sha256sum] = "fe61d0a5b9da497c00a5e745fa5c05bcc07391c8762b702e71e06c1effc75245"
