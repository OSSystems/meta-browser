# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c95094b32e79243c794b24182e27120a"
SRC_URI[sha256sum] = "c3e20a3bfbd428b48323ab848cda7f59c537c0005bb09427b482474becc5203a"
