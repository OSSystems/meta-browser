# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f4b0d5ebd2a82a804a8d2e425d683edc"
SRC_URI[sha256sum] = "f10ec99b02d930daf4f915dd9600dfc6569695a80a457e5cba58e6ba00d37d19"
