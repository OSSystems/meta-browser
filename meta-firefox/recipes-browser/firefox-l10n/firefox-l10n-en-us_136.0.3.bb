# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ffce06182a6e89f466b6ee335a35ab83"
SRC_URI[sha256sum] = "8f3caffa1f3041639310cdd80121f7ca50e9eed5f52ead2ebc7aca2024f5a293"
