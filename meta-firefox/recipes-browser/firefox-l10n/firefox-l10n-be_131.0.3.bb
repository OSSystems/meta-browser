# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a6d4ddec9772abdcfa303496b6628134"
SRC_URI[sha256sum] = "11960432f9e67ebf0da2e1fb077df27184ad2c1b21a944aa114951f1eb955856"
