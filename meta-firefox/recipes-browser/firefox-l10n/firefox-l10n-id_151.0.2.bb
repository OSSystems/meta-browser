# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "82aefa9d2e77e0d0aa5f253549d8d73d6be9bcda565abfc64ec0fe5ea7d337e3"
