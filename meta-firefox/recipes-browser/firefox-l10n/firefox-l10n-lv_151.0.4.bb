# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "bc6f003b9b3f91b9f15102bbca1529038916d5a1de6c0dfacadaac805a5bcc48"
