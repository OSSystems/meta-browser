# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3210127ec946482ad64b111980d69492"
SRC_URI[sha256sum] = "ea62469b344e6146761fcc44a1d49ee6875d4ec29588946e1ac646fd083a29d3"
