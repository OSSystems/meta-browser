# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1f2e067ae5293b8891a06f76665ee29a"
SRC_URI[sha256sum] = "d2f628786e3420d8384a2d91451c36d1734abe7b9db43d8e90a533d27b82bbf5"
