# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "bfb820c367dd39f57f20c8338faf925b42fb1eae83ca87d56d16792de2c6850a"
