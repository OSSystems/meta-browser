# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "50b583a4b9e4e86bfc7c6249a68b4891"
SRC_URI[sha256sum] = "1c145df016e922c0f2c4947a3b5ba6ac7333b78e48ad33866222458bae9176f2"
