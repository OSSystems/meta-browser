# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1c80b3e90cb1e8994d5b8ea3d07846e2"
SRC_URI[sha256sum] = "e1171da1c9e2dccb26e24c220b4d1232245256e4481c3a540cdec91234182fa5"
