# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8cb7b67c910f6deab7209ddc6b0a4756"
SRC_URI[sha256sum] = "e76f3346dc6a26682427ec6cb61e92f65839164edbb479072497c22ba82a9a8a"
