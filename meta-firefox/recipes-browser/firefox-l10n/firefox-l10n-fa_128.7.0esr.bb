# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5d23bb0203318f7d62759e15da7e172e"
SRC_URI[sha256sum] = "3e4e9cf91b73022be3bc755dfe8f4581f358109e245ffb5121e00e3c60585ad7"
