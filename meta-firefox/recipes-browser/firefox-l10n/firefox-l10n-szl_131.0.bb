# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "91507dd543d913ab46dbd37054c63458"
SRC_URI[sha256sum] = "23653f6c938e3f27c2252f5b8f4fe32e887310bbe0873dca27ab0b668bc9f611"
