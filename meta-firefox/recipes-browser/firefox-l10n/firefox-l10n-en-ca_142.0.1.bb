# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c249715b6506e617d3ab4388ec542a64"
SRC_URI[sha256sum] = "193086f1ba3952ff172d0eec56ee4ce91488b7cc856295f56c4ebc4fd0b629e7"
