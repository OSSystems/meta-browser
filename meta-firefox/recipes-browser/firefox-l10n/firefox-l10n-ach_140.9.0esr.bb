# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8ca9b30a7baf6e091e8d9715b622284c"
SRC_URI[sha256sum] = "6d25625a27b60eabab7b3d42271a8c68acafb548397f07f26de4be7cf5ddb642"
