# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dc1081632a30e809a0bc10e73cd74a34"
SRC_URI[sha256sum] = "b37d091a469eade455cd4ffe6a46ea8276c210efcac245a824ed89335d79a211"
