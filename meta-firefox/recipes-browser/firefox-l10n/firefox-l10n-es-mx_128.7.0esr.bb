# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "113a42a0693664b828125d87832cbf4a"
SRC_URI[sha256sum] = "bfc27f0f7036375b8ed66bb57a4c7ad7e4ba6a5e754689bd547bdf5189e1138a"
