# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d52f93f167a94b5392c1888d2e2ad256"
SRC_URI[sha256sum] = "cd20ef3ac51a8e113d00944751375587f0bf9d155168e142cdfb2edef522598c"
