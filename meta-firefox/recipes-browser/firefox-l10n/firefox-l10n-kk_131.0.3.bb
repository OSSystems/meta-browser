# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0f4346ecf68a92ddf9c6f1d43457f46c"
SRC_URI[sha256sum] = "72d462859569105f6b4532ff49a0cf10f79d34f2c8a868793747c43c805a077f"
