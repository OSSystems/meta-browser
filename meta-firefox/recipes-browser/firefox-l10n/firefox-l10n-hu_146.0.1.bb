# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7a6e38dfd7a72ce1fc1591a41b3b0ea9"
SRC_URI[sha256sum] = "1ad0c08b3cc7245eb9eca8636b35327a87d04504b343f94da1ec4863e5e1c464"
