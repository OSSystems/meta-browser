# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "feadb8aa5b7a374c75334a474e015416"
SRC_URI[sha256sum] = "df39312fc4a9ad23533d4ef8227ed950361e840bca7dfbc1b6ce84fe1c02008d"
