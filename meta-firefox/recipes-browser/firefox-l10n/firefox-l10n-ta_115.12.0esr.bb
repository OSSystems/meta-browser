# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d7a874c095bcf7da7c53226bc6fac397"
SRC_URI[sha256sum] = "84c17d8b5b48ae0f3585f9c54b70297d5e46fb4c5242100a63fe1b01c1670f93"
