# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "763d9580f3a2bb17ea98054307ff9000"
SRC_URI[sha256sum] = "72b0a1c19b2b3e58dc755be5323ff4372cda86023d2acedc81f61560eec25739"
