# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8cbc0593c885c58249e81b35ec68f04c"
SRC_URI[sha256sum] = "4d41fc288c1fcce3f192327a8a307df2ffeb4b89a8d96bf2ef768bf6a29e67bf"
