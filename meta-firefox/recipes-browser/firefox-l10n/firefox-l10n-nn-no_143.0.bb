# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "958a8f75d06e48c560031910b99ddd5c"
SRC_URI[sha256sum] = "ffc96eb6ac3b49fb41b487d6e100b0a7759e4374b27c4bd9887e9bffe96fd608"
