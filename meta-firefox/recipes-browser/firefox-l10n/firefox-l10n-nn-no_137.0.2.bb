# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e7e0ed52bf02be85fef8cb09492ccce2"
SRC_URI[sha256sum] = "8b32b4058076921c9d0b181907cf958c326b9d9c9412c8efa66911757d0ea9b0"
