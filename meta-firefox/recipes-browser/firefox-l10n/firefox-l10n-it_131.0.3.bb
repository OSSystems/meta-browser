# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "309e35743344fa9f63ebffd56a2de601"
SRC_URI[sha256sum] = "438e9536509d50031d267e07f6636544dbdb64d9b49770c3d305f1b47f0d7dbc"
