# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "64fd7ead08be758380c0ca4d8ac8d860"
SRC_URI[sha256sum] = "c034e60cf83c791e5a08a4671a78d3c2392e0d1f1f7fb9d2ad68f0b86c933a12"
