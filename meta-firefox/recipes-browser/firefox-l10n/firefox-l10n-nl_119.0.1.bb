# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "916cbbea1c3a00ce070ede262c36cbd9"
SRC_URI[sha256sum] = "ebccf4a0226b3d4c46a0812e4a79c2ac61c600918814acadcfb1f7edecb2265f"
