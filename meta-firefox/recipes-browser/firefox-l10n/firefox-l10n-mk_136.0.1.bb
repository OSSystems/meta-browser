# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5682d12a072abe47974e1a06d7710817"
SRC_URI[sha256sum] = "f9f97d022ff8b26e6f4aaaef2c131ec36e4f5821577d16785fc6439eb6f97f08"
