# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fb5940bd5d7225f274ccdf26192b29eb"
SRC_URI[sha256sum] = "29027a4e50cc8199c78c658ce65d60fc87c1fa8d490564361c22e1139d78988e"
