# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "991737d70e976c6f1fd01b47a355ff90c29647c175213183d58b2f493b986164"
