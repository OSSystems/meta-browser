# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9248d088863c0d2d76a272eac33559e7"
SRC_URI[sha256sum] = "bafc928fba64961182c319834cccf4135707fe8b550b1ade7c2d57514f39b8a5"
