# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c8b6e898599381062e9664dbd80ce79a"
SRC_URI[sha256sum] = "b3a2d0ee00be4341a59e43f07feb4ea203e07206a2603f4339d3486bb7389117"
