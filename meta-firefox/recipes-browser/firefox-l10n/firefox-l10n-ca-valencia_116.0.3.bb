# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "44e82ca4d6cfb4b2943d85ebc4d2d247"
SRC_URI[sha256sum] = "f294a9486ed85426e13336440545dc389191c8d0f167b62b444eeccd0f3ffbd4"
