# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ad474ec10bdad1fd730153f3b9cda3aba635061cae13f4b5583a5b96eeba45e9"
