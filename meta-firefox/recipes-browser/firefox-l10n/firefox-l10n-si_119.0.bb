# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8ed5042944ebedc77add235dd24ea848"
SRC_URI[sha256sum] = "905f4818bba58c97ba57d7433e28674eb7858a25f3fd2b6435208ad3e94b0c5a"
