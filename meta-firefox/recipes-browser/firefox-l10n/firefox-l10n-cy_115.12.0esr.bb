# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f158342ac2c46035939003ba623f025d"
SRC_URI[sha256sum] = "9ef16f18728e29bd77c8a6d81595256effc134f10cae677c1b1919d9f897dba4"
