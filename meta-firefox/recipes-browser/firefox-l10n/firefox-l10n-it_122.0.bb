# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8c126d0daeaa801a5de3dd630b09197a"
SRC_URI[sha256sum] = "b0a5280b814d031d7bf8cc60e59198f04c0ec30c120bc56fea4d6df02e4fdd47"
