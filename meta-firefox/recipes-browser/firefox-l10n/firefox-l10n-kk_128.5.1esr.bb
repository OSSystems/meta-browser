# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d8ff5c241eed926bff4323324e457fa7"
SRC_URI[sha256sum] = "aab47553b938486a720361352303dc82cade7ca1cdc748ced313c1d938bf4f91"
