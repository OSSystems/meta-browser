# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a229cc538cbd5b0ebc940c3ea63256d2"
SRC_URI[sha256sum] = "5723723e83e4076eb0541f63c43d9028bc738023b86f557888f63afccd498517"
