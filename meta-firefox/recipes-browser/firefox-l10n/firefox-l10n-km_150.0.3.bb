# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "f1ee16200010099241150d52cfbe9314bc634bbb6ca00ffe850dda99c0fe7248"
