# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0d110c87d31b614dc3125448544d1851"
SRC_URI[sha256sum] = "d28633077e7edf6c36d3af6e57cf2fdbde33fd0fc5efc675fdb911e455e921f4"
