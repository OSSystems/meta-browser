# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2356187e3c371485e10f3d6f7bdc2dba"
SRC_URI[sha256sum] = "0a67d1b0ed3cfe8c74b3cd894f587f8788d051f77be25a4d633133d5fd54c101"
