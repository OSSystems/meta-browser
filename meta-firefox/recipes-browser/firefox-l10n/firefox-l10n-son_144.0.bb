# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e836334ee0d2b4395a85dd3d013e1872"
SRC_URI[sha256sum] = "c41944d1b8c6c431e4282aebf417221d2fc9424206f4fb1728e4681e830cc5df"
