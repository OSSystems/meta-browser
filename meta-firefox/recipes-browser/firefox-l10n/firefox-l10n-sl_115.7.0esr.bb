# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c3188db65795d96c427da6710b41d39f"
SRC_URI[sha256sum] = "8c485b4b9cae0268ee036ee6c1111c143877fbe4c5fe585c33907578568ba542"
