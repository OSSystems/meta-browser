# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "39704c7dacdb0f3f255e7a98a919b266"
SRC_URI[sha256sum] = "1a3e00b1503a737cbc378326ca964c7478490d299c3be70e7d9911ef09428ed4"
