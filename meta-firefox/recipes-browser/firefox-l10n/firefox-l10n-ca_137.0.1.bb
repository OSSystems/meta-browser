# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8e54a5f25ff8ae994ef0a4de73b27d7a"
SRC_URI[sha256sum] = "c5a1947672da5659d3f981b6e4e54d9a7b2b3cc24438649a289728acb1adbfb1"
