# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0323e8d73b59f83f357c5c851c1025b1"
SRC_URI[sha256sum] = "b6f4a121d3e2dde9afc0b54e5ebd4c080a1af299bdecf4478d4ae86187b9be67"
