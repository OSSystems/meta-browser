# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c6730057ee65410afde952cf5161654cceeb8eda8454b35d1222620f0ee78397"
