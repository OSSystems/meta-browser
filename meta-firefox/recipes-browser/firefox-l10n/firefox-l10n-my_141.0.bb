# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3a13a0c462eeb7d5c7fa1ec5e0503144"
SRC_URI[sha256sum] = "d95968664a1bc92156e4239dba9383b0ca7b6419db2aa3b0dc2b3fd97e0b0473"
