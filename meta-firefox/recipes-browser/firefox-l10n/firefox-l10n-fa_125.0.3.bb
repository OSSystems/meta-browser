# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4fba13bb963b62f25187c3f1c790776d"
SRC_URI[sha256sum] = "a50a5deb20e589eff403dddd57c339fead18aa9c57a2e73101da1125b1cc2102"
