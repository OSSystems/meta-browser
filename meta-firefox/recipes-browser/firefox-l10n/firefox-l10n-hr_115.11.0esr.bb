# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7d3329e584f50c0785ede86a20cf89c7"
SRC_URI[sha256sum] = "e1928c7f112eaf17efefb7132118568391152aeb181118e86eba61be641513ca"
