# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0b07b027693a978b47f46eeebbf2b439"
SRC_URI[sha256sum] = "5fa75e135435b15717ba4d106a41bb61e5bac29e7b66edb50a4d4a770b8bd623"
