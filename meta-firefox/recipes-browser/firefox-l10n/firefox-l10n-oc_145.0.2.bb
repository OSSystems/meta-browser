# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "03fea81ad9883be43eb67c5d9611c0dd"
SRC_URI[sha256sum] = "a7c90c86dc4c674d333f8f023f85b8ef4e00a691b4e0d977f7a69318b883d684"
