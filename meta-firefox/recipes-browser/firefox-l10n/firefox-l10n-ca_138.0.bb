# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "16deb39c87c8b87ee369f47a73f65916"
SRC_URI[sha256sum] = "666ee465101a149f453714cb3c4945d105e7ace3d5aaa5d018d6d77379c7e8ee"
