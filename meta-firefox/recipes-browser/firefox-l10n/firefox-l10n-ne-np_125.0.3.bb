# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f4c24a72a67c22bc772b0612a277af79"
SRC_URI[sha256sum] = "307023c1401b78a7e60bf299bf08f97c89faa7d2bd34666b502ed40ae8809904"
