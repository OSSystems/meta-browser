# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "806630f7f15a490b2265e763694d4526"
SRC_URI[sha256sum] = "ba8bf807bbd7d284990538533a661748875d370c286fec5bb63f9e3d45783c2f"
