# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b106ecc7af1996162dddf607c2a4d328"
SRC_URI[sha256sum] = "8b5cb7a69684f8bc5fe58585a48138b30762cccf156be5b9a29702fa82b0f056"
