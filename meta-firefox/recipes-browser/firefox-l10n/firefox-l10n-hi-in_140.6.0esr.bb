# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6b9e1aa33f3c9fef7c732a33761d8316"
SRC_URI[sha256sum] = "1d195bfb0d6cc4ea9b137b01f23cd631c3abd5e0d289ef264b4e0345a3aac5bc"
