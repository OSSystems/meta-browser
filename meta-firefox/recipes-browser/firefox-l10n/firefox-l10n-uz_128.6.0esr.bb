# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6d0f49b05273127831f06566791e7c64"
SRC_URI[sha256sum] = "7f34e8c9a2ba0d81175e62c5e4e75417626853b802bfefdb78ac3eb78a4a838c"
