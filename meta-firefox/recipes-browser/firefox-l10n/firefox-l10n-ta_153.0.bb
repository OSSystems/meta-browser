# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "6a944711deb52973a0021a6b1eb83d26ee70c5eb184f32914912e7dd86f2d4e8"
