# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fbcec4956d81b9a45782b1db33d1779c"
SRC_URI[sha256sum] = "922b13b06f8e5948dea9ac2e5e67e947e2452d6a143d3188027947e25d3948c8"
