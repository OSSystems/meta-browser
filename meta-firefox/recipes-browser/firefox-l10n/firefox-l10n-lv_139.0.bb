# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a5db37501c3d009f06e083edf2a8797a"
SRC_URI[sha256sum] = "462c26ff5749f32798e91cfb6c9b4b692fcfdaad31d55715965483fa6f028038"
