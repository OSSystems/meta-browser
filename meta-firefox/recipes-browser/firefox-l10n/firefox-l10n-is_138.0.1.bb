# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1ca6d6ab35d4113931f432081b95023d"
SRC_URI[sha256sum] = "7b427ff19b54c431b25a5c7e76266cd084ac2f69b5af907a9936b5f5288b6231"
