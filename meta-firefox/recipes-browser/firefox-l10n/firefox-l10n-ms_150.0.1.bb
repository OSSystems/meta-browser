# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c69d90c36602b5a4ecde266a9ba2d022f284bb7903dfc3333836b50860086d98"
