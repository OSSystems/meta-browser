# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3ae83292e833076ce5bd9efc7a9a9ad1"
SRC_URI[sha256sum] = "10e07cbfeca10101c23c3217d60aa4b0a32a659eb8bf9207045685d76ae96f09"
