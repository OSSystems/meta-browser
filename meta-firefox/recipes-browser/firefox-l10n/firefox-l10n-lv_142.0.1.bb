# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9045776da16caf2ded535e9dd2dce713"
SRC_URI[sha256sum] = "471fb23a591406553a96d6c22e9918e43775e67561da39ad835ab2d32951f0ae"
