# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e6df42512e666a9bda3fe4b5f1c20d61"
SRC_URI[sha256sum] = "f4c2c04bfbd955897190373d5aa72073f6108ebc4cc156559debafc9c9ffe77c"
