# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2e1f4bea7b061d6adc9a6e15b9a1532b"
SRC_URI[sha256sum] = "12e06ba5fe058ac324f4f40a36b5d1d4849c535a0126ce86a8cce170661991c8"
