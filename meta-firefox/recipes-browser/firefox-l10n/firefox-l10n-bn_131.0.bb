# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ced6609ae27700c1cd304c4e8b74447a"
SRC_URI[sha256sum] = "022c132d34febaa28cf6b0510a8187b86b28a598739da9cb7bdc699a608b333c"
