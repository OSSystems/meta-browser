# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b3d33ae2a44a33c2008acdfb787fd4e9"
SRC_URI[sha256sum] = "26110b9af01d9278c0c68d442697cee3fa295c97ab628f8ab9890aee688dfaa3"
