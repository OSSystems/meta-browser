# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c35ed2fca6d43a33b79986b85ebb3283"
SRC_URI[sha256sum] = "8e7596f3596b90cfc314bad218643f219c0c3d6b71e6a37dbcce737275ed0944"
