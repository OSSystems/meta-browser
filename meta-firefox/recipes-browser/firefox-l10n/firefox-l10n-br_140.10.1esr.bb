# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "362891b903dd6cd9575aadf43cd2a2715e46ab1cac87b72f0090a53d89db2289"
