# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e36fbe8db642c04521e2a652a643aef9"
SRC_URI[sha256sum] = "ed37c75fb63addcfe4d4c6d83cc1455185ee9cc8744b322681387b8e2955474b"
