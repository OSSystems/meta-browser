# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "868d4ecd5d89da8ff1c3a0e86d169d2b"
SRC_URI[sha256sum] = "0522581ccefd7c5a9de87e92b3804bada4e31472efc3c570504182850d0c0a27"
