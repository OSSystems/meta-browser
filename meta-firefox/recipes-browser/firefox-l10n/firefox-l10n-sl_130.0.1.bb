# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7721cacaac11698431965b60a635451e"
SRC_URI[sha256sum] = "4c91cca951aec182d9e635f4ce72d007713683c73ef6f86a3c3cd0783359de98"
