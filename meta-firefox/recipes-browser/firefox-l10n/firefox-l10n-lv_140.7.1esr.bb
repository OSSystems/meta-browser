# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ade82c10fc9eb6ae2d2f0dfac00f7e44"
SRC_URI[sha256sum] = "402fc7fee7e21cc86f76a3e9c938ee494059d001fd4a37d2c2ffea16cb36bccc"
