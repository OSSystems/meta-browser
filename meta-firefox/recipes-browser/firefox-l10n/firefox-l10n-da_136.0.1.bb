# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "faf25dc5f81631c8a1250121f903bf89"
SRC_URI[sha256sum] = "72615cc9ddf971f334ae4a999b14c10367c283f434a5aec8e1a4ace056f28827"
