# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "41c6b19aa5f51f6bb2d0be8f981759e0"
SRC_URI[sha256sum] = "db26eb400222f5df630101a97d836c728d9bb2b716dd218ca5e69824239fc62c"
