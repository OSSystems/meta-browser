# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fd284f03f69e4a318c9e67239eb97e1a"
SRC_URI[sha256sum] = "5b9195026e344e587ffa6ad401ff6469ade829fd5c2e7f4eb637ca116896b967"
