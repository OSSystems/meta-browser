# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "48f96c183a9338a45ef837b47dd2edb3"
SRC_URI[sha256sum] = "d21be94ab85880b8e8c4e32394ec50bfadf9ab485c4371dced03a9590eefa3f9"
