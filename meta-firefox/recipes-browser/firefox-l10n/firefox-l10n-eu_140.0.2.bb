# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "82ef6afac8f8b0773d6bbc0dcd9bcbc4"
SRC_URI[sha256sum] = "c9145e641c127290bd95d1fcc8c7cf8fa0e18fea7e0c6f41dd4a2fe027f787cb"
