# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "50d1ad2ce3e3fcb497d054327b5d9410"
SRC_URI[sha256sum] = "75302536d74610dae1bbf2e8102dfa3dc91963a3cc3f86d4174e8f639b4451a6"
