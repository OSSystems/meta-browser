# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a6cb41c2b35b0fb0104a6181eef2ff79"
SRC_URI[sha256sum] = "4a32a11ee85ae70ec8777baaa6ec44056ca1c13feb9c767290a198e4fced4e0b"
