# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c5511718eaef6a0c15cca9c9e2345181"
SRC_URI[sha256sum] = "849f7270840c66c439933ca15178a9b345d462cb214730be395d673e4c3a49e4"
