# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c4503a562ca13651404fc7f4b333a19"
SRC_URI[sha256sum] = "f0c45560397cddde46e38f38aa190630f92e444ad790a841e7004cdc0e8fb1f5"
