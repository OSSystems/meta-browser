# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0897addf6d87896c54ebaaced0f7b665"
SRC_URI[sha256sum] = "d3dba88bc49812480da02d36fae5d4c8268404698d43950eb6265fcea62942f9"
