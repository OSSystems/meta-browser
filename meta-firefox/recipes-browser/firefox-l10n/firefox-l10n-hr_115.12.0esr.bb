# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "01c590bf3c43f7d278fe8ec1cdc4ad9d"
SRC_URI[sha256sum] = "f0db27969e3adc7aa3f2d8e5537884a3d792b7da062b1774b6e3f0608f323a70"
