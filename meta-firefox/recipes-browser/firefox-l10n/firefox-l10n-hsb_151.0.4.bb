# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2c958ff0066dc59361b2ca5d43cd43c8cdc3e0f1f51f42d6222e5f100924d80f"
