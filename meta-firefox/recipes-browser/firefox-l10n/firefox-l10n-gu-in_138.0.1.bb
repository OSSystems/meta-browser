# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d57e83728e46194d97fbe3eff62dce0c"
SRC_URI[sha256sum] = "1d9e089736390f95c9b3fd1aee2066351e94e97d48bcdf23319a3954c352fd03"
