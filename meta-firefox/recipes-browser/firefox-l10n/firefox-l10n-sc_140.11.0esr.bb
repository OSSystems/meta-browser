# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "f42a826191ca6950cc907703c98136b3cfe75e949ffa568118e0f4260d590426"
