# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "541fcae44f04987d9c8e187cb37a5208"
SRC_URI[sha256sum] = "aef5e666755bfbc798956fed929aaec6885c4ce8c0f2a22a838ae2347e06050e"
