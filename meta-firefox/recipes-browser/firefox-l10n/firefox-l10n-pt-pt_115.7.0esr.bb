# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8d99ce29af879e7ad1ee0ee134e54793"
SRC_URI[sha256sum] = "dfc64493c356f474352fffcbfeab8700dd3a931097f3ce574c272d78d5cc8d92"
