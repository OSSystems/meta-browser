# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "07248fcc3c9110e173c0d8250fc184e3"
SRC_URI[sha256sum] = "01b43787e2b2d90d279e9fbbe08919748367a6a595803654c78831e0934d0cf1"
