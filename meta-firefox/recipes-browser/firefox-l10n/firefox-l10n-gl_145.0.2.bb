# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "54623a5df591efb450ee19821fc98d5f"
SRC_URI[sha256sum] = "2c80468c0e9d73b09cc6768166385877c59828b8cd54e41bcbb955a09ec970ae"
