# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4ff0eed084ecdd139b79dd8b51186d96"
SRC_URI[sha256sum] = "39d8db45c85972d77e3a64ef90813eaf68bebce6b4d9bfda8fa5a864b6f1552b"
