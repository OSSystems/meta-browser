# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3b90c58693029b0761e8c0d540ff178d"
SRC_URI[sha256sum] = "e507a3fd8f7e99d87d9ee1062453b232ac86f81e9d1e2108d1c405bdf1d4331d"
