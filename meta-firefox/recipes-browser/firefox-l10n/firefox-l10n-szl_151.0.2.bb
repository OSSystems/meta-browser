# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "24d906ee6518c52c0e8e6343730c5d73f04fd181492711541a3678d5b11a10fb"
