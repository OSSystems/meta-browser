# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "53cd51d57495097b54fa02b9087bcefe"
SRC_URI[sha256sum] = "a6bb197f51d770f28a3518a075fc60ef5247ed38da2a6614c80de675b4a813e8"
