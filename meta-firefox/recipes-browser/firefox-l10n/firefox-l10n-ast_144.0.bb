# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b6756d8745226816b1c6ea24ef719af8"
SRC_URI[sha256sum] = "8b952bb0601877176b62ac573e8f3012403ee08bb6b598a140b497ccdff9c3fb"
