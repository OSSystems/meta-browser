# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "36e6b7bafe462be5578e73a66ddd0b94"
SRC_URI[sha256sum] = "bf9a52831c416c84c48c41620455bac00b7a0298172dbd8e9447ab16a594d58b"
