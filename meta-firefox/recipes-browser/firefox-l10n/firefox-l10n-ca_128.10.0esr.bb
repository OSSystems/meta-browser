# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "34409132e67513271a85b4574a82c19e"
SRC_URI[sha256sum] = "6317e06dce8ffa4b8898fa034e5ff981e9854e9abf95962476f290ac14f1f43e"
