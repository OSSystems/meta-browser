# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "99e285109e79ac331efca6119fa5e409"
SRC_URI[sha256sum] = "73c5af02e8c5ce19c83ff5182a8381931164a74d6ca224a64f7cdc010807152f"
