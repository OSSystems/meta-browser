# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e4bec316d64a505b8d28385e72a2f1f6"
SRC_URI[sha256sum] = "343f6949263b69d6b472b42d903549360dcabf3d6fd5aea1394365a7deaa26ee"
