# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "153ee212f0d4bc7fcf07ae266e51df58"
SRC_URI[sha256sum] = "a2a58a755844ca1d74cfd7cbdb1783a6cfa37fc63ded65402c5e2919ed21a7f6"
