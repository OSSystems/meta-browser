# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bbbb8cdd504e5b7be552f5ef90949b2f"
SRC_URI[sha256sum] = "8fbf5aff03138b49305f6148e2b578bcbaf5ea9b3a4556b83304a7e5054dd557"
