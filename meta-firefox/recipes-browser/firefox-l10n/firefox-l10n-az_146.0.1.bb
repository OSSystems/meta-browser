# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "34905050495923d783194916d58e54a4"
SRC_URI[sha256sum] = "30f71c0e82089ed30f7d950426dd05431119bd199a000f6212a224ac65434ee4"
