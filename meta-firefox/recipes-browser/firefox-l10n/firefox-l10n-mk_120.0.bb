# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1e25d0dca55973c8cffc5cdd0c41e883"
SRC_URI[sha256sum] = "6ef258c033876bf5e5e62e998b2087c32da36840e65c4c36b3323a1dfd8eb5c9"
