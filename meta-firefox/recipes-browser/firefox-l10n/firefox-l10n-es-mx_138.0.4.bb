# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "19410ab155374aab582df884b0d3e645"
SRC_URI[sha256sum] = "476855e4c5bf0858b671dfdb752be7d68ff710e2b6d27a119ade22e33f90e24f"
