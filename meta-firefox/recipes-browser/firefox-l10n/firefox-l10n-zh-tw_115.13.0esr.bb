# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b370059cff6168b6d6d411a54aaa39a9"
SRC_URI[sha256sum] = "e9451a3fdbce9695e1fe409b1a23d0ceaf7951837701cbc7bdf5826b996461b4"
