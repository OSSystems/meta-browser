# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "916ecfb022cdc3cefc64765ab91d68b5"
SRC_URI[sha256sum] = "55a5a720a222bb98ece348f5ce1cf80e10646dee55c1f2747c9931dc7e86c507"
