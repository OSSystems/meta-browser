# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f6e490c79af22264c966dff56ede6d01"
SRC_URI[sha256sum] = "46ab37766182fc72a665a553986181c95f13079daad408cb34af4e46628d271d"
