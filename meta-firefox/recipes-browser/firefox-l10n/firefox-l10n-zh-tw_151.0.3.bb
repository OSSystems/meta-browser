# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "5218f3d8024fde7ad9ca5be5184307d486dea6f695f9915de24f8d7d2f0d1669"
