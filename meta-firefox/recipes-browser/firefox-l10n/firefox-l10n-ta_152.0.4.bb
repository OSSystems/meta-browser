# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "5ba7a63ef2e2c7278949f8c7328c93e5f9055dc142f09d3c32552aae3b8bf892"
