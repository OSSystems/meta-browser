# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "98dc4528dd3f49a0ca7ca9e72b96c1af"
SRC_URI[sha256sum] = "4ac74577fac11c9c87017b7a21d9b08d28a638e405af376c41753e2e677edc11"
