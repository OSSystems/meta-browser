# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "095e30636adf2c08894c050ea81c352c"
SRC_URI[sha256sum] = "0bf7a78def3d686c29fae4a92eaace5f1ebea4946299094f2bb1646a96b502e3"
