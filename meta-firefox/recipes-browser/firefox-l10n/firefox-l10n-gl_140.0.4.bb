# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ce1650d08bd01877614936787aeff64a"
SRC_URI[sha256sum] = "484b6e3ab2ac7d5bbfb933b7b52e29d2c1af052a3864c625437db1d18bb1ca26"
