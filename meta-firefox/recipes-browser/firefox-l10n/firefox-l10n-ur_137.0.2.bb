# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0feee284b5835eabad15ebc76eb23b81"
SRC_URI[sha256sum] = "d78dbd12c090dc23eeadb9b6a7f4f6b967a160d038d871ba7f5a09f4c8427da1"
