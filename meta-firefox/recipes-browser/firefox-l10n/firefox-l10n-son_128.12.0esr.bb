# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1bcc758acefc0a9cd1657c778ccf9073"
SRC_URI[sha256sum] = "bfc626d4e8545fe40f1fc52c6448ab9494dde4a42ae9dc9902700c3a221e8385"
