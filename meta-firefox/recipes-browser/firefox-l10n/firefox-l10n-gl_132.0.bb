# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a640a15d0956622693aeab495cfe526c"
SRC_URI[sha256sum] = "613cd440ab31500df12232b0c932d8d700efedf7dab989c573599d26c806a3e0"
