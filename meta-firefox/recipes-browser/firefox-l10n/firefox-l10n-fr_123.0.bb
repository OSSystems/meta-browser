# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "15b12d761ee6d5a3a8e4d28f6378366d"
SRC_URI[sha256sum] = "aae46c8bd024d3c02f07866a39183c7be753d5abab6e9a523f74876fa043014d"
