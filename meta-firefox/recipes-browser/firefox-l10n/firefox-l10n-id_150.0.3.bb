# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e5cb433cd2234a1d94a6b09e5ea85dec3f747e2ed263c2e62d1ad601bf5c7818"
