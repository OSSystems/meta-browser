# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "60dd3e315fafa19ff516cfe02af4fffc"
SRC_URI[sha256sum] = "a973968cc3b196a41ef0afdb3196e6d93014e1db8692c5d8d4c06ac6acb0d8cc"
