# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2bc48bed8163884542f7efc9899087f3"
SRC_URI[sha256sum] = "a328e4f276c0560971b83d77260869da2b7259f941b9fb97d810bfafc46ebd21"
