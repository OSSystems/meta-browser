# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "97284fb56a9c41a37a05244f1be9e60d"
SRC_URI[sha256sum] = "83288406fb3bc80e65e00a53f0d8d89a57f8ed035116439fe451d3ee4b3c6ccb"
