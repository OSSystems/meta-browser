# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0cec3de66539094c8fb980af1c8ec6f8"
SRC_URI[sha256sum] = "ea26900e8797c4d35aba3633d5300003caf1fe6db5332dc584dbae40326e32e7"
