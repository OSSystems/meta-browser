# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b697abb82a194e7c18863bfd9e85b700"
SRC_URI[sha256sum] = "b2927c8d38ce342ea29d9d2261ab5b6381378917207fe130a62da3cbee865c29"
