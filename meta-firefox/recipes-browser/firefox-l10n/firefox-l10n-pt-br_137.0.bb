# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8938e8b7b3c2bf2dab6de589faf5d87d"
SRC_URI[sha256sum] = "d9eac8084f6a379a274bfe24d18c93cc58b809ef2f107831564324cc50f7dbbf"
