# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "59558b16e7c2e0b142b8acb2af7d0882"
SRC_URI[sha256sum] = "ca806db888666e86bd3ce9d41023d7d041131d6c8c47fc025f00ad13eb890ae5"
