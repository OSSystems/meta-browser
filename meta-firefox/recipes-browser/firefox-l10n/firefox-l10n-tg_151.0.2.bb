# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "612b9d53abeac47e0ead54afd461943d8f9bc6302efffcd92a143cd8a2b284c1"
