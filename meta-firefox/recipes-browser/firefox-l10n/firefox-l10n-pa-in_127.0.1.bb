# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f5080dae3332f0032054dc9f0e7a0720"
SRC_URI[sha256sum] = "556692f63710247b9370c3df6079099b99c7b0053a13e923a02d83c474df3e6c"
