# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "802b3346cb962a49bd40dfef69fc2dba"
SRC_URI[sha256sum] = "a5a267cb545789c79f17d130f243edbd0f6bacdbce47731e6c3a4137f29ed374"
