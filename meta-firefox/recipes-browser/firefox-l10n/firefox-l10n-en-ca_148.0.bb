# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b4d8b7eb025aa559ef5d1bb45a079134"
SRC_URI[sha256sum] = "f28d362bc946f93757464f0a636ecb83523006e56a6103e0b2f80b0702aa3cc0"
