# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4b28627ef493b76c2221091a30fb307e"
SRC_URI[sha256sum] = "2f404c432d7897777a60755219be117125df998469ad9942740a92034137123f"
