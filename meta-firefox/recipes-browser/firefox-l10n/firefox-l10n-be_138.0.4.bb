# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4116fecff8de37e5ef7db658f5cf8b4e"
SRC_URI[sha256sum] = "c1797d22aad64d14f9c3b044d6aeb06c049a245be217fb6fd502d51aeecff495"
