# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "53f7a20a3d96d30d16edc994d2603bf3"
SRC_URI[sha256sum] = "d8c69e44fe97cdb8922ba06ac057b954c24529f038628c38404c5645ad61c5a9"
