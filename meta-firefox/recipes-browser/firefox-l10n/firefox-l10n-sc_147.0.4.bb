# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "64d9c3fc1e0c06e190fab0895a5c6049"
SRC_URI[sha256sum] = "198f9eacd51368746cd7b78c35152ada7a9bd51880f0ccbdbf7f3d68e495cc2a"
