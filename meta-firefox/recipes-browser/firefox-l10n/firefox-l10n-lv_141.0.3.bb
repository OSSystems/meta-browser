# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7649178929d7e39041ef92700dca6cc5"
SRC_URI[sha256sum] = "dfd1eb65f1d279b9aae399b1d7fe002eb2a2523f0f85c7e67965921809b1671b"
