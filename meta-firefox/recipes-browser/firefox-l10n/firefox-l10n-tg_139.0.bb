# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d17375b1e1496d4a8464b02955552766"
SRC_URI[sha256sum] = "7b2c0fe0a21051be097d23b3c476565b42587d7b34b6542c1e4c5c14957a15d5"
