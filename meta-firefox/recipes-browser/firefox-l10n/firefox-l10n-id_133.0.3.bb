# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f0452d85eefeb77578f05381b2eff47a"
SRC_URI[sha256sum] = "7fabcef1f98855a2e3b8fec168baf5313c29ef157150820f61e144b7652e38f1"
