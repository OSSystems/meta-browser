# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c795598c585d6b62c0eb1f4d38dc54e9"
SRC_URI[sha256sum] = "66706affe9976b3e7624d72a6115209a8a02c5d4d0f1b7fa880a575154cf7c32"
