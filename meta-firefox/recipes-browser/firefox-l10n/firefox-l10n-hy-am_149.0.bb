# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "167392d61363a9b41bd0dec5529a4df8"
SRC_URI[sha256sum] = "15a431a86e5a0d426cf5a0a9d4dfd5d9bb3078a94e00ab61dec5ecb5853e702c"
