# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "463d03e612dc5cfc24780e90f3aa4992"
SRC_URI[sha256sum] = "01a6dae790a88b95989a317baff40d1ae75b565a650f271c92316bb0acecdbaa"
