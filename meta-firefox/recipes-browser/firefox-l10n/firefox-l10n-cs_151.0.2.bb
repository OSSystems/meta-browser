# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "b6d39044e43147018e138c06e1e3e94f1bfc5be834884e6d3de6d3757b65aff5"
