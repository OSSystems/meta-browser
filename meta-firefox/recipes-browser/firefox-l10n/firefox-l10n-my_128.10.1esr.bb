# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ae68fd05fcc4fae14acd640a4e831c31"
SRC_URI[sha256sum] = "21f88d9f15b511fea771c62d9df948f51a934464144a74a8fa21283b4a29f8a7"
