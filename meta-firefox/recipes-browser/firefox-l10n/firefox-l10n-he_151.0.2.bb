# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "f07aa8326dfd7025b5386c400d54aaf8695059e0d4a1cc7ac26095c59ed21974"
