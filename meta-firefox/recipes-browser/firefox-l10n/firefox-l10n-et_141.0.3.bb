# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3451a26278ce9446f3a076262afa8e3e"
SRC_URI[sha256sum] = "ec8436683425272d030530451c83d3217385a6268e922af6dee411a94318b57c"
