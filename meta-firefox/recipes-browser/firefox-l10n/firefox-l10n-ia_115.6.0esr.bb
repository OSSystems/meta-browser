# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "352e56a5063358838622c04ba135da11"
SRC_URI[sha256sum] = "3d1c8f6d1713ed6a047b9872f9f9ed7416b7a5d47d897e744f94a8bbe49aac86"
