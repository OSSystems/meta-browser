# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "83fbb67fc6fd24e63bc6dffbdd94bab2"
SRC_URI[sha256sum] = "cbcfcc94349fc86b3d3adf8834771f5acd8b4349fe29f2e4623bdfecd24c10ad"
