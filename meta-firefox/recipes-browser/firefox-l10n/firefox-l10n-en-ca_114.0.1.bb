# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f19a44ca75ac06fc56a5b0f1965fe9d4"
SRC_URI[sha256sum] = "2fa24bca68d6fee4affd4d62b70a2ba87eb130b272a5dfa22d5fa8aaca8f7e22"
