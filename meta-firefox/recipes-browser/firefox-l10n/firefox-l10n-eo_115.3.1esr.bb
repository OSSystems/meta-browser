# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "70848cb45c4498bd8462da125c1f2f11"
SRC_URI[sha256sum] = "280044743892c71968f4f2363212e8ab3df8a76027eb49a734e816659289990e"
