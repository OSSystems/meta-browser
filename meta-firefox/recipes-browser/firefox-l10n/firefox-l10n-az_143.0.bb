# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "93d3f4e034dea6b245d09df76a9a896d"
SRC_URI[sha256sum] = "34c0fec3bc7367f8fc586e85af2c095670dce5837748588f09f33d0b62432a3c"
