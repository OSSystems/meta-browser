# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "49d612ea1acf830d1fdec658cd1be260"
SRC_URI[sha256sum] = "a02b5e698d355fb8f22949eb9c7f7a6b37e977ebcad7eb4c82371ed4f7139a8e"
