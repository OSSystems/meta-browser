# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d4af4ccf9ef48324a46e21a3e0b1a3d5"
SRC_URI[sha256sum] = "8ee5eafb21cc09950193afd4bbc5f5ce916a9ba5f8aacfae3957a1037c7ced88"
