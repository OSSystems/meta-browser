# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c98a1a651289d17f4cb13a082341dc3a"
SRC_URI[sha256sum] = "bae26c51bac9b5c4769c5becbc7fd005f6c4693994e1c1632f1963b885b8d5d6"
