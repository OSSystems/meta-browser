# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b21453540583f8bffa20b58898414024"
SRC_URI[sha256sum] = "2cfa6cb80cbf312062da79a55a4db108b730a4a3336f9289659225972222670e"
