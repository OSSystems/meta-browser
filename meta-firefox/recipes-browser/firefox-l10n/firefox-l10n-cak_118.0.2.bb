# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "62c7c0e89bc75db3e3d1327598dc1620"
SRC_URI[sha256sum] = "8b670c062fdb520b47a730ac5027c0fe613f484b00c77973562bce4dd2a4b5c0"
