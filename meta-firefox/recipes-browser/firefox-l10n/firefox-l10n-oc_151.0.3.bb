# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ef45cf467bcfcdbf44f641ad04e3421baa4fe7dcad2ec22cf2f265714194cd5e"
