# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "03e4f79ad79d15a61f7a9a5842239361"
SRC_URI[sha256sum] = "30368b474aa06574fedc300fe2314a7ef409c98100b114515feb08026a3f94d0"
