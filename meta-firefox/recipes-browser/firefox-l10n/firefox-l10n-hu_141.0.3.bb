# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2f314d97ddc04f03b3e8bfb09fc27cb8"
SRC_URI[sha256sum] = "2d51b302d71e769693378b55998f8003a3226995d07d8109bb96d7699dd5db3d"
