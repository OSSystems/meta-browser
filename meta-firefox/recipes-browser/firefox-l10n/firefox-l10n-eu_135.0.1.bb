# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "33fc14f1f11d01e9d9521facab450551"
SRC_URI[sha256sum] = "b23a3ca8467674bd12f6e754370fe616bc1509dc0ca6b2f5b3d8655f63fa42cd"
