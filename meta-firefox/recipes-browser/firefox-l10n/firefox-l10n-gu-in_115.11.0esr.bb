# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a1c6fe08c3ad79bb5e542aac88a00bbe"
SRC_URI[sha256sum] = "e3ca02ed90da42567bb8b0b7b24eb1ea4e75299cf1e3f5ff9c7d3f55f87031a2"
