# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e7196fa66185d1a82cd33b93db4d4e20"
SRC_URI[sha256sum] = "8b484561e71302d74bc7592862cdcc62f298d65af7a2749d8a993553a94196d8"
