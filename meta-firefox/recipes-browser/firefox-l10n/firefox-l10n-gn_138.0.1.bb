# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f2024e53db80ca3c2543a1d56735c308"
SRC_URI[sha256sum] = "c11128a9aab56ec8fac6892b0b68339118dad4b6d1bb52924c97482f9a806022"
