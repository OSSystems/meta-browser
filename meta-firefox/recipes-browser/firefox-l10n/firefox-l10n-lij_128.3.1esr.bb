# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "18de2168601c6bc98a8965ee9211aa2d"
SRC_URI[sha256sum] = "188339a220924586388d022a49552aa8fdee0e482e2c8091d14ee294b4a9cb12"
