# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "96a3d09acdbaf9ee82778f1b9a7b3c01"
SRC_URI[sha256sum] = "e54c084c9524f46ff7760720fde04a0dbd54721151a36cbc7249a90a4be0ce74"
