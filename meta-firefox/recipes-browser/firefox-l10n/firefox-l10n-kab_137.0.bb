# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ea9de00279b15b97ce03ab879f5a734c"
SRC_URI[sha256sum] = "787966a9f1fcb0c39c810e35b47ba7756be4529e8d503f6a5379d3e05738ac5c"
