# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e6387b5d43b9512859089c3a0c8095ab"
SRC_URI[sha256sum] = "26fc4cdf7a911a25354825fe92a0d0f65beb8da7b8db7342df878a4d7e01a65e"
