# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "57ed5e132fa61a62480e4a9eb2e6edc1"
SRC_URI[sha256sum] = "6faa32dd4530686cd644c5858f48fb4c0abfa7f906b0c9a498620ed390224567"
