# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c596c8f2d04ecb3858e9215ee22b0475"
SRC_URI[sha256sum] = "86ec6d60bab5dd415e449771102dd317a8d735d42a0b85f88c45e1456bdefb31"
