# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c9f952ffb882640caa7f45b4b9db5801"
SRC_URI[sha256sum] = "fec0be5904d4d08a1a78a200e642d9b652f79e5cabd23ea0ae6fc46632801daf"
