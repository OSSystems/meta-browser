# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "58c29c3fc92039657b5b217e88ab1230166fc5a245f8851b5c0848f13ece77fb"
