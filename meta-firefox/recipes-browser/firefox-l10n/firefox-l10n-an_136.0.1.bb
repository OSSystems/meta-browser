# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "30b7ab7b700421a2a531d251834d1c3a"
SRC_URI[sha256sum] = "c952a29cefbe2f415a5c48ceff0d124d79210335dae063adecd4d9949118e91f"
