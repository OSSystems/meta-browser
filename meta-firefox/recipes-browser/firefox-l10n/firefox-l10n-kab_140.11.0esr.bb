# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "37a4da91777b71e1e6d121331b20fa0d23fa27a160e1624b76e7714fe492b996"
