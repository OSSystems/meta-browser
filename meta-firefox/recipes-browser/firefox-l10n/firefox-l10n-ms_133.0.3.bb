# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7c8d7bb167c0f4627e39ba8b3c4a9ddd"
SRC_URI[sha256sum] = "38a476c7574ff9d3d56cac296cc2dbbd74cbf7c5c3c17ccdaf1dd74513e8b230"
