# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9292e0b4048e6487e39c508ed84c43ac"
SRC_URI[sha256sum] = "9f6c8d21552f2e31fdf3d5a7445cd02bbfe7a70e3cea9fc22967f3282a4aaee8"
