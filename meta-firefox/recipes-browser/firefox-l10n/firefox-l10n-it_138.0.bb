# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "73aa54d2a907d42041eb65e70c863b65"
SRC_URI[sha256sum] = "8b5618338ed639fb44713c9881018bbcf7dd9f546b5c4eee85c860f75255d834"
