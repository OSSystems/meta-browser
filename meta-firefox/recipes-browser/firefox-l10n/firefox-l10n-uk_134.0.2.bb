# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c77e1048e08026058db146a52ecb8df8"
SRC_URI[sha256sum] = "0ee68dc0214405837c39468f91e72694bcbdd9e4e608466a1891712d571ba87c"
