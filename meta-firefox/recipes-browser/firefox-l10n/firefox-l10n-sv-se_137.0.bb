# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "317ec51020921590ef13e5a040ea30c7"
SRC_URI[sha256sum] = "edeb16fdcb89a8595c5d1a59532e80985e1c334a702a4d856b7a7fb05b4f03dc"
