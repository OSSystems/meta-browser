# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4be2ab65fd7de832bb3200cb21ed2bb0"
SRC_URI[sha256sum] = "b87a5db1a4dfad1053cb6ade57dc05a1bd0e10a19a70f77348247b5e278448f7"
