# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "73385abf21301930af95959bfd796628"
SRC_URI[sha256sum] = "3be823a520329188d8be082edce5141980962bf609d664bfe6cdf8b02f417c24"
