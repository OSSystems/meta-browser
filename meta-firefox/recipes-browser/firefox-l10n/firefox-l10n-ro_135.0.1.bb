# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "044c6cae0d4ac6b173b956b6e1c54628"
SRC_URI[sha256sum] = "0ccf0d67b4eb4388f7167a7848e1d61e7cc5b82e031876f29784768b90374d1e"
