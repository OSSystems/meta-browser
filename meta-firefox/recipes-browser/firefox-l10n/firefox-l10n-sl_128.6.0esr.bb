# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3f847f0b49f2ac199f8dd6699a91b7c1"
SRC_URI[sha256sum] = "66360184611f8e6f2a6666c39d2e4cf4c6d3fa481b102db1b2dedf052798c097"
