# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "a123683983120f5838afb46751bd7f274b7e52f3725aea0eaf7f9d7005e25ba2"
