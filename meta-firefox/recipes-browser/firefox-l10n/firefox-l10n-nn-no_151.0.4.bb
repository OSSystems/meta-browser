# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "43008e9ba2b4ae814f9ef17cd77ca907e93d84792257c0e7a6b969358823370d"
