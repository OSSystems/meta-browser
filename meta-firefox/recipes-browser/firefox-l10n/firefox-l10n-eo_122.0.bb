# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b6d0a870d78967b38e026c6b3f8e1d6f"
SRC_URI[sha256sum] = "a144069ecbfe41de98a94481b028b9979be54444120bbbfe337bab5a06b4a1b2"
