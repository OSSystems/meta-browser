# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b30dba07d48944d00008b55632302ec6"
SRC_URI[sha256sum] = "f692fd37359635e5f388ea3a911adbce4eb35100c11dd76d662a9e93c96fb32e"
