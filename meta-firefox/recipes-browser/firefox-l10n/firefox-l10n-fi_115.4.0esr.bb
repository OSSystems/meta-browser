# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2ce3bd2028fcb1d0c95b5dfe319194e7"
SRC_URI[sha256sum] = "2eab8a4b9cbeeda3dc413005f89dccf88347406bfcbbca73a350e0ee55e9c185"
