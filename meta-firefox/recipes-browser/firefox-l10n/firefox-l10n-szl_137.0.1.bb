# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "67d752bf55a1e075c0a46107f0d385ae"
SRC_URI[sha256sum] = "abfca32576347c49cd137c901b46bdefa61c6876dd2835f0e7f2fa1394b121b3"
