# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5b42a660cb916e3e1955660a55eb4c7f"
SRC_URI[sha256sum] = "bf7d0369b830354279691c5f6716c6c1547d300859d978b82d18cf9b26b194ea"
