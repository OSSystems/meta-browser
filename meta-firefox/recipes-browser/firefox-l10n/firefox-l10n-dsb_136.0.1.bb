# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "afbd9c3e673aacd487a44edb0c5d90b0"
SRC_URI[sha256sum] = "a51c755c868822e33f37654522f0d67fa6db5096552199227a0c21abe74dbd96"
