# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "8ba63a5cf0edca3d91d1852976cafbb24b88c85646014d672afbb70a334c7539"
