# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2bb1b8699e417dac8d94efda9c328721"
SRC_URI[sha256sum] = "a13d86604d0d3105fb31040ad3877e5cda1cf1cab8a568ddb699ce5760943d5b"
