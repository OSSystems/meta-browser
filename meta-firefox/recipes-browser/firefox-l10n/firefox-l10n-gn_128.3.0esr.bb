# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ad0ba0c79bb77dcbc1a443a7e8587e51"
SRC_URI[sha256sum] = "2eee4793f4303c7245f9a3d7469d932ae79720e68bfe8abccba6f35296073489"
