# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f086b8b26251f083b839b25c04a75093"
SRC_URI[sha256sum] = "404aaff690cdc88aae8f33f38be14384f9f5bbb58f55d1e4ffe34a442a8022cc"
