# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d572741274f8edc50eb0ab2dd30f2e0c"
SRC_URI[sha256sum] = "c7500d809c5c380609afae8d071990def2bd2ed0acdc2fa797375d8161e50cd7"
