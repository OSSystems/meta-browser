# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "396cefed4d4f328bb312e4e3642fd36b"
SRC_URI[sha256sum] = "86fc6b5b868580e9f25533235cef691e66c2a8e63be7d78d24f706d20f2052cf"
