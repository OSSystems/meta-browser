# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bfd9f34c143f81f987e679546f988e2b"
SRC_URI[sha256sum] = "c4c9b0b6d6df4f6c5bafb4ea12f9384809c12565646a896a9a0c6a7e9fec4732"
