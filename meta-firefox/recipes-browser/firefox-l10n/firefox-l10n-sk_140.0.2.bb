# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ed497c9237728a9f74229277c056d5f6"
SRC_URI[sha256sum] = "a364be7ac3b881cc4287a37265b7f25d95824a11fb5654e45029a25e1fbdf833"
