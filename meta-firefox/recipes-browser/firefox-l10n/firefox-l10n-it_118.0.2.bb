# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "12a82996c6c68799e401b64f9090e960"
SRC_URI[sha256sum] = "ff01e7ecb40a02a5532234224d5ddc218607aa450fd46f8b6406d7e89e1d1212"
