# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a7e62106d5794d1229dc6dcad8a0f1e1"
SRC_URI[sha256sum] = "d36c5ee97b6101578142b85f881c540a835f7eae63c795deec703aac799e2a5a"
