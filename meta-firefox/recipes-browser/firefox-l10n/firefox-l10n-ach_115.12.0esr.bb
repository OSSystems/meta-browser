# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "57996b1c0b4ed56e71513ce176317c2f"
SRC_URI[sha256sum] = "6a86e6806dc2eb990a14b215be9a3f673f6a7fe100667391e936525050978012"
