# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "62cec7880ab4dca3bc1a503fd8a3032e"
SRC_URI[sha256sum] = "b0d8ec50bb9b351efe128f0f4c8332f43d2eb09866aafde81fc6a1d9b20eb0e8"
