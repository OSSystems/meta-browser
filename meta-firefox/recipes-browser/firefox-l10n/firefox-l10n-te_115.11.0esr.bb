# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3688ef7d2405c70cbf1f8bfa5841e9f5"
SRC_URI[sha256sum] = "a73d61d2176af68617d4259f2cc25474d0f3e236cce383a33ff8ee0eda517538"
