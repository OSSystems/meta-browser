# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d1b0716840cd38449077f8d6a89e62bc13bcaf1c08407e943b1f8e4d64c8c963"
