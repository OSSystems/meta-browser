# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7e29a0424b29ffa535cc3c6bdcd15043af049d68afad3e00b5c01cb0f6046fdf"
