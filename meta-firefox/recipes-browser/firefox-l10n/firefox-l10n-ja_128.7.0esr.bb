# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5c17da9784b4af832140e7bd8f35771a"
SRC_URI[sha256sum] = "4bcfbcf0147e2a14682455f09d8a3953ee3541d184c0b0a71ceba7004f4430a4"
