# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "038fca3ef8fa56cc2bb281241bcfeb615e52eaa70f6737a541ed26de9bd2675e"
