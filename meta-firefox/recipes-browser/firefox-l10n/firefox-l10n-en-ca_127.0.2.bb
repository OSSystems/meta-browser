# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f15b207324befc755e3d37daa246851c"
SRC_URI[sha256sum] = "103c177f1fa5ef5cec605ee0cf86c0342ffef4e8f855022a750f477285d24380"
