# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "161523c7239ad1daadf304ae3ae9b554"
SRC_URI[sha256sum] = "fdffa66978591d7a535ad1b2d094ebddc592e33ab65150550bf92b2edd118af0"
