# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cb33935dd1046009efffc29791422f22"
SRC_URI[sha256sum] = "cf864a29889f831dcb4420579f1c8cf3c75de699e787b18d452128bb5b770990"
