# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "07a036d0691a78c1e415f2770c6303e2"
SRC_URI[sha256sum] = "1e9c50ab53d29a3389b71bc9c94a73721f6c3d048f9abfca186255abab36be5e"
