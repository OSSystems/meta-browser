# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a380a8d745d5199f76218a1a598719df"
SRC_URI[sha256sum] = "1c65f77b1f2044f30cf31adec859593066247e3cfd6f22a0b4ce7e59f0a52d90"
