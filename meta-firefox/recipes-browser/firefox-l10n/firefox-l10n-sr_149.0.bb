# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ef3e4f263f17a9ccfda672fe777c6013"
SRC_URI[sha256sum] = "a648faaaa58142a9903bca6b7988dade50aa53db9831bc0aa6d5e2d2f6da0838"
