# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "41cb634d6f208ec11a8fbfff0dc3f60b"
SRC_URI[sha256sum] = "bb0d397800b24fc62e30aa27fac104a5804099f98204a997e630138680500c8b"
