# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "77859433759575b0c2d8609c8098936c"
SRC_URI[sha256sum] = "98c1d0d9259a5588f2a116194b977357c981eadca7f3b3734bae9011d9ff91dc"
