# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5af5b408eee0d3bcca17c277f884a9e1"
SRC_URI[sha256sum] = "25cdaa4685382400c616ed8c890c1f42dc80c154c20ebaa9b6e939eb83510a1f"
