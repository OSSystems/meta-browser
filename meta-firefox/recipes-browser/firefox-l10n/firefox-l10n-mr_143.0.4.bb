# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0ffa26378dd6fcef77b8c7ddd45f5ebc"
SRC_URI[sha256sum] = "5a119bae8cb8efdfd51bda114718aa8c4eb7a4ab4be1337775fbde706db16ce1"
