# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c71eaf0617416430c96666bfd6d97fff"
SRC_URI[sha256sum] = "6a21548cd171b38b2c88e7845c229b32903623ecd21226be607c288027988038"
