# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cb8553e93f0a7c137c48e0fff9d8b53d"
SRC_URI[sha256sum] = "72453a590846850cabaa65b4ee3a6bfa56b5fc63dfd0f2eb3f294a929be58e5d"
