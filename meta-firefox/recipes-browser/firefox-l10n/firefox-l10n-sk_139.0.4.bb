# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0d59e9e0481044bbdff02ff9c088b8bb"
SRC_URI[sha256sum] = "330ff1fa657e44363e84ea53cbad3ef0a30b5bd48a3907317a0e322346258520"
