# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8de2bfe2dbf7f48d3364dc7375a4f635"
SRC_URI[sha256sum] = "7277aa28aeb4a2249e30f85fa6c270d63da94b7ca5de6573fab555d7d7f9dce9"
