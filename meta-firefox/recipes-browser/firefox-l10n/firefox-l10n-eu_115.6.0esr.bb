# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "56d2e7be587d6ae5aabdfa54ff5b2c06"
SRC_URI[sha256sum] = "4b5c4ec96e0cb8478602b5899fa84e4880c7a77feb905f88d875774e8830ffd7"
