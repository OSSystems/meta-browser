# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8e36cd03451cd1edc66e77c42921ebef"
SRC_URI[sha256sum] = "1cee3d83a078a9af5f289cfa56b7382d57d0c9a15a95e57c551646881c5cd07a"
