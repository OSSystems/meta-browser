# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "20dd5ce9e6d117478a756303b6e91e4c17ac8e4510e004b1287a4c05213d2170"
