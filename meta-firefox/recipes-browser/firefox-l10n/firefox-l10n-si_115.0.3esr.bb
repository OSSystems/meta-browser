# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "920044a852844ec46038843b7a5d559d"
SRC_URI[sha256sum] = "2be31e985b2735d814041637bb393af8fbb8d734bd955eb1f047330535d8101a"
