# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9a3ff0667990ddec3a6a543046e39650"
SRC_URI[sha256sum] = "9de1fec7fa4e4f24d37e11aef774f5c7de2704759da97a12735f9d7cf401f306"
