# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3ba1eb84996431f5131527926c725fd0"
SRC_URI[sha256sum] = "411186b58ad3b671ec6a399b9f81e9d21b96c9063082f7ef6fa00fa7b4da6598"
