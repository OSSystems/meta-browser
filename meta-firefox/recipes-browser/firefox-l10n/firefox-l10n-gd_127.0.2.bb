# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b156111223d6dda44115bcb56e30043f"
SRC_URI[sha256sum] = "2f38eb1ff5b9cb87bb9065aaaf544a127cd8de06f1dfa9efac347fe8b157708c"
