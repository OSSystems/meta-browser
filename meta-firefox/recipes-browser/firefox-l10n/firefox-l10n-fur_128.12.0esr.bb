# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "66f6a36af6b537d3f7aed8dab0ad93cb"
SRC_URI[sha256sum] = "e13002e7e9e6f5041b60dd1a4276c49bef50cc5a1d8b3481ccd28afe6ddd6d01"
