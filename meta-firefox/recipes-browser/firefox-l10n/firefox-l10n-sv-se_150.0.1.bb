# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "4a50058a879b63f17e6153c41b012a9053a785ddfe549cbb0bf5e58f60e6af05"
