# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bcd87958cd4c1c99c31a5301c6725a62"
SRC_URI[sha256sum] = "2d3cc2b03436134500fd2650992eaa369fc1c69606d4f1f65b8666b5100593e3"
