# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "50988a4cfcd5083e73baad959841d57b"
SRC_URI[sha256sum] = "fe12b74735fffa66cada359c2ab5d73b1022149a7ef0632980268e8923b567f5"
