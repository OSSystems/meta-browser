# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6c29ce358e4d54e31e3b3fba6cba7096"
SRC_URI[sha256sum] = "5c38c7bc61c60b495e93adb1788735f5a1a3a01d98a5d65d11b1559769a90178"
