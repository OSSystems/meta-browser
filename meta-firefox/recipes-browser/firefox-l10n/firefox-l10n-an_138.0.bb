# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "663d90472cf5ed245107528132fd708e"
SRC_URI[sha256sum] = "47f7237ed5fc0384ce1272237225e669832343cc2d552753a302098ca0dfae85"
