# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fdf92577c9426df7ee6d108b9e47874e"
SRC_URI[sha256sum] = "982ed3c11b5ac41b56db62d3f2b567756525fcbcc683fb188063d2625cddc5af"
