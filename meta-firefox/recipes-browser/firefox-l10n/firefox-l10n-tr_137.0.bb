# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6d94aee5b8f92a47d2a36a870cdc81aa"
SRC_URI[sha256sum] = "8e9687932548fc02e4e70f65cbb4d9f4c62c3372ae7dee1487798d8088657e1c"
