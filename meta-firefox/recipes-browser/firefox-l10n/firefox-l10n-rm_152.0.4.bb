# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2e048b8a8e5bc17649d673cf3d53678de67e099f517b8b8c1baca6c41f3f759c"
