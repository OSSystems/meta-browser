# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7768ad14e6d078dd19de6222eb45cc77"
SRC_URI[sha256sum] = "99db999fe89aaa8b1274b40bff6a604dc2dd07780b0e7e3b1d6c940859900fc0"
