# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2a0a4e17c2abab1b58eca4e57df08414"
SRC_URI[sha256sum] = "6e619144a5e995be5a96090b35a73ebdcde381d50c0a8e754e9f472762603560"
