# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "09d6f3d419cdfc7c27dba9cee5d09961"
SRC_URI[sha256sum] = "c6546c2a0fc787b04ea40b22f3b8addddfe2f7151d1aa0fd6d76b964654bc4a9"
