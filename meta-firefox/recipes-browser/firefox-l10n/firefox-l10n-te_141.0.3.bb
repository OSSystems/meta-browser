# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "03b3b9d07fdae4edee4b7c68ac2f7cf6"
SRC_URI[sha256sum] = "b26cb312dcc98dd2cb2fc2fadb62d17a45cf169c8e43c45cbd69c740e9b72f9f"
