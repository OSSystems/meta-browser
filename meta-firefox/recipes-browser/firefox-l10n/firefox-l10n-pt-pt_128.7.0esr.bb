# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9259e8ddb3f94e1b9bf54436a0677816"
SRC_URI[sha256sum] = "6df0555f42802c794eb177ed2032def758829b0da1d56716f03bc28146d52b0f"
