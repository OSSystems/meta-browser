# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5b565e9a8ca5a0387d98cc8cb54937cb"
SRC_URI[sha256sum] = "d2c56214bfa356985701d78f3ad3c41b993ab18a4da85f07cdaa4c5e2abb0ca9"
