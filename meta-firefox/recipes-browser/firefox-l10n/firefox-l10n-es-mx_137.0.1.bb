# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eaa12248f696312108df742b81c57e42"
SRC_URI[sha256sum] = "4cea281f3b9259b23f56ffbfe63b1900c2a6d6fc3e03eaaa17da625acad9a0d2"
