# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f95d65a906cc80c61d45dd9c1a44dc84"
SRC_URI[sha256sum] = "b100d631be5031841129991be6dca39d7655766a040ed3095e9560c4f673df49"
