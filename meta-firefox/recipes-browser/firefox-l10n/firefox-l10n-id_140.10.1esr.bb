# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "30ea4901204d1910009da3eb47c4388b69364260086822a4b71ddf6587f56fb7"
