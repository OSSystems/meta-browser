# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1cd819a60f926c5e3e5c7e71cb2a1268"
SRC_URI[sha256sum] = "d922e9f407312327f376867fcddbe894d05e26acffc6c98b622fa294c2947b83"
