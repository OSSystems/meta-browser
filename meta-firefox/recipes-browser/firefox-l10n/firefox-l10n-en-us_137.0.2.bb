# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c16e9ee775fbbce9082a5b08ce82d104"
SRC_URI[sha256sum] = "245ae5ff789fe5ab5c76a4bedc6b4d3982f3172c763a782ded00bc36116e5276"
