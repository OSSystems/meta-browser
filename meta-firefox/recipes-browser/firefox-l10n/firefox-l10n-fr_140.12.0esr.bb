# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "4095078101d1334e7d120c02a3a0c413ad30797c0202e427175a3e8c922401aa"
