# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3ef2663754405459955d46efebd0357b"
SRC_URI[sha256sum] = "f8d46557238f8ff9184380f609a0d1f1bc0f76bd03d51bc208d79785f35a7e9e"
