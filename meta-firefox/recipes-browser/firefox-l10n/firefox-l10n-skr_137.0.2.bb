# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a3eef3e9e89b6a3fbe0b418e3d648606"
SRC_URI[sha256sum] = "c3cb729b95913f46f912deeeb56df518cecea072b390b8fad4a42e02bc5bf1e4"
