# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "05c9432fb0f7b0aa745d003fad182065"
SRC_URI[sha256sum] = "0ce056bd59c5d9914ee83d673265757c15c3d2ce8a5ae39e331c35b886ddb3de"
