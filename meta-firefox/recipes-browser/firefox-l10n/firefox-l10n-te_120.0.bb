# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "262d20016381b49f74f65bd1a6d905ad"
SRC_URI[sha256sum] = "583e03d77fc7aa4692c6084531c30d69cd01aa8dd557d00cdd5838d57b8d24fc"
