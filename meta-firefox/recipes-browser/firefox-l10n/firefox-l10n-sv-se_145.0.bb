# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fff8cc9be6736dbe69f24f7b63ed8e80"
SRC_URI[sha256sum] = "4306a4df8374eb5aa64e1ad6f45332906786389056b5c47b7c02b83a44d0f979"
