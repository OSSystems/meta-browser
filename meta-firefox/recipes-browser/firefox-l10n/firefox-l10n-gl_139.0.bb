# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9f471d977c767770057e966670d1de58"
SRC_URI[sha256sum] = "f6444852dcc1eb61ac550c12ce7e281c938f6d910fb16fa794442a9d71b18ee1"
