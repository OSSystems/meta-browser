# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1828eba6e5458189634bdc9f30c3265b"
SRC_URI[sha256sum] = "f7d340a626511504c266aa52376111468f3061614aeca5c06f3cf2dfd83adc9b"
