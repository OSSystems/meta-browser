# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8cc48908b8e94cf3c1eb735cb66ccab9"
SRC_URI[sha256sum] = "2e2ae720e5dbc69234738bc803248824505eed558ebc1f1317bb4145eb5ded51"
