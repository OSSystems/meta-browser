# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "573156c92fcaca2246084ff068efd1ac"
SRC_URI[sha256sum] = "6a1dc14e090a64140cb41e49259616646b0c4428bbcaeba096879b65c9b26c39"
