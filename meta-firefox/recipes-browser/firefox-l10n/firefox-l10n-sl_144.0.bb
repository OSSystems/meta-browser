# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a6de02d40dbef1034a0cc27ee1c2d982"
SRC_URI[sha256sum] = "60a972b27bf5a485e4368268bd2ac5248d072f9c3720a5d068a0435d4d38538a"
