# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e6371a3b8783bcc7778f4818eaecc469fdab4e0c8f7cf969a8db3741318a41a4"
