# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0cd0f1928dce57976f6a59cd20ea01c2"
SRC_URI[sha256sum] = "ee044d50424396bc6aff01f5bcc56711b255d796270fc51ef5b7ef7f6743992b"
