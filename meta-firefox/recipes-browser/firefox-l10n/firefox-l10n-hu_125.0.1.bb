# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8752016fc76d54dbd5515bf721d7eab7"
SRC_URI[sha256sum] = "07ef2d17dab716be35cbce3e8899e910d67ade719c5db14b40d02b0ec319f99d"
