# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e71ef8b03642fe1d04741443d8626a5f"
SRC_URI[sha256sum] = "2cb5ed005b73d2378d5baefd4fd01616aaee0f4df5e3adaec7308506fd86d7a1"
