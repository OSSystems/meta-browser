# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e6d51516066c5a576b70f8853e4e5b5b"
SRC_URI[sha256sum] = "4d1a4480a3f7b07faa0b0ff812f2f8f55e7a096f107be1a3995a5d74464b7540"
