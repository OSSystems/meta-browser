# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e3feb07c1b38d0c8b992073da7df8cc7"
SRC_URI[sha256sum] = "d606053699bc15212681214dfb51f3000d11c72256cf1e36a3a2392b9a525577"
