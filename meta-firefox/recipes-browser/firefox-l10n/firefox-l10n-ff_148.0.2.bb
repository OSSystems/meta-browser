# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7012e76b311a1f517a72d10dff1776c2"
SRC_URI[sha256sum] = "fe9bf9dfe1d531686a57144d2be742b859eedcac583e662dab67cd3eeee82937"
