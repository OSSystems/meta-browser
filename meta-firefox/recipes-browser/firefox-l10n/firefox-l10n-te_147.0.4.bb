# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "266907b9af77680371d627ba38fea12e"
SRC_URI[sha256sum] = "a30a64a02026e39d10a5ceef7648f9cf3a944c77a8f1d9dd0a60bb894d965273"
