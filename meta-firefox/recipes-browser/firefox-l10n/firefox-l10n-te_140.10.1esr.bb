# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "db3b50e687f6d91a32c02a413683ea9eec10ece60acf8cdd23be54643a44ad20"
