# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "442e3dc46c804abd7266916197980990"
SRC_URI[sha256sum] = "e21f9f3c0bc68dc803b7d8d88b297914cbb920a776215e3f9d22ffc61ac87864"
