# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "60c6cf20578892da04afed2a8b7237f0"
SRC_URI[sha256sum] = "a5dbbae0a6b2263d080b02c418801bc343f49ef5b65d1929bc101e46cd8bd9c4"
