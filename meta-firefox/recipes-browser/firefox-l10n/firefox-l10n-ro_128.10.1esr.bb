# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5f60d8019112c8560803a46cd9d807ad"
SRC_URI[sha256sum] = "f888319f5a358c76945095c80f0edeeceba1395f93dad8011a8468b71d490ce0"
