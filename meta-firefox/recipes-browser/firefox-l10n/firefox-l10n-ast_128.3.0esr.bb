# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "03dde5b0885be954e4800d8c69bde7d3"
SRC_URI[sha256sum] = "8552f88da0d5a1cf38b46c31bf95cb5627c54b8714248d03f28aba68dc213723"
