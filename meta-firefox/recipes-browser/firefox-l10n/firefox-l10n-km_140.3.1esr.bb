# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "141998c4bd3d7162a31d62578881f48e"
SRC_URI[sha256sum] = "b11b00fce9e71fa75bab89d793248a706f70c43e2b3cb902f044618e5637e7f4"
