# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c41d1a0463a5e6e19314878b65e5679b"
SRC_URI[sha256sum] = "c4e281da393b7092ac1ef53640fe2021b7252949c6875924f4357c08f3d05735"
