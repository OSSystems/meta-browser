# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1f3238224ab8b4875cde200eee323bc3"
SRC_URI[sha256sum] = "d185546c0b225bdf37134e92d549b4adf3551da595b5e4fc52ab114f04ee7d19"
