# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db5f777d402d5e575b742e177c38fd35"
SRC_URI[sha256sum] = "3598192bf492d6621424f3ef37c93793b5bdf5dce04bcde328b7925e6a865a76"
