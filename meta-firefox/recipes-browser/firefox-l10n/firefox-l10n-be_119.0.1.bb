# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5cae2d36ca2bda44e77d051b46c48d8f"
SRC_URI[sha256sum] = "c3b5e18363099c8ccaf15509371eb6e92f0f03b5241659268c2b76dbc58d005a"
