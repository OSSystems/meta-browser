# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e1bfbabf06d0b5a2234398215b4b7630"
SRC_URI[sha256sum] = "ba519c5f8fc34f90e4ff4e352e271a5997023a89422c29959729953faecc8311"
