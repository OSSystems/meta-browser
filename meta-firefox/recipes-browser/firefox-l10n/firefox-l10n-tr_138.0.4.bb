# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "31d567b2c10e456d7daea651050dd349"
SRC_URI[sha256sum] = "0bc73a240b3c86f069418d6da135cf404c279c7edc44484752480505456b899b"
