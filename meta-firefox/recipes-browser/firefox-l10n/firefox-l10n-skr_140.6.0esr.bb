# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6ebe84c4a0d61e785f68bcfcd9318033"
SRC_URI[sha256sum] = "3814b84b9525ee73c7d8f8db9bd15e9060944c695a1237c8f53aba23f7d10063"
