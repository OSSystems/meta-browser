# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c39d993e86030eb115e3b27ba9ba8eb9"
SRC_URI[sha256sum] = "2f014075ebd0ba2ad4071ca0f326347e6260176be87ac71bea7bbb88c2386e8b"
