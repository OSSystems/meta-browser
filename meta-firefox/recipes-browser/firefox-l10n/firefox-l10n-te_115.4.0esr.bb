# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b6ae2ded7b69f3afd9843d29fad60962"
SRC_URI[sha256sum] = "6d31414d8b499691e07e622ce5ff08fe7297fcb6a6ec78488a5820b1ad86fb10"
