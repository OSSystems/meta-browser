# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0ea1bd8c8ab8a3d85ce5ebbbae4a1d2d"
SRC_URI[sha256sum] = "ef77157f71b81fc1097b812c1f810000de9acd40b2bdefa95ef1b1eca6fe9f8f"
