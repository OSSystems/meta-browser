# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ea0e4a6c90b9e5577e9dea63062f68c7"
SRC_URI[sha256sum] = "b4754b3c15019b4302d14a8ed8067ebe06c043f00028cdc1c59e5da77ead517e"
