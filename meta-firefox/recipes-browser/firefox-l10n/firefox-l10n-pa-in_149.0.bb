# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d39e0ea0287b240d8c8f9067d1a95a14"
SRC_URI[sha256sum] = "f78b03a6145dd6d96e27f000dbd07f981708da70ddf6cca90b3d280d86c60f40"
