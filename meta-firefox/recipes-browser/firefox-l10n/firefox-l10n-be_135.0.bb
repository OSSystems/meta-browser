# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "de8dcaa7f91cfc3af567a521d97ca287"
SRC_URI[sha256sum] = "660d5100d4b58426ff452d33cd62d8187371d77bb9b3aeecc4f72adf64becc5c"
