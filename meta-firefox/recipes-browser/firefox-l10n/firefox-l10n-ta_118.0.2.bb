# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1a47897e938fd8d03c0d703b29e07674"
SRC_URI[sha256sum] = "0f94c5d4581a521c081a97ba0b497dca4f0ce802ff90b024a2143ec5d5c919de"
