# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d890c74e73ba258907fe16d0ca000a46"
SRC_URI[sha256sum] = "0edfecffcb79ac9a47ec20b0a7d5b252027e134c97eb93ae8a22fe5aa8463b4a"
