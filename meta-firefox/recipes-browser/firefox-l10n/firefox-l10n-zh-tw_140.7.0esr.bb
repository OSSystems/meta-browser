# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2adc3bfc9157a0449edab3aa9d1f7461"
SRC_URI[sha256sum] = "9ecdb5edceb73ce287b50cc50e1220d346e12a3b8c969e55538adbf4da17743e"
