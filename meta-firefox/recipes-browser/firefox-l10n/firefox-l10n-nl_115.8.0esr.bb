# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d2ae13f5493eba205bf06d441bd0d8a8"
SRC_URI[sha256sum] = "f394b240a50682a5dbe28cc32d79673398c9d09359347f0342cd404a9a4244f4"
