# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e063dd5d843c7d6e6040420e5f342c5d"
SRC_URI[sha256sum] = "ec19654a00bef4ef336ec1c5d3d8717c9914e4a323e79ac1ea07497d8c722aed"
