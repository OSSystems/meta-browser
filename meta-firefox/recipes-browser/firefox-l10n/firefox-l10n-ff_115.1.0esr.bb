# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ddc583f046c110eb88c400126784d750"
SRC_URI[sha256sum] = "2be01f7a0408c90d91e2a417788b95201f720e43871c460afe01c516128db5a1"
