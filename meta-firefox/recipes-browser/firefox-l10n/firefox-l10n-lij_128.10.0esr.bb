# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3468f1b12e744ce6349a14a69b71ea3b"
SRC_URI[sha256sum] = "7030b33d67e4364e7bae72bc39b0597d9ac67764e4708c41a0b91a9be146d149"
