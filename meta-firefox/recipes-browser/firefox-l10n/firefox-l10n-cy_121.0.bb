# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a6d992aeb66df52bbeee536fde14f20d"
SRC_URI[sha256sum] = "0c4e646cb202904ba7b8d08daf64fc62411488a184060d8a570a58def9c575ca"
