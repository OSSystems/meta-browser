# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6d12c2096861972a43a4952e7f26ae1c"
SRC_URI[sha256sum] = "aac32d457d241c70ffbe62eec40f86b6820ec35c1d28a950c56136910b9365ae"
