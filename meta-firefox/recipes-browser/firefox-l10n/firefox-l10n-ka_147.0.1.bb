# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "221133f811e558f63de15fdbc1f9bb10"
SRC_URI[sha256sum] = "0089d3ab2580e22d7159912366f25d5b0c019b6d85df6833ce0f3ef9611e9482"
