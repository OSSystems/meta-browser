# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e961e9831d1d2dfa44d11fc57a823222"
SRC_URI[sha256sum] = "b5c043f7b4befff5d3a76bae8e5a0dee4d9ad4f460246793afbeaf8893697aad"
