# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "de21dc0e97c27cced9c149b4f6a42826"
SRC_URI[sha256sum] = "2712c273e1d82a30bb06761ff95e298c20cb0c3ca541a4b78fa8fc5c7f8bc6bf"
