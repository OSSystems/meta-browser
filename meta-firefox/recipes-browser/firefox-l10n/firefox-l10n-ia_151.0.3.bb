# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e64fe4773d75c4c22eff301e3c7fa0bb10cb1fcee8265d5ec2b5abc49772c687"
