# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0899e291f1a0089620b29e94c6d9c27b"
SRC_URI[sha256sum] = "14330c5cb4c576701606f0934594388f185d5a966556d8238a42b989a9d10c44"
