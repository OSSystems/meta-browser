# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "55f7a9f0ba5907d02857b3c9163c5c76"
SRC_URI[sha256sum] = "76fa6d0b3d348092856441cabb9e60f19804d0a47dccecb982f671d8ae5435cb"
