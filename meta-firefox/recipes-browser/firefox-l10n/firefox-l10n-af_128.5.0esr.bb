# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7bc7592430df1270fe5f7c79f3d9e80e"
SRC_URI[sha256sum] = "95b12156a0265d7e8e7427681d7eaa1d506e2838d84a74571df929561e3ee7a8"
