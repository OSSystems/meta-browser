# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e71637e1a0b37d897aeae63e5a0ee9a4"
SRC_URI[sha256sum] = "92896b0ce4d54bfe4df3161694192079bf74bb8862f88e7efcddd0e9048f4e98"
