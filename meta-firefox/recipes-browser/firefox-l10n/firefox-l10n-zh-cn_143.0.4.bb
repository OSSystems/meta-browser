# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "325ce55ae453223c5d2b838a6ad9b5e4"
SRC_URI[sha256sum] = "f6af44e2b6e790339b05ba8865561c6b5279e3b661489963e6e65550b9c07e7c"
