# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fe483c36388273e3ae2b8f1f45cdeffd"
SRC_URI[sha256sum] = "ba75d2460207996e665890868b7b8b29c8c31874831beb73b9b458aa6d9b7a30"
