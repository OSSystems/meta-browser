# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "74e645ed7e58326a2211260695c558e6"
SRC_URI[sha256sum] = "87740bf02a465d3c1def5b2e736afa8151df2c8853e492f666c5b96b1e6ab4b6"
