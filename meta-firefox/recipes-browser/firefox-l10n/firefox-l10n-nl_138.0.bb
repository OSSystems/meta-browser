# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0f11cb94d4e6b1c1b6a64b641328843f"
SRC_URI[sha256sum] = "37680433d255d003dc59e91623afc881f4651d61e8b13aa97ac77a082ea038a0"
