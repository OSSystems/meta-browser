# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "89f85ec72c1c22230c030727e7360116"
SRC_URI[sha256sum] = "2e3924a2f49fcb5b9134d5a8c628e8501770b8841444addc2b99c2c6e7ff8d86"
