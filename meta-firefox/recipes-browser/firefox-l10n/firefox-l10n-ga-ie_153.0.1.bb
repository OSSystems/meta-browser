# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ab47edbd4ee4ce1f1ab7fe869ee3ce5d2181842ad8fe462c8870d6799af22aea"
