# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "00bc589d872a9de19b0a757c06098018"
SRC_URI[sha256sum] = "90d5da3f454d33b9e6f97cbcc31c943d3d473d946d01b0729868b41405cc56e5"
