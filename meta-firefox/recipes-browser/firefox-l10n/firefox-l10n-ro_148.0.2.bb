# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4e2232ec3ad1fc97e3fd16c0adb372af"
SRC_URI[sha256sum] = "7836527424f021c03ea90df24d9eeea52bf9b3c3204c08efd17fa549933924c0"
