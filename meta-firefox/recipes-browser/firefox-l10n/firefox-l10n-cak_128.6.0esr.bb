# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8ad28de84921163cbc3566a248d18cad"
SRC_URI[sha256sum] = "c5e83622f6be8a1233e2de14c3115a3a6314be50842a8d8d3fa148e02af8a7aa"
