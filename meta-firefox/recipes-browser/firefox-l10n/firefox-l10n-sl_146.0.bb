# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1804d0cc62faa6921f0420c4cafa7d7e"
SRC_URI[sha256sum] = "fb1e476132700ccce60bb4b9798b4d13ed36c8aba4eb6320b7390daae6fd87f7"
