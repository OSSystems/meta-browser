# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1ed21164160944e697c3c30d550771c2"
SRC_URI[sha256sum] = "78dd4a1968e697191bc073a7d85d6a40d27a423f0dd4165e1e5b4939948b6b65"
