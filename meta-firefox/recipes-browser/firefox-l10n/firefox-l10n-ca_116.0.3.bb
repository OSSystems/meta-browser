# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8f0c9f4af4f818b105a1128d78b5486b"
SRC_URI[sha256sum] = "2c799a505f26b5653df3ace594aa1bfdc46b7edc28df3004c681936feecf8fd7"
