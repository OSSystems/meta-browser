# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d54784fee093e28adfdabed6cc4e3ea8"
SRC_URI[sha256sum] = "7f9da94cb9521c4cc8cf6913e63f9b27df36872caa2515f32c0dd0d746f305e0"
