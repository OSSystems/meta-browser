# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "27703599e2918e37f614bbb178e284c0"
SRC_URI[sha256sum] = "a2a90d92bb4dfe2140a8f80ab494a9c6ee175a88f9f27a0fa9a034d12f39a4f1"
