# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d5c4030299435236aae1b75def4b674e"
SRC_URI[sha256sum] = "a2f9336e533a2e5160f74c79d0a24ac2ec3b0e59731aff3d1467a6f8e6e4499c"
