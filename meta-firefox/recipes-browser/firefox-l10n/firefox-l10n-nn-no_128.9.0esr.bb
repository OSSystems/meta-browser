# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c40f9fbb812d81d89d09da930781834"
SRC_URI[sha256sum] = "19347424c02185735cf9defc4dbefe9759689a8a7c8e534cd72d7feee36634b2"
