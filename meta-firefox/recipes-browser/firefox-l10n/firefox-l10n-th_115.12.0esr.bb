# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0327f549f25f89d7f18303a53bb8edda"
SRC_URI[sha256sum] = "7ccf461e4cbb0a5d1da32b866192c40fc8c425098d93897cc9837dae5092c869"
