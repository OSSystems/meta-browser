# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a7ba0925d7c42e63290ee715634b359b"
SRC_URI[sha256sum] = "09625fcb500bfc0b95de914a9d1adf52c24b420f0b3aa9a36e9d774cfbad62a2"
