# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0a7e639e8d8d68b3e3861c80c298c1b9"
SRC_URI[sha256sum] = "81e09bec1b8e4c3aa1bb0be51674c54a86cf09d61edb9bb1855347b0d76aef15"
