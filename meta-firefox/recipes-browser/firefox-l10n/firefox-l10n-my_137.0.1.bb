# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f99bc8698cccd39634bdd483fcc72573"
SRC_URI[sha256sum] = "7920456056c2a281c6538f2ba2b698f3e91d8ecc92f28d3d85875b512f910cc4"
