# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "71c9c2b117684b6e8b1582757e4c4d31"
SRC_URI[sha256sum] = "7b040e26b07040449d7d9530d64e3931bb0ba40fb306d8b165431c6b8d99f5b3"
