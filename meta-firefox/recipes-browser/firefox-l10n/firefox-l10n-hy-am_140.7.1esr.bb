# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "88d78490caf92399e03fe005923f284e"
SRC_URI[sha256sum] = "26a120476b0f13d8e3cc7ee81dc952fe66fbaa28b945d4b4974e51f8ba7bc604"
