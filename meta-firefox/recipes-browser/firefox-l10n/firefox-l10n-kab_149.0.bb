# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ed46bf288cd00e9031667d62761e84cc"
SRC_URI[sha256sum] = "e5591065ac7b582c068ed11a08f98ec3d841cc401e96af153e524f0970fd44c9"
