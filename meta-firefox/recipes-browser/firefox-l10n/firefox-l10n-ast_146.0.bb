# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3d312a8e5b7ef33e79ee0d6b5c0c19a1"
SRC_URI[sha256sum] = "6a3c1448c96828ed2a103d0fb654284249c7ef130ed5576dadba716c6d68340b"
