# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4649b8bc3d3e0bebf2f5960fd94d0971"
SRC_URI[sha256sum] = "7d905dbb076e2c6bb6f3a59f59e16162faa4ad7b538d94b9455e225a575afd00"
