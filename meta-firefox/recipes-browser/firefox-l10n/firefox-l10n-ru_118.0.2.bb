# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "36b12c450372fdd8685f138c18579214"
SRC_URI[sha256sum] = "27bb744aa434f6f63e8be63e33a413cda9b740a8cf7f58021b63255f4bfcff5a"
