# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4871c1a64737fb3b0b4443f34f551af5"
SRC_URI[sha256sum] = "ac7eebeb982dd433f95271a5331942b5b009072faca73daad65c689cf8cfc27b"
