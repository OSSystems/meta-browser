# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ade5626f39c8bb1e7f917f10f2c06903"
SRC_URI[sha256sum] = "7f3f2ae735129f747e593a39f902a7bb82f5345e9456b14539719fa99e8eaba2"
