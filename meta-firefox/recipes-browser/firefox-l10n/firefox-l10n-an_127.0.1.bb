# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0ed04d7e568c1ec157216738e81d9a2c"
SRC_URI[sha256sum] = "49885871c23851719e2cbcfefce258d43c2c8c317982261ab859a7f243c7afa4"
