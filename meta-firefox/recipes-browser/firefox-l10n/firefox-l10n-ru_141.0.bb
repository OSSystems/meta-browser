# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1adb7830452d88ff8bef0656526e51f3"
SRC_URI[sha256sum] = "a86ac1f0bf898982a97500f3649d63920a0a2ac5fde035fbee07c0683458e1ec"
