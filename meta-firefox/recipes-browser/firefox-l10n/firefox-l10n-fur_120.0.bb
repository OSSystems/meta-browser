# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f47ff310fd23eab30410327d55861260"
SRC_URI[sha256sum] = "09bc22e460d5d4e58ede1ba5215d9284edcb0835211b81a9d54353253c2b5e41"
