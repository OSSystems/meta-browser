# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a402163733b7d076efd6e28171ca17fe"
SRC_URI[sha256sum] = "6dea8f2fd7f59d9124b76eba963f902be2c1057f621503cab2b9428ea906b183"
