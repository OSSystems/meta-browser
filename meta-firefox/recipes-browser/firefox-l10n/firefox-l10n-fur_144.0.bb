# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "898d090deecc7eb0118595f44d563360"
SRC_URI[sha256sum] = "e03918245cce3dced367c686f10449f533413f310788fa851cd6a23473e3dc82"
