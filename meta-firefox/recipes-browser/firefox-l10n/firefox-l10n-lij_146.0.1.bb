# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "70f3ef57ab2230e9b7ad33bd06784bdb"
SRC_URI[sha256sum] = "0b3ca573479bba0b76be11ae3d9b0e1c27209c1b528e40d5c3da0fcf0c08b9e8"
