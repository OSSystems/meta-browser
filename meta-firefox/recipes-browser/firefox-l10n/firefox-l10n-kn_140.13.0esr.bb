# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3004466e43f844263d1668bdbdfc4f0e8f5a1c56931f22184014604d013c7357"
