# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eca0f6e541c12d90f8ab2099773d00f3"
SRC_URI[sha256sum] = "71259925efd4c06040b7f92ccc89d4275caa8ae291880fcbec830c97fcbf37dc"
