# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "196f04a58d093b2f297c5af0ce9bd862"
SRC_URI[sha256sum] = "749375b72a8d781d230c111495a21b18a0f89df3e37457359975c3837d3a1219"
