# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ee0ec3604b6c8c2cb2a18e32e0fbc1cc"
SRC_URI[sha256sum] = "74319e5aa6ad8cc334a6690a6f16f71622d3ebe4ce582c80dd827640584158af"
