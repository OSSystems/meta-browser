# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4c906b8223e116a3fc07d20c5b076903"
SRC_URI[sha256sum] = "bdd408139b076581b2930be430471ca85697597b31427dd9528ce51fef90e3f2"
