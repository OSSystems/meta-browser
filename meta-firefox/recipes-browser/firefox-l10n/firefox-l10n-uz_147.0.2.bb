# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "16d5ff7017c3bfaf37c375c88def4bea"
SRC_URI[sha256sum] = "d6fa63de505b5c5712a1d554fcce83a5310bf73b6d7aefa0832affbb3031dd82"
