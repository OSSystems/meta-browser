# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0a3cb03c0c0ca506d98701152c8eb72d"
SRC_URI[sha256sum] = "e63bbedc2865bf0c7107fbb764099929b7f691e0edaf42afb28ae2db12c4029d"
