# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e193bbec4b9007e1acb73cc31d992a105e144d7f64b3fbaedab244fdeda06db4"
