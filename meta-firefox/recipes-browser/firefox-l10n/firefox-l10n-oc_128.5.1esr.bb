# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "003eb150be5654e00da45cc86a464c93"
SRC_URI[sha256sum] = "79cff110733d5ba63d489c3b471c311ff5ee3c053ad60381c2a7a3d30be97e83"
