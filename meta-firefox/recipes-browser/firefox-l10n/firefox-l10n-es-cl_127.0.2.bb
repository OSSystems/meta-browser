# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "03ef28c06c9a412ed852fb11e5f6a567"
SRC_URI[sha256sum] = "d98508c0c278fe8c9fe5e5a82e9afdc19e155704253dbbee9ab236f4b67c1a78"
