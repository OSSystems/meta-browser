# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a37d38c07d0f20f927ebf106d6240d1f"
SRC_URI[sha256sum] = "dfc6e573da1dd64e67a72450f2dac8130cf7b9564e3557904768624332837a64"
