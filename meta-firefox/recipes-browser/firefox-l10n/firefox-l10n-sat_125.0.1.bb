# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aefb4a1b509c8a3435f70910654e24d0"
SRC_URI[sha256sum] = "552d83c4bbc57c70d8948f813cd191b4815fce6771714ff8aa3c66543fa2fd8d"
