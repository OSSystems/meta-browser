# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d99fe0d6ab4fecaaddacc25dc2fb6135"
SRC_URI[sha256sum] = "fcc72607bf742cef62fd6ec04b28dd777bc43525a5826061154c11f223481748"
