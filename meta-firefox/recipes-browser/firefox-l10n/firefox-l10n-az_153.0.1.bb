# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "03694ff866c0cee48d3f5a914a96d745f6ee47f8b4517252afd0b453ba475d56"
