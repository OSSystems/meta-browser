# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cc722b272afefd599b7df3b2f2c35249"
SRC_URI[sha256sum] = "21891ff5cd7dd86f6ef1655efd4dfe520afe25831c372a85899335e1cb97d001"
