# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "bd334d9af7944725480d56f08e9d5691c4aeeada21524732d25970054e3f2ad8"
