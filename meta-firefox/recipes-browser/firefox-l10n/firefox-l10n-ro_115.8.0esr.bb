# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2607febe4f92da5fdc2e70ca37f27f09"
SRC_URI[sha256sum] = "3479635066c58d4aff798f0eb7ebb3ec2c48b7a68315f9b6f44f79ef8f4ae3f7"
