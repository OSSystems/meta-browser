# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2f41ef21551f2a579868d222dc5953fb87093bd882088ff08cd33f723aee6339"
