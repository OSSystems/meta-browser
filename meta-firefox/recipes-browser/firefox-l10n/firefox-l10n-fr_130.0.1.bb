# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1698a23d2eafaecab44b769604869ae8"
SRC_URI[sha256sum] = "cb8b1ad0c58774aadef65d7712fa25fa6d6e01ef2028862702a97dc8cf0f44d3"
