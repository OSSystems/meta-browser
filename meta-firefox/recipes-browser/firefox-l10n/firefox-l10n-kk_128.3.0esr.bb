# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f0f3302dcd9011d3705b8a711b6f9be7"
SRC_URI[sha256sum] = "76cafd88254fab3762ab0a86af67a5377d6fd050bd4b142461269a0e67c47f60"
