# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9eb80579f85e7a60f52dd04051c56ed4"
SRC_URI[sha256sum] = "598a4c18445f6d7be45b2d27d03e9388ba094b04cc29b541074e0672116aa924"
