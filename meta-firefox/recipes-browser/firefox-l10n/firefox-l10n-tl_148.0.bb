# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7bac99a521af51df2ee63a97af279752"
SRC_URI[sha256sum] = "6197b6ede2fedca03572baeb3a38669e990060b1860ed8b646b3a3fcc7f6c908"
