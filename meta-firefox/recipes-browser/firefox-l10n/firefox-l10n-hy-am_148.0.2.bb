# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2474a23bebe32594bf34b89851673abe"
SRC_URI[sha256sum] = "dc622bc7a7d55f38898c5dbe3bdaa91a25b3a0699b99543cbd6aa940f9f9d55d"
