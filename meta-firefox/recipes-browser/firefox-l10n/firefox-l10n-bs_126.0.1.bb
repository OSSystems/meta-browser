# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b2caf52bf584a16846038c7ae844665b"
SRC_URI[sha256sum] = "f4331f90ab592a2423d7c08d4ee3639f97ee7fef0b3a220debebd068e0e87067"
