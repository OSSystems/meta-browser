# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "05bf417b25bb94c9b7296426990ac2fa"
SRC_URI[sha256sum] = "f32002b6d5cb08c6e9d9fd1d02c27c36f84104f758f0b685393dcb2db9d086bd"
