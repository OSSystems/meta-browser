# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "263f224a884754863d95a2948c748fd6"
SRC_URI[sha256sum] = "ad357ba0b200a0c93533fd95bec284a0978c2464a6c663f34df72f43a9045dd4"
