# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "058e2f4f81036124ed27ceb1fe3b4a92"
SRC_URI[sha256sum] = "cfa1313b5ac666cd3047332ca63decffb483f2aef3d0e7365aef8c4f457efd26"
