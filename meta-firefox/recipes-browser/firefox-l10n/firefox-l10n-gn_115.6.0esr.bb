# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "12bb779aae955ce5e01ef25f154564d6"
SRC_URI[sha256sum] = "ded3daf98488ea4387616ef4e18c127d6abd0dd1491aa4ca40659116c4c898cb"
