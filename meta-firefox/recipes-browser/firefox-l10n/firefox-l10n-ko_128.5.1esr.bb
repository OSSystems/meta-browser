# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fcbe94da121310af6e808a18c205a7e3"
SRC_URI[sha256sum] = "9fdab02017fa96dd1f828a9b1a76ad85b1251809bf6a5085e25617c22b96fa87"
