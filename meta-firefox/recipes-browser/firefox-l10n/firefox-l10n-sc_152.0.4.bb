# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "8c73b7cb8af93f5528f2acaf43783f37e100097e809220b36df719aec3271752"
