# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "210995fb687a0c5dd413651e355921eb"
SRC_URI[sha256sum] = "a99a891c9dc93b1b67c0f5670372ba789494e22e7d15d6289b14f3bc041b2e54"
