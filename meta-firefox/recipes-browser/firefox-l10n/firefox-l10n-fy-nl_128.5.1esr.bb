# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "83f29b1cf8c4feb3e6762db2c6bf4528"
SRC_URI[sha256sum] = "f253a460845831a7552e7fd8fc1faeeaf88c7e921708e6aebc8c499cb8a4fccf"
