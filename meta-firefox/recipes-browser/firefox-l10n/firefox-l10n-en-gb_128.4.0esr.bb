# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "495e87e3f4dbcf5427d5890e5bb793e2"
SRC_URI[sha256sum] = "51e48d63c253336688f8b38dd8988d7701781546751f7ed5830985ec0f7fb5c9"
