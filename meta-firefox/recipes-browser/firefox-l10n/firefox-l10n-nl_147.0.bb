# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "31118576aeadef35f9d496e9e796f5bf"
SRC_URI[sha256sum] = "5d86a75f9fe5a371beffd92cb8783329639fbced00669129ac5b81a372f74ba1"
