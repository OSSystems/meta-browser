# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a1c2e95c9c6772dd377109b428548f39"
SRC_URI[sha256sum] = "7fb3d9ce2d053e1ad2cbf401b1d64ac6521959ffe7b0c771ee516d845aacac29"
