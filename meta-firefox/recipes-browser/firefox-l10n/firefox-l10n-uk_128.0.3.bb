# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "78c4ba3ad9cfffee65857a3158be0aad"
SRC_URI[sha256sum] = "76e1caa97c69c14e73ee037c0019a9f26440d7c5b939710fa6c555946e64ee04"
