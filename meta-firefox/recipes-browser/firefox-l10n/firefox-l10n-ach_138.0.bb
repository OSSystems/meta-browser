# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b9a84e25a3526cd4cc617c128927832d"
SRC_URI[sha256sum] = "7e7bedc7ae6d6aee46ec92676c7eca6c1f4536fb56fd4c279c11c67e2980712d"
