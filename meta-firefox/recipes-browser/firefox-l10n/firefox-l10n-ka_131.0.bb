# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e1b991cb12a4e7f6dbf5a18345d4ed04"
SRC_URI[sha256sum] = "895e58a3aa4aae27fbf57e357e57632664c5678b4e1815b0aea07a85a52e6300"
