# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6978028dbc4b29a0466480295a053e31"
SRC_URI[sha256sum] = "19805f8386836b4e62a5f490182278852e7b13392a1f40976510d3bbfe9dbee8"
