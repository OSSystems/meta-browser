# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bdcd73dd26c5ba76d864e585e16d3517"
SRC_URI[sha256sum] = "0eefbb40222e1915cd2a70b371e6434e01194549457e118e24d30e2c2c9f4a87"
