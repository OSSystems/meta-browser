# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dc0e88c631090f6786f291f31adafb2e"
SRC_URI[sha256sum] = "eefbe3966641779c61100ced4d042f0052d98bfec69feed2425516ac7932b498"
