# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "0c8e1bfa5c8d8f10dc17cd6179baa2fd54b64ed88e37f9e7269fcbbd70d55c16"
