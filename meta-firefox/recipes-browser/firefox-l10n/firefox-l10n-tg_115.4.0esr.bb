# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "589322707b122f62a435ed408ce704fb"
SRC_URI[sha256sum] = "c3828b5272666e3c38d96a93d70f34d43e2ea3ff4742881b1b909915cc825c63"
