# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "4ebe9c10a6a42a8e0a31bf9aab42a7ee73688f2d5aa1f0c0535361e13689820c"
