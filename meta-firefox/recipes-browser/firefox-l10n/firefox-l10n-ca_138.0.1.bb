# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bdc545e064c7acee370f958b609d9607"
SRC_URI[sha256sum] = "1031e546563ebd1dc8406b82ec60fe9bcbcaed7021eeca7b696ade40ac5c9184"
