# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7cee5a8a735b56f6d3c120fed5a42a29"
SRC_URI[sha256sum] = "d00ce161f1248d87ec2c8b51d5a61376eebb9d9010f50d92bac69c92c4159c18"
