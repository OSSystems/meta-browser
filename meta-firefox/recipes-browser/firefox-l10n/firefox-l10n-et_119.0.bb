# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a56c12c0bcc40f4f24e467cdf793a447"
SRC_URI[sha256sum] = "83aa1738b48f462362c85736b622d36daa3dc8374f47d4362723b354ca8a4185"
