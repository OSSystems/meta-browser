# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fe2b43f330a20cf227bc392678f58efb"
SRC_URI[sha256sum] = "34641ad46962a56d6adb1c49a6f892193d6b7fa717f610e04ef26892249e5582"
