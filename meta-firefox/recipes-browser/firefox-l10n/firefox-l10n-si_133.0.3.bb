# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "52588a8e83d8ee1479d71d9c6425dc5d"
SRC_URI[sha256sum] = "98fa49477531dac137c29dd97328e10a5a7022ffcd0f74492d390d351ed88a81"
