# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6e3054f660c31eafa09684b23a94123b"
SRC_URI[sha256sum] = "464969680df831bde66d9d3e601d9046f2ba20b175d54df345b70e61de72309f"
