# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d82f6b7a80dfb91387cca67ee4e680e3"
SRC_URI[sha256sum] = "f34052a12daabb8ffe5d4cd79f4137e3555324ce2aed3792adf7812f80f7c4c0"
