# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e8686aadb17fb5d91aee83985f7e749bae3f29c6f85f4c95ea83db1044490cc6"
