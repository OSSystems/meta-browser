# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "224cef04fd12597e4a19e6779aa53799"
SRC_URI[sha256sum] = "4c5251b3a5173b5cac217840f0df377c0ac6ba662c1d2e56ed50f2e1b8369cff"
