# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "92cbb41418136dfc223330a41b1d10a8"
SRC_URI[sha256sum] = "3208edf8da08c93a31471999375759c08a3ed5674d47b5d2327269a7e36b1c5a"
