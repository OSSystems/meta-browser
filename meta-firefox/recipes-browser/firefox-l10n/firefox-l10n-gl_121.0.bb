# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "53368ef5a6bc93f209f67ca16fad336f"
SRC_URI[sha256sum] = "ddff434df1ee69c2a23621b9e2c09464d76e6690b7edadccdee9646fa7900288"
