# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "02040cdeeddb725ba9716b71b1a4d13a"
SRC_URI[sha256sum] = "211deeca3ffa471bd0bdc2b5ec51d4b0fbcdb1ac2b8497c7494e45d6b4bdbac1"
