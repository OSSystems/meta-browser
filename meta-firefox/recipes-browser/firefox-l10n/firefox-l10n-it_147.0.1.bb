# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "39afca7ad26c2ab12390471846d1bd23"
SRC_URI[sha256sum] = "570aea404f473265c7d97757f2db7baf988557fe8022be4b1d90b9dd1bcb2fcb"
