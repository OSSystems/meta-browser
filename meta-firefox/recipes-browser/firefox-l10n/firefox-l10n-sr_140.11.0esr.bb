# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c70d82622ceef90e78d11b6b94fa489e44ed93c6d82811debe3016a9698bb820"
