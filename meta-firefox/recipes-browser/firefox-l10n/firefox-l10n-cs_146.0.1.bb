# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "31a6ea74f532151dcd689391eb14ccce"
SRC_URI[sha256sum] = "3ab7a76b32bb7cf68eafc1ccc17484d4dad56f84969663983d2aa17093631f2e"
