# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6580185a6d98603858221305e9d9eca8"
SRC_URI[sha256sum] = "2f56c50c9e64fe8c3fc89702bd8ecab2dbf14c4df049d93c6a6c30e54e1bda78"
