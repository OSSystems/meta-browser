# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "bfe035563b4c7e0db51200ed2f72bf019f5bf2279916c441ede9c0d5f5d2f925"
