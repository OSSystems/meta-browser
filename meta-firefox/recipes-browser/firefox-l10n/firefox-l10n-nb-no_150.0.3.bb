# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "9099fa6425d6168c5bfe5bcb496b8564ab300aab801b8031c16c0c18a48f9f0c"
