# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c63d34dc665e236926f0e4317a777914"
SRC_URI[sha256sum] = "f43d61ad20b12342d4c86466f375053cb91add7906b2ceb420b5b0a6da798d29"
