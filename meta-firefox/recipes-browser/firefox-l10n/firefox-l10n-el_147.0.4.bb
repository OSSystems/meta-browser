# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "432abd2a8e7275af4e7d14c72675e6fc"
SRC_URI[sha256sum] = "769a3d9292d00be05a5edb638d4ee75acedc839ff5d72715ae4a685512cb88e9"
