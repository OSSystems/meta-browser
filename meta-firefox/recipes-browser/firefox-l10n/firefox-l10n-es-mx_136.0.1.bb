# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4bee334db9e2c854b68b94daf6cf7d5e"
SRC_URI[sha256sum] = "5ba057e66f70b5b23599cc1578a8c5d12673573435bfbcb854feaa5f967a065a"
