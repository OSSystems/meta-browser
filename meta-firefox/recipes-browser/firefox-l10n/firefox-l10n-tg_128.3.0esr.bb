# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8668ea798a1b9d0564abd807eb5234c7"
SRC_URI[sha256sum] = "326b9eb1ca4ddd5fd68b913623ee65c81a90bab2b16631ec5cbeb8a847f8623f"
