# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3db781e734205e9b26a8bc3e8fd35109"
SRC_URI[sha256sum] = "82c59bc761a5d7afaf1afa924a6cf18ee8994960bb5a048d209e250d9f9988a3"
