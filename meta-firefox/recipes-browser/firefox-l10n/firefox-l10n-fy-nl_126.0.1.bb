# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d5dedae31558b7949520f756b1db4cb8"
SRC_URI[sha256sum] = "79189e955e2f99e8c481aa372f69d14e926cc17eb6b18b31a2f97a5d943f15dc"
