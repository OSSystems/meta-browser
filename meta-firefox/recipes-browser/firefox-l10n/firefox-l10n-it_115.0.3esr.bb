# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "967b517d1d6f803d77858f0e4bcaaa58"
SRC_URI[sha256sum] = "e59d92fcd663a53620d3d977c2772bd7fc63916fe094e1de75284000d5270684"
