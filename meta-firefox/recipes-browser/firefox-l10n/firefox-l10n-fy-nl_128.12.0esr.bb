# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ea23c9549cc0cb168598d95962a5de45"
SRC_URI[sha256sum] = "d82f6a4e6afa62213a1e103779ee523ebdc379b7aa965c0511553811fac77c2c"
