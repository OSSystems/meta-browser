# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "513caf7319173421c94f31bc212924bd"
SRC_URI[sha256sum] = "875ef4f803aeeb4af4713cf3ce4e8b82bbb66941f008fecc0d2cbb39b5391baf"
