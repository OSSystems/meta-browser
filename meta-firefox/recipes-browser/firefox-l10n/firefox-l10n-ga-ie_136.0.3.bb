# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ee3d978b07f00474a1b679ffa6eb917b"
SRC_URI[sha256sum] = "d360df3f207c2d272840e03cadbfd860b7b5770e1199eea9d9d72340f312675f"
