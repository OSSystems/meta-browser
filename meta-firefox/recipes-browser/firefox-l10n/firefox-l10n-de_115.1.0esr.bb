# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a918f987a0461dd0abbc422e39c5b7f9"
SRC_URI[sha256sum] = "132b5c0f419e9c4e6917f28b1259671bd1e244314c3308fa06a86e5a0907186b"
