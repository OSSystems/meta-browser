# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3741b0b1eb804d61d41f52c03dd7a04f"
SRC_URI[sha256sum] = "be8297e99966168fa62cae4efabd2386460aec71652d61afa74223a1053a4e56"
