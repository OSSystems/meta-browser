# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1c7761d317d713e9473c3bed8ef0066d"
SRC_URI[sha256sum] = "8514430e2a1122a8ea9e572268216bafeaa6b064ae804ac8093021c278cf4fc7"
