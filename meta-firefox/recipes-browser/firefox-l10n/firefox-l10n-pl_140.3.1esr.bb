# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c7033ec562d526c5e7ee93d75019905e"
SRC_URI[sha256sum] = "26fa85bfc922b711bd7dc70f204f9dc631ab0a16ef068ec77e6f929dadfc017e"
