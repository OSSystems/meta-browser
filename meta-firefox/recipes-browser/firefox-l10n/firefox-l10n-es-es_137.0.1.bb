# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4974935495feecde5d4e50c174b958ac"
SRC_URI[sha256sum] = "6b65a29ef6277dc7724685b3c1d3582f38bcdb1aebc7c98ed35f90ee155200fe"
