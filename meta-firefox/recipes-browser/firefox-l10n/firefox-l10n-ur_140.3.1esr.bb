# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "14e846217c81f4ac254dedbd0fca0c0a"
SRC_URI[sha256sum] = "dde0bc8afdd95d2dcaa93a6f1a178439088d8638c0ce3a24eeae32fab8fb86be"
