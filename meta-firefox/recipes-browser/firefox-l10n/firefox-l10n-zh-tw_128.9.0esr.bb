# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e3a6669811892d0e4c38a8a97e32ea41"
SRC_URI[sha256sum] = "8975fe521c8af5823fa3bcc7f872b8f6626537fbacbc2e004c1647a67dacf126"
