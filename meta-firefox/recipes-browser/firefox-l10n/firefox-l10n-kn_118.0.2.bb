# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ea193811366a2b9c38a6a17757a5706"
SRC_URI[sha256sum] = "bffecb38b53608023906342380650fdd4d98353989a4322674ede12062cd992c"
