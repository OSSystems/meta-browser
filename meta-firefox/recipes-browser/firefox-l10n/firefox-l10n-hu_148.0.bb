# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6d6261d413b7396a66d24e6b5c25cb24"
SRC_URI[sha256sum] = "dc7d9406b632f912112ee911105db857b67d2f6f2b96eee6b7dff0491c44d6bf"
