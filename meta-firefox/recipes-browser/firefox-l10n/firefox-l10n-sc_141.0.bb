# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "22642a24e83bb326c500831bbd817146"
SRC_URI[sha256sum] = "aeed0a63eb7b46d76aebd7db74e62a6ec5e0c69e60602e07f1b34bf9133881f0"
