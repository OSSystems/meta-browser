# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "784ce74da6e01e749e09e4623d3fefd3"
SRC_URI[sha256sum] = "088285635c2afc1068e6edac8b20ea772fd91cfcc7be411e464a8b8260d5339a"
