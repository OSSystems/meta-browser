# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db9ccefbbe51b87fa00c425970539c2d"
SRC_URI[sha256sum] = "c5f6c32c27c9eae2b537c4824bcb95328a634ebfd4e3f9b70bf4520cb13e302b"
