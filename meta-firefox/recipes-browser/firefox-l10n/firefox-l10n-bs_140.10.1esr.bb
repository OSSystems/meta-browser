# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c9b0b45d9260b2209653e7535da9e1f11643f5acbc64fcc0cbb81e24c69dcf78"
