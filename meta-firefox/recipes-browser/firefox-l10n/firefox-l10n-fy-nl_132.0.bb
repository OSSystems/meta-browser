# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "49a47a75ef83fefb74a5cc3fdcd031f0"
SRC_URI[sha256sum] = "b39b8806cf09a2b86ef7682f1c59ebceed7c6a2209d1e09ce9233f2d13d27025"
