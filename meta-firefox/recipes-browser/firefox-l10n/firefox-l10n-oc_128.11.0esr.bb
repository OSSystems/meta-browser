# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2c700e886e0ff165a8b3801a5aa9873c"
SRC_URI[sha256sum] = "ae91d537150aed81f1992bc30827bec17c541ca034da3042caf74b9005aacde7"
