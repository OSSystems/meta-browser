# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "fa91aeaac6a93ef228d23c3a92e136eac7f826f79c6e64366645c7a8b5dac886"
