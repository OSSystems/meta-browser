# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "57ec5e8d94e9e99b9f8db29cdf6ad167"
SRC_URI[sha256sum] = "357bbaa1d5552713b61034693f07e1f8f0153b84581788b6ceddc695791525d1"
