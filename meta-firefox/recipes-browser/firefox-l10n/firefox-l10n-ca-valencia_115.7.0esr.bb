# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "22a86f62c2e7eba4f6b99bbfa4208e0b"
SRC_URI[sha256sum] = "c30018fc7810a09d99c2cc7895f54b06aae7bb72e1056bac104bd2fed7b9c800"
