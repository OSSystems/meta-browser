# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0f40ca142290176cd3a94ca6f27eac65"
SRC_URI[sha256sum] = "2b3240998608cc6c8a56c4c65e31702c92dcd1af24ad51d011990623380fd98e"
