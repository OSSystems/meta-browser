# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c03e5582b78291ec3e80df937400d104"
SRC_URI[sha256sum] = "99dbc6242011aacdddbdf8e3adff05dd3967d8e2cd4ea6498f385d6e9e52ce85"
