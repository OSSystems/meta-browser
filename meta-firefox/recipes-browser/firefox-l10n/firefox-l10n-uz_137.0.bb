# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "884f767b800d62b85e02a3211678a64c"
SRC_URI[sha256sum] = "4b9ff7d81e36ae7d0a2ecd60c75f0d4f355bd88ef7af2d673eb5cb360a091b56"
