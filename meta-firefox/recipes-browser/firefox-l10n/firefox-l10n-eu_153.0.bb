# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "0aefe788df7ebacaad65e375f065cc067a3c84c58d4b170291024aa2d6759431"
