# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "45d744bea45b48bfb31f4378386d54e5"
SRC_URI[sha256sum] = "9a60303f544604a3c284201e9d952a2d34116d83924961cc69b2bd2707a4d5a4"
