# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "368fbef51ef78eeca3304ee96ee993ad"
SRC_URI[sha256sum] = "27431c727f25934e14843df12eacda3b5dfb9ab9dcd115c3a0ad4722d556cf5b"
