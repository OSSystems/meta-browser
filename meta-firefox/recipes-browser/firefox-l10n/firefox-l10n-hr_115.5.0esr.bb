# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b3835dc0d6ab1def9baca8fb525d9008"
SRC_URI[sha256sum] = "136245b24171416d28d854bb060c5ccf47463458c0da4ee96507204796d23978"
