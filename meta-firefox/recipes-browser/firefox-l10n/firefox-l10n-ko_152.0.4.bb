# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ce167f5aeef4f2deb4ef00d5ca6a983a186267bd9b60914c358b37d24c44f74d"
