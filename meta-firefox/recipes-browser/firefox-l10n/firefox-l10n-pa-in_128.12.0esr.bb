# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f6e29d7fe8b3bc4b606997a19c4f354d"
SRC_URI[sha256sum] = "e387052ba571c0ba78e52a4837c92ee93b7d6414c03d18a5db432a8a24755b2b"
