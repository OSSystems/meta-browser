# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0576c28af0645d50d0f5f40b607495c7"
SRC_URI[sha256sum] = "e525886d12388130eeb13065949293181a876b149a184e2ee046336f8fc7fc73"
