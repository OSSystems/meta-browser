# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "1d645b6590d9cef75d3a122e20c3e941f5c4dd6f3b6d6f37463b6f9249e36bf3"
