# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "72cd3bf401b83ab3afdf74b91aa9b2c4"
SRC_URI[sha256sum] = "85c5d1c2cb5e14f800271557381e3994f7faa5517e0243eea72ad8cf135757c9"
