# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "19404876dbf8bea99ed2dedf828844a2"
SRC_URI[sha256sum] = "e4fa6a3c17eb837505e74c73447b4b395ba7cc6695d21d05d4cf3d940a682bc8"
