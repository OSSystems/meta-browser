# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ebf5ca9edb94357a832ddf16edafa700"
SRC_URI[sha256sum] = "0d20d8e9953468ec9fce2b4a4ca79105034d9957bc85a49e1fe38727e8396b3d"
