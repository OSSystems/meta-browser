# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a5c5e66e0b759e15453754057047a074"
SRC_URI[sha256sum] = "c893a6c36ab96e43e0b3510dfeae05683f547c5241efd5f19d70f290e49f7be6"
