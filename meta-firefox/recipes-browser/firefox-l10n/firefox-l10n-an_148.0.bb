# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c47b4b79e16b294d471ae2a26c03dcc8"
SRC_URI[sha256sum] = "d08370e7c236cc5bb4053e0f5a9565f525ed0ff05afae3592e6d304d0eaa05bd"
