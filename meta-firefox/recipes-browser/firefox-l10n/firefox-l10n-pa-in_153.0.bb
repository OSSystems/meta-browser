# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "8b59aea59439d18f287f0400c36f0091a19b3ca97d272338db6873387c46d2e5"
