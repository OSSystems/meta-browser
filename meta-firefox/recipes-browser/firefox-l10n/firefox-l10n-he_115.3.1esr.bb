# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2df96195010a7115b15a8506fdb97d75"
SRC_URI[sha256sum] = "35606a55189b88c6f40b21aa76e3b97ae3d369c38fc871939a61ae14a443f0ed"
