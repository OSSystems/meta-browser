# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d5f88e18b809606bff0de6dab525b5ae"
SRC_URI[sha256sum] = "61c3c04714ecfee238c4060339f75d95cb54f72d6d3abab294ef9b5babb44758"
