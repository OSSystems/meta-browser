# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "519ff0579f6c24347d8216b9e0008078ea0551ab7b6e9a2ee95d90b021612f02"
