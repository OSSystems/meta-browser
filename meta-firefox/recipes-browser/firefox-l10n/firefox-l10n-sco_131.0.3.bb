# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3caca5282ffb86d03e625a6e5bb40700"
SRC_URI[sha256sum] = "71944df56a6912f420632b496192df96a654fa7c6a2a66b87c49eca06ac9555c"
