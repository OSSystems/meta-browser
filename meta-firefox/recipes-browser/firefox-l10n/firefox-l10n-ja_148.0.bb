# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b087a8ea809d28617e67904b3ca3bd74"
SRC_URI[sha256sum] = "39514232cfa2f4c485d7d6dc9d9b4c12919dcdb4a28f3494cbefacf4ef3a4d9c"
