# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4ee6d4551c152df53d621f90a4c1f22f"
SRC_URI[sha256sum] = "4bffc16b20cee6570ee1ba2513668f6a47c3ae88447fcb669ba26355e3763907"
