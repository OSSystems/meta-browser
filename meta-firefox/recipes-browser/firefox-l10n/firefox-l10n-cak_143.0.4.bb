# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c56f59ee3e6d427e4015ff9df445e1e1"
SRC_URI[sha256sum] = "5a2d2f9650ce482e37d298e1eb7a631034d340dd6f9edf14dfd411486b9cf883"
