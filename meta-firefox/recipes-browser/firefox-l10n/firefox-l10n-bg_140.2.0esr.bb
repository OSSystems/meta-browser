# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4aaa14e4d4dc1cfb4c412b0713ab2909"
SRC_URI[sha256sum] = "c5890a6b15b97cc59d94fb0d36e9b1c4a98634c537b64ca847d24b9b423dbb92"
