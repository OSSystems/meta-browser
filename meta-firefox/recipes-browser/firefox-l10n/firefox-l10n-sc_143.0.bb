# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "797589362983cc5c1d2e71a5e0c79193"
SRC_URI[sha256sum] = "381b9b9aa37778c1c5ab86df3ac19678dd6c911efb69c8402e17d8767ccb292c"
