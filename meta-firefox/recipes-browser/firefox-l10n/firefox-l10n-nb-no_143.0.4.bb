# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7f246a66983d3f350ed10868f82e0e41"
SRC_URI[sha256sum] = "fe8d50848473da98be2ab3a80fd60e624d3ecf50e8ffcbecedff80d2d309d09c"
