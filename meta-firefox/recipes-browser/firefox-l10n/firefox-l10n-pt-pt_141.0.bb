# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1b4027b9d647f39ee3786a85af52a15b"
SRC_URI[sha256sum] = "d867076cbec52c6b59bc96ee4a64fc886a43e276ff223dbc299825a57682efbc"
