# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "76ba8817b1d9916c752bbfac1daddcee"
SRC_URI[sha256sum] = "4cbc2dfc785f09aaf74d6f768a1d710e654e177a7d7fff26eb02677539a68b09"
