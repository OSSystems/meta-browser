# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "545a279a613cd7b44102c5250f7991d2"
SRC_URI[sha256sum] = "97ca5e1e8c0fa9c25e9b44af489359eb97cc946094bc66745babafef2f9abb6e"
