# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "444d77adb3dc8d3260f2ff661337de55"
SRC_URI[sha256sum] = "cb1422bdb2abc0aae8316f870871948894bbba38fe9c7fc03668567665df961f"
