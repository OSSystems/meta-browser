# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3f0992b486f239e60c8860662af9b3b7"
SRC_URI[sha256sum] = "5affc4bfc88e66323eec23cc42447d7e42bdc07d578cab62552e6b70f460f67d"
