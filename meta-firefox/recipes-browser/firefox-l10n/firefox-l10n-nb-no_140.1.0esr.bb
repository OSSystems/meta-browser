# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d0742e7f4ab4fe03592eb88a9663040e"
SRC_URI[sha256sum] = "816c521658df55b986ec795a030a2bc5f0833eab82fe36921bc587f78b9d3498"
