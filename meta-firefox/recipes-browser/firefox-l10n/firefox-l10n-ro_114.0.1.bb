# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "26f1d1a8082c451479ee2ed54c46f4f6"
SRC_URI[sha256sum] = "263509bbaac2e17643bbf473e3ff5eecb6814e21b91eb649e38fa1d8d2e1a8d2"
