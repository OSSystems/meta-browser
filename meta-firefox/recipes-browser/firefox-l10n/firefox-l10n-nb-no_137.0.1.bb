# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bbe6c5c666f2b2d18747c9c8c072e45f"
SRC_URI[sha256sum] = "b97427ea0c0d6073eede55da9c7c2bbea1bcc57db3599c1e5b9f065b8877f43b"
