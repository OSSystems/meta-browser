# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6f29bf6b0078ba5e20f9ac3e540a482e"
SRC_URI[sha256sum] = "b23cfe1749fa50a901c0867368a75300b6ddee38aac2e26a4c2d8eba80d083a4"
