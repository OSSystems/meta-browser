# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3538c5e4b36cb1b56a9e75a6ea5f28a86b1fa4b67c4e3ea61d0f9a7f799482c9"
