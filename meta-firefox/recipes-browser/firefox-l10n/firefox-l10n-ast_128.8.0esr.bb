# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2771bedbe6df4269a521c0bde359e163"
SRC_URI[sha256sum] = "d84fbb3f288d5747ae986f54a8e66f1564832504f7f47cf3ea73c82bf0b84dd2"
