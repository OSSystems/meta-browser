# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9c0b42925d1cf5c9c66a4661c3cd8d3b"
SRC_URI[sha256sum] = "adc45e9c34bc56ff37983658e91d8ad35eab865d304c65079cb8bb3c93a99755"
