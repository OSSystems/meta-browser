# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "45aff67d9ab9377d99b160706ba0c76e"
SRC_URI[sha256sum] = "bd42718f5047dbc3dd67e5b3f8e7d3051b449ab3bc2373bde99847b3ff2527ba"
