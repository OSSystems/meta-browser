# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2dfb874ef8c0b4bda0b46f755922003d"
SRC_URI[sha256sum] = "3425693ed845b9711b734b5936a19cb5637d20afafd5c5a0ce560b1417ac873e"
