# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "4201c9994471ac448d32bb352295e183485df12b7e2a134314fe74746f65fd9d"
