# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0faceb03f0e154819e66f96c4f00097e"
SRC_URI[sha256sum] = "424b653fc1d7aba53fecc630799296e25a22515374c4b256b248649b770cc8a1"
