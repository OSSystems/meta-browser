# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e68e907a160111f01333f601d9df314b"
SRC_URI[sha256sum] = "f4f924c119e40b8f3463f92149afb6ab1e1264e24b415b37a9c2452a5daf2724"
