# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "634847c7bb1c2e786217bbd90510ff46"
SRC_URI[sha256sum] = "343c2567001a15217616f48a26bd6e02aa18514009a94cdee43f300480796ffb"
