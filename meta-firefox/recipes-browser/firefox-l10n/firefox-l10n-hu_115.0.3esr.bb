# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a8ae6da7cf4e91b10037d37005cd965a"
SRC_URI[sha256sum] = "13119aeaab4d25d0a11a3068cf1706ae8aec0876befbf4fe4f942aa8fe228135"
