# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ffc497fbd135ec572cdab62a0c136144"
SRC_URI[sha256sum] = "4cb55b7b3d5a10790c784127ecf6cb6c3f7dc6f1d5f27695754ec3d6b4e7ec8b"
