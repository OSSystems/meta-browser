# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5224e37d313b6b13b99dc6b84120a5ce"
SRC_URI[sha256sum] = "3a4cb26fd0d52b43e5a2d3908f3be97bf26fb886c1291610d9428c2334509e34"
