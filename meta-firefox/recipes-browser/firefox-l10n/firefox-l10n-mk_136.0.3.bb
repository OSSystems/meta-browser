# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "819c5ff81d443d1de14d8718bb423269"
SRC_URI[sha256sum] = "64c2e972e1812a85eb148cfde5f319e9ea3ae2ee77d2efa9da180f23db7f1bac"
