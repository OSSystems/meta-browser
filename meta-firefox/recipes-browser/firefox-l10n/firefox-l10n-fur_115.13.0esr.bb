# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7e966e482a6b497af28c675ac4f1ec5b"
SRC_URI[sha256sum] = "419eb2746c34b287bf064ab07939651c0ffcdb25091593f89f596f42bdaf8d3d"
