# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b0d22664d18810430a911cb13425eae9"
SRC_URI[sha256sum] = "bf7418109eb4fa39e0ce6e46190f150c1e3804963f533d90417b7f618c3e2b94"
