# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a56f1986be6c52dbe21fe5d9fcc5baf3"
SRC_URI[sha256sum] = "6f786ccd60169ce5dfc811c773838f34f5b29bd62baf23a25c778c4b88a48f63"
