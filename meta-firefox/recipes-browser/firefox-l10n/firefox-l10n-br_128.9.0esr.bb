# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d9e048434940df284fc3d2b8d9f595f6"
SRC_URI[sha256sum] = "9316ef9e4d0fd195658243596d71b69cb5c8211f06009b418904784d26600543"
