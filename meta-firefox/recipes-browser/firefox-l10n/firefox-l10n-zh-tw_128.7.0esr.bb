# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d8e586c6bc2858639965eecc163f3612"
SRC_URI[sha256sum] = "122d52d3766e039521b6b4aa039f3d9dc29fad071676262c5f39011600abe82a"
