# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b97c8c7b40dbadc4ca669c674d9544f7"
SRC_URI[sha256sum] = "4a3cf2bcd39ad9e8726bdaf528508b1e22e8ea8e448c75379152a07784a72d7a"
