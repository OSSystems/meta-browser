# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4b3d29d73167a6f827089e76312e45e5"
SRC_URI[sha256sum] = "99c5f025ccdfa66ea7db1fb28457292f1ffbb4a47614397a8b23e177edf714fd"
