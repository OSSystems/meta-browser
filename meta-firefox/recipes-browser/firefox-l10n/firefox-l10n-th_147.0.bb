# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e5d646b0434d8951828a40c9b22f6f4b"
SRC_URI[sha256sum] = "768669e42b85d31ba005c050be0b66b1417386736d02ce4ad97c6733e2579ce2"
