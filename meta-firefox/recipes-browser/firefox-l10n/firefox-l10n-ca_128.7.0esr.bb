# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5be5ec304ace61f1be844bfd54525540"
SRC_URI[sha256sum] = "5849abac730ef14b8d30749afec4629256dc91693fc60d994d5b59b522a6a057"
