# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ba8aa470f633e9d00a4fcd79a35d71c4"
SRC_URI[sha256sum] = "11849ae69bb9063899485a1199f70ce8ab2b020304c731880d320517e0388c1a"
