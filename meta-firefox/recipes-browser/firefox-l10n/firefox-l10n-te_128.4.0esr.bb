# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "270faeb09899b5d5a71cbee7b1b4034b"
SRC_URI[sha256sum] = "95fd810ed5e5dd4e75dbb074b4aef631e50b67c52fa7e936319349f5ecec2736"
