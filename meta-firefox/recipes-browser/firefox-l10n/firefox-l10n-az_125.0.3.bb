# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a2640a45a21e4c948f3833cabb079ff0"
SRC_URI[sha256sum] = "82965a0095d94da7fae07452269fda271e9cade196e923937ad2c38f6c1af3a5"
