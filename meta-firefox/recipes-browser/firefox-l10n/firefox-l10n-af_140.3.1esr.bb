# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "74b0f20862284cae60aeece9f584d3cf"
SRC_URI[sha256sum] = "88e94e4dd42d62a3769434dbafe0bd8c444fcff9391ae6c354a793a5d6a02805"
