# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "413d39bee826e721c313659d95c06738"
SRC_URI[sha256sum] = "074a2f4252ba023ec8ff43a1d0759a43f98bd2512640168593669eadce0b3162"
