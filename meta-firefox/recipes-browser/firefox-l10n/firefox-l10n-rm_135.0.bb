# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d6d5f16e44ef5f9dcb19e140e4971164"
SRC_URI[sha256sum] = "70d7e264b037c0ea887b6a558293bfaeb531720b9eaaa036032d776186c39520"
