# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "9f9cb03c5ca6a7be7fbed09cbedf61b5a61ce649dd32f182cd4cc88f0910f23b"
