# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b5635fedb11451615ab7592c00e2f651"
SRC_URI[sha256sum] = "8375b26d6527975a81232759020a5829957f35c5e8b06b31e86ccb6ba674b859"
