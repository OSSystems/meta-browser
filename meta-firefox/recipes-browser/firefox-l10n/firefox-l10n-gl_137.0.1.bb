# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8931a4706e25131b71a1a1420db7ec62"
SRC_URI[sha256sum] = "93b3ae8fd44bb1085a77c590e97f8a09f600dfa4e77ce106aab44ab0edd176d0"
