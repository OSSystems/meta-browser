# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "57748c9cb14594850275d19ebc533cb5"
SRC_URI[sha256sum] = "ea8f0dda74fab37c7275f1c88aa3e8f3a3833697a4b3d4dcce32c7a023a12799"
