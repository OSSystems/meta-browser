# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ae19af25c1805ff2db00f7be8a5d8e68"
SRC_URI[sha256sum] = "09ad3e0419c0dc9566308c3c7989bae278df4529144a8bcbc17a676d099765bb"
