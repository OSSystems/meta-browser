# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0b53c50102e99c02317a1e72b82d6875"
SRC_URI[sha256sum] = "5df92fd45558d588cc8533b2a465c966c4d756fd8e594d7054cace0293b1fb57"
