# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "99b527b076b1246358e0e984cfb50e7e5d30a0e8206db06a814baf054ac71143"
