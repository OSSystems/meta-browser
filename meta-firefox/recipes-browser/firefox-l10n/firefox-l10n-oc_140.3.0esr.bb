# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8a5805775fe99fcb7b0e7808289c1f00"
SRC_URI[sha256sum] = "1c6b98af49b4ed983cf2ce6c33bc43d7760809a411e6e391ffca4a34e642d427"
