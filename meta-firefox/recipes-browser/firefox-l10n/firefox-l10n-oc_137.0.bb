# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b6c92245d9328ae713122f167406df46"
SRC_URI[sha256sum] = "86ba94c70c7bd1772ed552f7945be658b04cbd976013a967c4d91b5d142c69a7"
