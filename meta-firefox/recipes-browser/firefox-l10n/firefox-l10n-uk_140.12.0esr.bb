# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "1c586d6afc2075846aa07913eaf4f0e07a055759bf7a414e064756f7294b3d58"
