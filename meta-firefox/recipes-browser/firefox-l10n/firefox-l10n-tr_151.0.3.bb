# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "70e533f0216a7a6fc8d017a4b8f1bb33baae86c3ec674ed8a0f88912c7294e35"
