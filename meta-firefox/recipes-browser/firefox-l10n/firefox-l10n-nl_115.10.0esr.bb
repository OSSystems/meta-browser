# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a2d0330c483c322ba699f65b31928dd2"
SRC_URI[sha256sum] = "ee289d8da3f5b0697664f560bdb5986f4ba0828e9d2ad532a86543936d6c26dc"
