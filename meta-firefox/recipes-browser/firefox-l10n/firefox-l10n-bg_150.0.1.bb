# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "f5cb660934067e7b049aa6017223d0f4df132d433e0fb35c99c97e3269e401d0"
