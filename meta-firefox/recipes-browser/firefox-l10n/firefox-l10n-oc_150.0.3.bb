# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "39f51a564f2d04ef6d38ab6ea03625655dff98187d203c6ab7fb5cc9b42799f7"
