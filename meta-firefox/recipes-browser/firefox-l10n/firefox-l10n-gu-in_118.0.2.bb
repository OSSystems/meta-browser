# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6bc73b95c4d110593b93c3f068a790da"
SRC_URI[sha256sum] = "172263776367f9fa0ae8ab54bd348887de29d78abb45b937432057f6af11438b"
