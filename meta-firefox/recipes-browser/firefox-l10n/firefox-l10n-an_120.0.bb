# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cf34f8944cf6e588eb22b8b229426329"
SRC_URI[sha256sum] = "139ff43d8df50764377280d50029972bf6d48854106e6840a64f7c995e7baef7"
