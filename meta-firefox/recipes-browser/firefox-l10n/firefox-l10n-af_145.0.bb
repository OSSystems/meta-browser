# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "37112c12ad5085f9a6cd71beea57a43f"
SRC_URI[sha256sum] = "59c9aa31252706df988765ab267befb2383bc38d749ec35bda11ff7b7771d07f"
