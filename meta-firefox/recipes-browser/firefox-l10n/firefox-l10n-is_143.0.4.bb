# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "11a56bbc99095069d585a626a8b42add"
SRC_URI[sha256sum] = "c26f10462f58d4fcf057a9d8c3be9056af9cfe851fb04d63f93f114dc613aa89"
