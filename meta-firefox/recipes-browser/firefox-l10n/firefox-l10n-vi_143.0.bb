# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "031df98c3b5926d532071031391672e7"
SRC_URI[sha256sum] = "19a77901f75a5cbc8ef35e3d85ca411d2b368b2c64622be8a5cd54d5c6878cbf"
