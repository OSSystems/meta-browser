# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ab6f92603a5cccb3114b226170426e67"
SRC_URI[sha256sum] = "d856bdc7b5c8d9aee2b3ec4af1f76d33a80ca043fa73eb56e5d45d0ce4ea8f9d"
