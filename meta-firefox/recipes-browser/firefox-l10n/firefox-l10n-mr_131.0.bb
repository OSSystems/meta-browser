# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "93a57eac21200d2493e10154cf90cfb3"
SRC_URI[sha256sum] = "c9dcdb016a08420e7883eca568a6337fa23917cbcc6d867c946f38fa7e20875e"
