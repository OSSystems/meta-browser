# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bf004ed010af7ac8f76a92bc013d98d0"
SRC_URI[sha256sum] = "523a4a2aa5c0c56a5393abf537e19ac01ab04920a630c5770796b7750af3a8f3"
