# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "50d29afe50b6dcff89b14d2fcc9ad7de"
SRC_URI[sha256sum] = "fe43fc0a6a5b3c9f247c2cff4d3e023981a9a50b719a205d574d20d473fe7c5e"
