# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c636a061912890efeee70be00da27527"
SRC_URI[sha256sum] = "6279c05e7416ba288feed0a0ae54bd779c0c1a67a4491f496f80d41882806798"
