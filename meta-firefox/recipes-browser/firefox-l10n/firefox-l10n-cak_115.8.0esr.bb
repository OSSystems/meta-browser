# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c9cbd1de502f93c6eaffdbc977169d3e"
SRC_URI[sha256sum] = "c6c716e7aa95f462f4d3c41d49c9d1da63100c264cbd54926db3451061d11964"
