# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "317a6068fba74fa0722a255aa72a8fd2"
SRC_URI[sha256sum] = "0000e33d89fd92999f8d37adaf545549ee4e72438d7d7bd4859dfe12ccec09df"
