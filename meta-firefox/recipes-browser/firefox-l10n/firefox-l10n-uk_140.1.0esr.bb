# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "551c538a3390189c74e67755eaabd63a"
SRC_URI[sha256sum] = "47cc094d213824c1aeab42f2ccc88181ac145bf909c8030a82677574c09a3994"
