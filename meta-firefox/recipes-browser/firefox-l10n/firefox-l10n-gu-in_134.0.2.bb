# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c251abd2cf792c8cc8f1e8163388a985"
SRC_URI[sha256sum] = "09d4d4dbc76e73f7bcba52cf51443b5581f16f01bbad19d40b7881d82628bc77"
