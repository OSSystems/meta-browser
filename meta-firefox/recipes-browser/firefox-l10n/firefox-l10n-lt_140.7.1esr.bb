# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dcbe3f1831bb1e0d48611e5d5ffa5e4c"
SRC_URI[sha256sum] = "0011358fd8db2862c8eeff553b21b6c8f34df09f88c5e4a3b6d14db6eb81e67e"
