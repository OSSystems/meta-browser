# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "51dee43b16c0d7dec88ab9579431f602"
SRC_URI[sha256sum] = "d8fda6b2d31bd4dccc5dcf5236021b27051275dffbefb8b4bccb213f806c5fb6"
