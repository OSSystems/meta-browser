# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7fefecf37ce4fb453ed199d2e547531e"
SRC_URI[sha256sum] = "0ef213aaf51e984ab71ca672008a36ff76bd5bdbc2ccd1c251804d6f63469ac4"
