# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "baf6e51b5e5da6b52dd35b00add54ae2"
SRC_URI[sha256sum] = "b34ea98fb7d67410c8ba4e4f9dfd0d0b03a0a4924716dd4d733308fc9714bb6f"
