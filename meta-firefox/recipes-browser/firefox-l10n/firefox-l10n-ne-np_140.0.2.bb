# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8b66c56f8a62ed3f2cfc471d1d80e53c"
SRC_URI[sha256sum] = "33d67cf00c5942fd82bedd86899878745dd0272897960f6ee8981ef1cf975b30"
