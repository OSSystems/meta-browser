# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "535b353e538df30d9ff91f870d507459"
SRC_URI[sha256sum] = "b5a89a612da31675b06cd37f5c1d4a99c58602e08fa1a05412fab886b0304fb5"
