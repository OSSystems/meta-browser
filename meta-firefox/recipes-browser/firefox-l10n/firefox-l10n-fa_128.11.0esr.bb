# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7c90b5273970103089e3f1267abbc3e7"
SRC_URI[sha256sum] = "31810e2e3320d0e4b1a44dae5d1dd59d5c290caed812373df1c61a1011d90894"
