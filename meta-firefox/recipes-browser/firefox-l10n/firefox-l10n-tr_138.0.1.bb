# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "23e7bd6d2add3daa15d4c4744235decf"
SRC_URI[sha256sum] = "a05cfb1a1520f1f1c99a6056f27311a10c6b53a40727a4eece74ae6a1f9e929e"
