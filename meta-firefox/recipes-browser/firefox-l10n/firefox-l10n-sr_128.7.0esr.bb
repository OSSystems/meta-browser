# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7997968e8a07e5edef51c9f2886bb422"
SRC_URI[sha256sum] = "d612ebfbdc6f690507c31a7034f949ebfe0671e9d84357b233e665836c53e840"
