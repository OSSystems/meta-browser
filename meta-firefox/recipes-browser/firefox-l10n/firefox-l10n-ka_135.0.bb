# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "52f432299d9637809a66c823684fd482"
SRC_URI[sha256sum] = "2d411ea972529ca82958e0d391482cefa065bc639f6f9a93229191301041f6ab"
