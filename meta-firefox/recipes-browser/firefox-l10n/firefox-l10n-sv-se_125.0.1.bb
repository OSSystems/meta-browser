# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "18116c9f81f64d27bbd64153f0a597d6"
SRC_URI[sha256sum] = "35eaf27389b2a8634f477fb82b27941581658ceaab5a980cae1956ccf84dc3d1"
