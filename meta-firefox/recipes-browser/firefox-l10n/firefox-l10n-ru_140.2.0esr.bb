# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b0ce4a85ff58a3efbca54923e6459223"
SRC_URI[sha256sum] = "65f3a7fb082a9d2833eb8a098a058fd6542f4f903ff1393d10592409c9356a0e"
