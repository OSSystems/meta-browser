# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b51b2856e2fd9bd094284bd8341b9f96"
SRC_URI[sha256sum] = "bf14ed0ee9e3b888e2a5b0a439617a804612f923e443112f73072deb656efa83"
