# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7c85cc898068ef5af73336f3403ba3cf"
SRC_URI[sha256sum] = "d771cb925c6a5d66844ea5ae569baec3ef5b07a5c7c723f31a35a3f3175ede32"
