# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c34292ddca9344ff471868efbd638442"
SRC_URI[sha256sum] = "66c114e9e78842d68c14ad7f0179f4f724bae30933c7b6a0b14bebcf012a6780"
