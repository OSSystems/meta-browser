# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "139ee3319c50446d9da098d6f59be304"
SRC_URI[sha256sum] = "4753f1ece9fea22768148d8527028d851e76446da75af7e9dd0a161960b69371"
