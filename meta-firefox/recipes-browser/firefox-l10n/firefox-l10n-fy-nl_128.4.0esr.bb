# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2cdab36985474eaaadbbb315a30f25d5"
SRC_URI[sha256sum] = "79b7e0c83e2a4b5d5bd3b0e5225f176b4077ea9f4a598628684af8b07be2ca5a"
