# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a04a1175e4e76f8df4ca5667ac8e3050"
SRC_URI[sha256sum] = "5a86f8d5508f7a6e0fe07d1a0d1802c8db6386c0773617d7bbe61088b11e3f63"
