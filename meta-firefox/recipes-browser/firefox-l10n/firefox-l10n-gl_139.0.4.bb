# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ac16d40c7dba047761a22f8971b1030d"
SRC_URI[sha256sum] = "f1e6c78a5565bec57055bfd22c98ed2ca4ce4f30bd7adbcb79c62f86eda701ef"
