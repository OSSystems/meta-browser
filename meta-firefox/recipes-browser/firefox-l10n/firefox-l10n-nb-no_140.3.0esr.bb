# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "95739ea9f63c968a632bd5e7e33a893f"
SRC_URI[sha256sum] = "7221da125552f6a9b206352ce40610355c5400649af3b9c5d23e8242c72602ad"
