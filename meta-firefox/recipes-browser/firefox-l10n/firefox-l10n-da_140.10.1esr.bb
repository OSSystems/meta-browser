# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "a3cdec6aa7a8f79cc0db0ab8c5c06f647b72140f17781db2913dc30f0f6298bc"
