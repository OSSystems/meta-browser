# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fc237281258e7c37276173d490bc2eaa"
SRC_URI[sha256sum] = "1a249a1ee48c0539d53c845c3f9f4f89937e9b97f54f086c4ddf9b51083fd292"
