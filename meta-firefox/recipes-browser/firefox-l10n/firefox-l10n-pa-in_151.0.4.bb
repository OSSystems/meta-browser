# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "6d0ff45f394dc5ef15034f3ac58c3548e81bf75637a32bbd36f85d53e8af26c5"
