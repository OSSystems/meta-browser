# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b11ae601a789c15ebf186d2dbcb9647b"
SRC_URI[sha256sum] = "7d6a159fba1d799759a4e9a9641fb405216bd08021e1b3a508278c7e0151976e"
