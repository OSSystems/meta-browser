# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "11f00cde5ba26c80c7c672dc43f73a76"
SRC_URI[sha256sum] = "b48923224c8ef4d74a03ad3db1aa39bc7b2de727d387a1a68105e8483be08033"
