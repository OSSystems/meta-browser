# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "0541095209741a9b3943c0a78332bad33750fce5f6afdfc9b333e5eb6a21882f"
