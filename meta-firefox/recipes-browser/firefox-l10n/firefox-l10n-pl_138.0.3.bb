# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0bc5c67680af3d21115de303e707998a"
SRC_URI[sha256sum] = "efb38d7c540b039df7bf6ccdbd5996c903df29f5f564e8540037947dc1329a77"
