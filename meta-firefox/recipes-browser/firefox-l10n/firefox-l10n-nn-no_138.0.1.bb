# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "622bcca27f13309c4fbd3062649a4a2f"
SRC_URI[sha256sum] = "7847921882689c62a95d301fef6bdd8d95554980e5b4ee9e2452e5e05d222746"
