# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2a6f2b540785e9f3e5511da17e8c36e1"
SRC_URI[sha256sum] = "518e6171d51f3977851d6e0a12dfd2cf829d207876890ef0e47d92f547e82863"
