# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1f875c17f5bde8ab8a171d1e2492c9ac"
SRC_URI[sha256sum] = "b90eecf166404d3babdee9b695bbd4c62eb3fe9a927863010ae5a38233a95507"
