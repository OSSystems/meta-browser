# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "81ef281f7e71f926524eb0843df99ef8"
SRC_URI[sha256sum] = "6b2d7e10a48b6d81b15928c77e63796103715d8f8d523f3189cecf734f5a1a10"
