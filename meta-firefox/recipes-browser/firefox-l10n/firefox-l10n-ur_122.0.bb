# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e7654632a58d1393b5b349e67355c18c"
SRC_URI[sha256sum] = "d16646f7043c352ce235099605b7b0facd141ce9832ef1e1f92163e1d934481b"
