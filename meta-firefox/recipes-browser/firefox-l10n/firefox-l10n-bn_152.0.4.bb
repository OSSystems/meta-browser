# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e62be4ff56a6203d611cd922bbfd65a756838027951fe7cbcba5e7f6cecfa894"
