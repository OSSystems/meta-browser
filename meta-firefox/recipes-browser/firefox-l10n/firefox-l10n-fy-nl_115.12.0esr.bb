# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c4642ab54353ef90bf4bf1dd8a9780d"
SRC_URI[sha256sum] = "9a8f50ba2c932334d556790695d4719adfc7a65dba7632fd158d68c37dccbfc6"
