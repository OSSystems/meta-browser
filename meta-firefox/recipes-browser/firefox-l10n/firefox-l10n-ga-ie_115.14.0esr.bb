# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3778af5ff3dea60f3d8b17bc56e17247"
SRC_URI[sha256sum] = "73b66854f3d1bd42d8e4adc228cde845b3281a3ee3f2b45242750c38e38a3ba0"
