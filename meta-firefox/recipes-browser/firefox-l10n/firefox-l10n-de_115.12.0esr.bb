# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "346132798cd4b59eda970047e520b442"
SRC_URI[sha256sum] = "63d112a39cfd4e2e72d61c22e7e4d25264e132753fa452970a6db52714967eed"
