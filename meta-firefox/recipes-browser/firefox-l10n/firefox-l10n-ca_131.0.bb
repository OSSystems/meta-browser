# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "efb8157508cf1eeb812beda0607c1a0e"
SRC_URI[sha256sum] = "1e803d449e0bb656a03c18023cd77ffdc4201fc1949cde8ca98ce943d4b208af"
