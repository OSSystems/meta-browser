# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "40c2e0e4573ba1f0763ceadd724240b8"
SRC_URI[sha256sum] = "7c39baf682529f2a1b2ef14fc2982e40657b413b68dc400fc154d4d0f16b1f36"
