# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "11a39a860de443bda3047fdb79527409"
SRC_URI[sha256sum] = "7fb7c06751c4dee2979f34bc1a9c747713a86f3518d54fc8b044aaabb92869e8"
