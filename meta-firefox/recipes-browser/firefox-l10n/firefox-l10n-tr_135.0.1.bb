# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f8b176c4e8f8bdd0187139ab75271f58"
SRC_URI[sha256sum] = "2fe7826ad1b4188a503af49d7a25ba357e5f6624ed99b135b1002d48346e7586"
