# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5291a701e1b3949d01a432f191886315"
SRC_URI[sha256sum] = "6f2eaad3e688a25c9d91624c1115240f40fb12ce4cd3f017ff6cfa7ea51fd9b6"
