# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2ec8eb085a4d3c3cf9c6b33112ad99fd"
SRC_URI[sha256sum] = "15bbed901189f87aef46f18830e2f4b150c6267dba2782fcc690d19c69fcbf00"
