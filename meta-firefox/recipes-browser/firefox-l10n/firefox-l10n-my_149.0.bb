# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4aee7d0a9e20a287cdbc2c285106e0c5"
SRC_URI[sha256sum] = "c45d6b050c4010f5c1559edf0288aa765e9b727a5a9dd1316e940f040e1d5d15"
