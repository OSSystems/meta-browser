# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a22fbc4869fc8f576ae6804b9108e79f"
SRC_URI[sha256sum] = "419a85bff15dce285d2a521217eb7eb4d5ccfaa6a8973aed5f41ac102158fd5c"
