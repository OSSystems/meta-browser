# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4918af024e2e5e10dea9aa559760ce0a"
SRC_URI[sha256sum] = "5656318f148043eec4f41dbffa73a90eb45df1ae16e77d01991291f3a0e85c91"
