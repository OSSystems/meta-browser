# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "df3a720ba92dad7f0e3c6940b8c066c5f800bf7ce5c0eca01aaff3dcfac5ce02"
