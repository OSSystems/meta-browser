# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "04d2d3dff1c376ebf1344f5f7cba4940"
SRC_URI[sha256sum] = "0dc7db062a7f5f4fdda86149e5d08eafa71cc2fd8dc59e6cdd9382df2ef17a8f"
