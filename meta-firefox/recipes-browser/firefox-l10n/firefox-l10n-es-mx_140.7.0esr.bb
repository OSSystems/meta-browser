# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d9fe41b347642551a3083097f733c090"
SRC_URI[sha256sum] = "deab92a63cc67f61e65f32da7242c6c863a9e49d4b9b21bbe6760eaac38dd64a"
