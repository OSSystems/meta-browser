# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "44b5e0e0de93dddb01f871af9870f6ef"
SRC_URI[sha256sum] = "09ce4adf040aeab7b15f3ca20b367b08f82584aa5fff195aad70c65562d37d7b"
