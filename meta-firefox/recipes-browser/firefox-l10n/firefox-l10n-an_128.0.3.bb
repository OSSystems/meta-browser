# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2ada5fa46dee75d310fcbdb7ab2876ca"
SRC_URI[sha256sum] = "dc3e77472d88cb731d002a087444c33145ace656f9576ab817877785d0962e97"
