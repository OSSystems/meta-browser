# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "23222fb677bf16363af646b82f94399a"
SRC_URI[sha256sum] = "d0d756effdbaee7234540145b518c9fb3dd4efd41bbebe163ac2aeb947082bd4"
