# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8af94a2f3ee38392e851cd41c32171ef"
SRC_URI[sha256sum] = "824363c01753c0564066d0b1a61ce2598c350941d4e42b43380cedb60713b061"
