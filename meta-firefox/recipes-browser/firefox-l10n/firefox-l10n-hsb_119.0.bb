# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e607ddbaec7c85ea4e6e275920301e71"
SRC_URI[sha256sum] = "ed6cf79abe07c3cbd9075769eafc96a84a6de5b96e02147d1265f93859a109ed"
