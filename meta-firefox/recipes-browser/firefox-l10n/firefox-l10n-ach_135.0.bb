# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f9e601114291cd63a4a04b2745eecaa5"
SRC_URI[sha256sum] = "76217b8865e8a454b813d5d3cb7b11330740202625eaaf6e22a3bc60f546429e"
