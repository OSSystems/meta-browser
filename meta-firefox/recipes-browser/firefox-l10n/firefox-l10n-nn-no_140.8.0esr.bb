# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b18e8fb1327faaa04befbda56bc2e138"
SRC_URI[sha256sum] = "cf436ca3537272ded552d2b50530b1ffa6e757253d562f9ffc0a9b131e2466b3"
