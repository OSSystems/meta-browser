# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "98dea0c45b19132c2341a03fefbf1bd3668ad0607e5342db7f184bedc1e218dc"
