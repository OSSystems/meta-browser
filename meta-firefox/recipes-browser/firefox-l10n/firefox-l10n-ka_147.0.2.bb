# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "11eeee50d795618cf4846dd115ee56a4"
SRC_URI[sha256sum] = "d7afcc3caf7fcc7752579a0d987a842824172ba3ae930840205f95e9aabdf475"
