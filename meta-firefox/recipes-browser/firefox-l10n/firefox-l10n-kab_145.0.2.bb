# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f22c77f5c9c625c99c352d599e274b35"
SRC_URI[sha256sum] = "dfbce46f4848b6d2590b56a9c60963032d4211a2004a197782776e623d5661be"
