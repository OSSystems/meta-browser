# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "03554ca8af292c8b149625a21755eba8"
SRC_URI[sha256sum] = "073d928b31910dd37d96c0be474f55a172fcff8b964bd24a62641040cac4cee2"
