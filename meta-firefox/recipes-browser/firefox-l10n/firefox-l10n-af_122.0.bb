# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dd9aa50d5134141137d8ceb7b5ecac35"
SRC_URI[sha256sum] = "731badd192ca03491c943b139b75776a15446cd2afe4b4de9281069f9e83f9ed"
