# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0f5d95774c035b9039e3843741c11a75"
SRC_URI[sha256sum] = "9aad4c7c823c1aca3b38e1fbfa479777197a6a00bcb594668d1e782d8d477b7b"
