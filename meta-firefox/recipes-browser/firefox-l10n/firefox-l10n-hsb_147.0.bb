# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "814a9bee74a0e69d2fcb6615dfc17c4a"
SRC_URI[sha256sum] = "2f01d2432bb4e3837b6de3eff790756a4e167e60a84de443e6b1946126a03d63"
