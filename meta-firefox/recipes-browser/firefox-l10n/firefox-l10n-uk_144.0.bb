# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a2a97a21842c01c57111f3eb1cdcb3c3"
SRC_URI[sha256sum] = "0129c479d56a9eae26997962737b5f02d2990fef9c280d39aad8fa1d4ea1d7df"
