# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ec0fa3cd010a1d81a6d28cd81ce61eba"
SRC_URI[sha256sum] = "c0b70f51da2428f2e962642b52fd64f9a85786b7a6310767923b240f30a4ae74"
