# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2b22834bddc9f22e049972fdedff6047"
SRC_URI[sha256sum] = "e70a232b18d76b219eae4b6b26114fde8be3893a1b1d0d3a33f91714ec8ec7a3"
