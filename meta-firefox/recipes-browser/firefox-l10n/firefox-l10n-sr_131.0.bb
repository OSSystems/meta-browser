# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0aae6313656b88a696251c8aa47ba5ff"
SRC_URI[sha256sum] = "80f3109aa8cbfedf404bef0c500a1953b3f6a4af0068913e61de5cc9d1434248"
