# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "884ef950aae7c1652dcac9e27205486dd682852fcffa50eb1a243cf22886d9b2"
