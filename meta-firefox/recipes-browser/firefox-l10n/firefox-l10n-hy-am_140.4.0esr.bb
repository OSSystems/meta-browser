# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3a6bb0d6dcaaaf4a04cb950abdc6a6aa"
SRC_URI[sha256sum] = "039350376f22c38204ddfcc54890cf081af02f6ea54175bcf894411de433c13f"
