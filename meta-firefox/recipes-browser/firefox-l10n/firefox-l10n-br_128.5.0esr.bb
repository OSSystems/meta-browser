# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9b70864ed079a7459b22896c4a2fd9c3"
SRC_URI[sha256sum] = "6043d8e1621981d7726425cbdf1be6da75657d75ec254243884dedc9120ccc56"
