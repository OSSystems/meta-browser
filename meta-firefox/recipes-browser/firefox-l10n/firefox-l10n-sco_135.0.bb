# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ec903f2e23d7be2f94bb09e99da27c23"
SRC_URI[sha256sum] = "9ff9001be06388473ed59485d0079ad45b743686be1e7d96752daefc83440342"
