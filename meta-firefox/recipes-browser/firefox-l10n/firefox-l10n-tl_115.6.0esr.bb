# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "de8f002b534297f57664d04decb87d50"
SRC_URI[sha256sum] = "e6afe4ee00715d826fa37ead7fa9addd4686509bf5679b6af5e2d00456f0a02f"
