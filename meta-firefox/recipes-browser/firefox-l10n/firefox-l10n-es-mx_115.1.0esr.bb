# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c34924b8aff241a3b567ae4dfefada70"
SRC_URI[sha256sum] = "e7f3a89f4909c014c727e9a0ed4daabb5310bf704c5fd0bf609f72852b798d12"
