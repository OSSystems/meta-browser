# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3878b1c6ee5a744dff28cefd73fcc8477cfebe94abd5193d00a9c05900af97aa"
