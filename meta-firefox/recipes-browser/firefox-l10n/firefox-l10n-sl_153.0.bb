# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "55361334bb1a5935840e8d45d2649f6b90ddf5db9bfcc99a8145ca09cea138c9"
