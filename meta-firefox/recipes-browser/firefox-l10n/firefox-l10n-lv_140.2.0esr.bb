# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a747e236eeff636fea99b635d1aa33a9"
SRC_URI[sha256sum] = "60aaf624cefd20edc12109407b35fed16a7f3a81fd411c3860649b5eed159336"
