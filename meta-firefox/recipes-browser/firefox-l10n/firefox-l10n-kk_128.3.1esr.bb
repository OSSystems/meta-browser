# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d81eb57fe0f7e7f7444e4498d55036d9"
SRC_URI[sha256sum] = "46fef812a59514c86e0c6cf7e785f7ca4ff5ff812dac4c6e21e62aa36f6d6fb5"
