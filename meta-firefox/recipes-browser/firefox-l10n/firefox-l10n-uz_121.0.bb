# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4d7a61dd24ed8b0ec5e67ab7ade865df"
SRC_URI[sha256sum] = "da2f1001d92ead9410a108fd474bf48e46a8c61fe224ac66c9a4ae9d63be5647"
