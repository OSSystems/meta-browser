# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "edf5e4588f520c132f4b9397a3b54944"
SRC_URI[sha256sum] = "5bc4790726e80e324d74397936b89abfa588922b2a94d8816e3c06c659441737"
