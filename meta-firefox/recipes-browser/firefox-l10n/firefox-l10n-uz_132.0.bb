# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9e8d659b53166d3df5da51af592b9227"
SRC_URI[sha256sum] = "cc9f2aef0c2d1019982ebcb0f61fae815b0a512c724f3092351aaee32cf77b62"
