# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "48dfb5c02bd8cadf33029b57d1d7f3fd"
SRC_URI[sha256sum] = "4a814a93f7f6613bc848a8600233dc9ab8822e1d7659fd49d5e64261c37208a7"
