# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aee6451296cb9684ab45d86daebf7b72"
SRC_URI[sha256sum] = "68889cce1bf008e21494013554c9df99c3dcdafc80cde286f845a00d5e6a7275"
