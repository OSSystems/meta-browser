# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "97a796b46c05cfb9103e8101e938bad3"
SRC_URI[sha256sum] = "3202f4fde0729823e6915113fa0ba06e5a52f55183a389bc6492f9c3e8eef481"
