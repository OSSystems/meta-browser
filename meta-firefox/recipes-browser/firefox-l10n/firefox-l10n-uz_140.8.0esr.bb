# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7e7d0c06ec6b7ffa1156ecd9373d2e7b"
SRC_URI[sha256sum] = "f33f3a4fffde8eb341925a8d67360a3643c41311b22b1d8a8cfafe628840198d"
