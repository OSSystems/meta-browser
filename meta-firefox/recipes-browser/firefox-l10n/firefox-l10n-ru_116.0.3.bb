# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ceef0753a3e2ae0beac880e63d37818d"
SRC_URI[sha256sum] = "e405a01041d84b7f1fb7faf36cf77235d8eb00394177d99f6e4321727514bc5d"
