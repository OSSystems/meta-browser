# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5da96c3a4f073275501c4079e7df35a9"
SRC_URI[sha256sum] = "e91e78462e84c5f1c18b81e5938c1caa5ace7e0f345c94c2e4bbf99ffbb7c3e4"
