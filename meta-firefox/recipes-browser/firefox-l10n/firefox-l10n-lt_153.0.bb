# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c57f22233a4cae18e4d7719c5e6d16af5cbf6c2aee11ff8819d77c0343236900"
