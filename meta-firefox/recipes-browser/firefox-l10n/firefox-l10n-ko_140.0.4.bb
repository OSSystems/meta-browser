# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "86af71ccb3e7dbf9b7d8d95d80a08014"
SRC_URI[sha256sum] = "176404765cfd6d38bbbb118af87e266b6909983bbc00b1b2df4a01c7e4dd757c"
