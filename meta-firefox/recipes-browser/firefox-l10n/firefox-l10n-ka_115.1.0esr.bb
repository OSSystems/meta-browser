# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fdf1aacd79077a774c15baac38d6779d"
SRC_URI[sha256sum] = "642e86b6cc7e768845af6f5d45390b9540aebc7950fd53ea84a6eba616cc6095"
