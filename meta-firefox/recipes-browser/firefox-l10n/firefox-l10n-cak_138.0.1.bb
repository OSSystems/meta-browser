# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f8df440305f02d637d77bddff799e889"
SRC_URI[sha256sum] = "541121e555af14fd637efb4b2750e73dffa836bf4ae3aa5e7035902a9db7d264"
