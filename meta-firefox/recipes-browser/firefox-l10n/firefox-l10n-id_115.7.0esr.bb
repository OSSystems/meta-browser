# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a4d0891e5e9e65181969b96e1d428e72"
SRC_URI[sha256sum] = "80dade65567cbeff3444004a8c3ba337e3f2046b1aa9b7b93617519ff8ecb671"
