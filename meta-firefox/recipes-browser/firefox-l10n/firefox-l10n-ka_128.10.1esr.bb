# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "87331c847c313c4bb0bbce3004c64c8a"
SRC_URI[sha256sum] = "7a28d629d8e8319cbcb0e941056eca276c4c5cdd9657473fd69c23350597888b"
