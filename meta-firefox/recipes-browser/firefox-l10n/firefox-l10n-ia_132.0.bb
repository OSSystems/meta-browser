# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1d8f8a12f26e71d8a4fb458840ff2ad1"
SRC_URI[sha256sum] = "5b599bc3c664e96caaa3fbaff543a6f464648ec7367954904da0155dcf709378"
