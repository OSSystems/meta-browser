# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2fb0353db4a86ed0ae705183cc21f799"
SRC_URI[sha256sum] = "7975f07293c6068a021f7a16b935898d3a10e57a4e73e8e7c997cd18a78fe155"
