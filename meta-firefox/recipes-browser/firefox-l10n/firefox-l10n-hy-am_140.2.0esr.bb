# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bb91479f2aa712f36d230d1b4a84434a"
SRC_URI[sha256sum] = "39eec3e96f036eabf07e333d66dfafabb91c6ec97441ce25d8667d726e996155"
