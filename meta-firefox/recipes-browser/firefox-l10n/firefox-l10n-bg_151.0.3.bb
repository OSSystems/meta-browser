# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "88a38d9e157f6e25db3f3efa83aec55e065f2d77e506932854e8c5a700b33631"
