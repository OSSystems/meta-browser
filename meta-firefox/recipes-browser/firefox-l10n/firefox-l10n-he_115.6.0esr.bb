# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "58b5d06fd03c8a85ecee31641d0482c9"
SRC_URI[sha256sum] = "ff1700d8edfed98993adf9c864fd898f7db2c16cc53b9d1dacb0895fc03a49ad"
