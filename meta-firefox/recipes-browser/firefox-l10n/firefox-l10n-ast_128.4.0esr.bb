# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "408727d15877459433fa79ec3f847f49"
SRC_URI[sha256sum] = "5ecf27cfc3a5dbe74cc01619dff86f82d0cc73a7e85f68f90d54df4cad923abe"
