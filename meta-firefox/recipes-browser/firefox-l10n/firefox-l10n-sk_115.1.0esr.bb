# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5a42b258d7a48e3d405afd52e833465c"
SRC_URI[sha256sum] = "a8b7ab13423bd19f698075da31390ae3906fc004162504e6840bbc87049d9d3b"
