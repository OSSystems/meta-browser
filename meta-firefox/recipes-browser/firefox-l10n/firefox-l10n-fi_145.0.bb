# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e4777c2d4bc6e99069df8cded0b14972"
SRC_URI[sha256sum] = "f5c678f97d0e79f372c94f0f3f8986f465c0392284fdfbae64ecb30223360940"
