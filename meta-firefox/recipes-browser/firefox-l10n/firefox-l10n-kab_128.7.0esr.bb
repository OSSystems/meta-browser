# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "76dde4c4d85a100293c4bee385bd0508"
SRC_URI[sha256sum] = "34bcc2d0bc3e6d831eab451283d4a613f0e490c778ab1f51cd1a466f0493833d"
