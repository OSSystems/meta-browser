# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cac2e9b5de8209bd563bbb08a0ad163f"
SRC_URI[sha256sum] = "22ddc8ac16d26c79cb7753e2a1265738041e2cff678fdb3d0a13cbc3bf2166d8"
