# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4f183b399b576023074b3c3e20acdede"
SRC_URI[sha256sum] = "eff5a2d9692f58e54463223084323e6dd5e5d7b8bd123227b8ccf7ec54805722"
