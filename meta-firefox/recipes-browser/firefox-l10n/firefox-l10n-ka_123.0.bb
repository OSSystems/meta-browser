# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "72cf935cfa6bbdac2f19d5db8599f514"
SRC_URI[sha256sum] = "3753922a00b7756e73267be570300193ef8e23feb42da4b4045ea11d07f0fb30"
