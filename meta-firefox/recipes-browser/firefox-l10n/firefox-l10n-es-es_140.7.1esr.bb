# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fd7a518943b9ba9cfd443c07b1924592"
SRC_URI[sha256sum] = "42768f1f756f5f2f8a5fca36e0dbf1c0e92096eb87e8b3ae42dd9d8e26f9d643"
