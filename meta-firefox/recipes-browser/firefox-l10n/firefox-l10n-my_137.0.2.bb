# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "80e8024a6268ca68bff209bdc135faca"
SRC_URI[sha256sum] = "a76b723ae58709723428ef8b8968abe7f33753a528eb6bcaad563bd2d5c4755c"
