# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bbe1bd93fc1ea9df91ce3cee1442c5ce"
SRC_URI[sha256sum] = "4e1e393e2b9f495256123d9d4214f2e4a7a9a8957acd6e66c916f6ee9388b2d2"
