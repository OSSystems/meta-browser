# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "074edfdb6e2ec6f39492b95a04f6dcbf"
SRC_URI[sha256sum] = "57f26e1f82eb880148b972c0bbd3d0cfd93777f17fc4dd281f69977904665ce4"
