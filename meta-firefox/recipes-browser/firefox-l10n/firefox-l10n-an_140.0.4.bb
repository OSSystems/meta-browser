# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "494d6b48000ac45ebe4b905e7a0ec873"
SRC_URI[sha256sum] = "9bbe831257a1da8a7805edc11d9ba53b3bb8fe3d00b9e11c211fc5adb231e7df"
