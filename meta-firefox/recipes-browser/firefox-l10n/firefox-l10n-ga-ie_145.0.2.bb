# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7667aec9cecf0b1ffeb4bec50b6c2a95"
SRC_URI[sha256sum] = "92543b4ee75b5f4cd6f058a6b39a834b4798115499168ab789fb36edae850491"
