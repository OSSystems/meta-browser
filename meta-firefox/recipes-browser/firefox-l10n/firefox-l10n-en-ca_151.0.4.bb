# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "625e635fb0f0e2be13a5314cef27146dcb08e859b64098ceed550d184e44e4d9"
