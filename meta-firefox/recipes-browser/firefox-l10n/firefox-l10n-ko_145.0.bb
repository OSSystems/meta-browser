# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "85fd2e829fbab808d018dc5c21467734"
SRC_URI[sha256sum] = "f6f6e5678a70a83935d13d94cd1e014fdd6532bed773a3ecdf99cabf53bed698"
