# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a822033f572dd8d617bb07e0cfd14ad3"
SRC_URI[sha256sum] = "e44eb649d228f69b5b8e6f790ebacd07d72ee9f15f4c9d8a2881a2696b5ff663"
