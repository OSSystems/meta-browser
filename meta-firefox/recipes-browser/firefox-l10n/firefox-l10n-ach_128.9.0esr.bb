# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7911acee4d7a280e24f065e3f17917e2"
SRC_URI[sha256sum] = "46628517df228cc3c679a57f7eb42a7a7d149f03658821c0b3e6cef05a3a798b"
