# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5198b68e41b2b9b54f442f8c3358cabc"
SRC_URI[sha256sum] = "546f35d15c1bfb044e143a528ab561a40528fb173b7c27f8ab410ef81f6bd2e9"
