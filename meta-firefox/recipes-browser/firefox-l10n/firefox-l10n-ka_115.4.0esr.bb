# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c2cfdb5b523ae9132183d9f991f7979f"
SRC_URI[sha256sum] = "72926e6c347bc4e961df7d8fe6359cea09278af42d2fa9b8b7ebe2cc3e587388"
