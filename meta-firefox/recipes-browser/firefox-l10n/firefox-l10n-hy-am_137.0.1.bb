# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6766ce503fc0e320be68fe11b72f46ec"
SRC_URI[sha256sum] = "32dcf3e775a242ffb586edd864679d949a90c426001dbe41aeb87ee156885fc8"
