# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ff59da7aca6d48559b507a113096cee1"
SRC_URI[sha256sum] = "ff394b29dd289be386000998afcb5a0ee51eb719d57aedd09b785fd83c57b5ac"
