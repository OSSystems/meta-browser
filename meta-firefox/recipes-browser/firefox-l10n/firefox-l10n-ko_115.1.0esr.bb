# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2614259c230de9de98dbfa96df360816"
SRC_URI[sha256sum] = "aaec63ef7f3c22d6ad9836a50cca68ed9ddb411aaae7ad0343582fe2c74f0191"
