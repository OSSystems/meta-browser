# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8da3d9560d441e6d684826dbc2c54725"
SRC_URI[sha256sum] = "7cc980290c05992c865f2acd0dea597de5eb031a01bdda1b81246164d456a8e5"
