# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "81e7baac8de9e83e5af396f86c251a98"
SRC_URI[sha256sum] = "dabaf1798ebb4fdd794230b689f402f51d70fa07dd4e5be2769a790ca1c834f7"
