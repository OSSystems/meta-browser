# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "052d008f1961350db7b8675506f82d1e"
SRC_URI[sha256sum] = "9d2c2c2473f9a8897f1ae857e637efcea90b330336c18415a2a3b33b3e2fcbf4"
