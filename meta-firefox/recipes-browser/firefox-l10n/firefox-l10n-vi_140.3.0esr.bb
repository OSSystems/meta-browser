# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "49ee242ca9290feacae33245dd62e1d4"
SRC_URI[sha256sum] = "9c4ebbf158c5b5908f9c42449d8e0067e94a3f957046ce96717b7c8240ed7fcc"
