# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "73eb77c5116ee60b02276bdd6f7255e7"
SRC_URI[sha256sum] = "4214e7c2fcd81d26714d426b0709ae18d90d68d59a5ca72d94a6c0ad3ec4e99e"
