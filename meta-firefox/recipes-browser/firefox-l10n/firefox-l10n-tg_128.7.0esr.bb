# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d5c1bbaad33f2206c6fffe0891e18f5c"
SRC_URI[sha256sum] = "5ed329616596bf0f4086ca13cef680799f0dae0264fff27805577c8288458fc2"
