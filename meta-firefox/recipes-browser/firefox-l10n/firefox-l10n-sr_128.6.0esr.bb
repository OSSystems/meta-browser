# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "26024aa3e971a66f1b43756319f72425"
SRC_URI[sha256sum] = "60d8b06861e381a10f3a10211cd7a14bbf7c8e368866645a4a7a067a3bcb3cef"
