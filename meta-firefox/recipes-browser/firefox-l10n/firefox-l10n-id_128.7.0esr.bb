# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3843afc373a1010d771cc64d74e240be"
SRC_URI[sha256sum] = "0e4cd46daa7d087e44fe5272544c638f85a508c61b2a8c196a43c0e1b90cf1f9"
