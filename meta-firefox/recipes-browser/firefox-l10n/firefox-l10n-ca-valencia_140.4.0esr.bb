# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6121f22a49b2f996ed7b2e46f79d0dfc"
SRC_URI[sha256sum] = "b86b81fab174a383144e486b54905880a0265d5331be389d94526b8786d8b1b1"
