# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b2c34a409fa2dfaf077dc619201d091d"
SRC_URI[sha256sum] = "5eb503081f758c9643dc5a283e8b0d8e23fe9e2fa4c3675b70fbc77078c61122"
