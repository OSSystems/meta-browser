# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "205e0da785f3fed17e80db6e124fa3ac"
SRC_URI[sha256sum] = "cc2784a639715840cfc77d8351ecf5bf135ec1cee2252f1d9c4174ec97fa25cf"
