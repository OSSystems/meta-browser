# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b5b215cfe9f3124bc418386ba09a32c0"
SRC_URI[sha256sum] = "0268e49d11231085d97d289dafbc0249d75974b1e94f7c2dadacf4be9f11e649"
