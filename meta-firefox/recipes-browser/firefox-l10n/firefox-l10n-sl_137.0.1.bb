# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3251d89e954a0b3e912e4e48c9ecb195"
SRC_URI[sha256sum] = "fbda8ea461b6d29cd58ad91a05ef82c53af4e617cf3f8aa46109236da5136e80"
