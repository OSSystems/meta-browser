# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a51830ad078a1f380c71dc4b1a1b3cb7"
SRC_URI[sha256sum] = "4cc55108c22b1735bab119f0fbc416861fefc704a2dcfc0162aed9d7d5c79785"
