# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1ee1de174210327b9db1119014634a55"
SRC_URI[sha256sum] = "463ded923c2c3ffa6d11b24e01e5c8354ef5352937f4b52853bb131ff40c2ea4"
