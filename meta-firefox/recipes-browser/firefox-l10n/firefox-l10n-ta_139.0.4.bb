# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fa7bce9c3ac045f927f1c4f3e409185a"
SRC_URI[sha256sum] = "672c3742d63a6de22215056a9b95561fb81fe655e74409240090a5fbd252f94b"
