# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "900a3f51e6e37d6c999b9dbb7b6c8e04"
SRC_URI[sha256sum] = "4530dfe25509e8896ff708eeb380c10f6a22c770d3651577a2c377c92ffe90bb"
