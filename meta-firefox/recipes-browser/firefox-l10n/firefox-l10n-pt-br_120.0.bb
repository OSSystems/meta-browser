# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "540fbaef124e1a37baaad6cbf064d0c9"
SRC_URI[sha256sum] = "1445d95f3b4cff819da34b248deb3f54a751c019160625e43b6cebb5b4b84f4d"
