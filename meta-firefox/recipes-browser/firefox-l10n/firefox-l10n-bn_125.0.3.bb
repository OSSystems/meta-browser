# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b1691b06f2d3d840404608ff0e039e32"
SRC_URI[sha256sum] = "4b79a68745264af8ac7ec6f9d27bd59a7c5f799130a01920e3c3570aabde511f"
