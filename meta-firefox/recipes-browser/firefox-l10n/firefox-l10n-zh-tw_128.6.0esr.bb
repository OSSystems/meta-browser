# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0f7220c466c9414074cb94794d348bd2"
SRC_URI[sha256sum] = "b768275b550cff908f313d3cf6c9f75612ad873382b894b444ab3e333584d6cf"
