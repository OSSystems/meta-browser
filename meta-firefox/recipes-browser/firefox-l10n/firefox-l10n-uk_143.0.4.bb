# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1f7bbdba2c388ef325e5238746cad11e"
SRC_URI[sha256sum] = "70f59df626ced84c579a4ef0e56a089936a7ccf2f5dad6bdfa19bff9d0819a65"
