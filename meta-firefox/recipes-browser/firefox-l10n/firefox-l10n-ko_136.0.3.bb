# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "635c02f829d6ec5c8a8afc4959d9a64b"
SRC_URI[sha256sum] = "25eb3bcf538e94748f6f7cbecff0b970fe6bbf94744a36bd09c9dbc9271db1bd"
