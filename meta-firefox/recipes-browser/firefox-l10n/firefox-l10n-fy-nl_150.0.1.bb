# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "49ca70c7325f0584b14e98f37949c831c1e4ca9b3c5ae9ac142c5107f3eef2c3"
