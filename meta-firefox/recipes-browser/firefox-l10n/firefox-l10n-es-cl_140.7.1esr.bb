# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "81642c0f130f9911f89120ad09f44679"
SRC_URI[sha256sum] = "3dbacdfb76b2ec9aaa5106ed5c5ffbf25246b65021e724b80f131be034487f1e"
