# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "dead73f6ef8cdb7f40fa6670e6bbd8d55220b9a383f9058bda94baa0f10fa6d7"
