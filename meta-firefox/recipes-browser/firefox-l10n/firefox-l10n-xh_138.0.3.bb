# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7287390eb99ffc0b8709f22a8b397062"
SRC_URI[sha256sum] = "d6ce1a41ccda017bfbeb1b942dd1aaeb8cf343ee605a955c252c29fb6f9daea7"
