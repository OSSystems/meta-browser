# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3c64a380040cfc4406dd94a97d5a6842"
SRC_URI[sha256sum] = "c515afb29689cd65be4c66f290402b50d2690aa0c5415a255e3368def346d9b4"
