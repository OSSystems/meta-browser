# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "785ecaa50496798d2ae941389e1196b7"
SRC_URI[sha256sum] = "b28110387af0ef972ae12945a874c0798106fcac99717de6a688298fd1dc14c7"
