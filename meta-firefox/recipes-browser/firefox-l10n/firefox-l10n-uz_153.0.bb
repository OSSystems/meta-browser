# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "9a33820c4b5e67926fb4da674c06db2ca98ef7fb287be4bdb91426ac8ce14a25"
