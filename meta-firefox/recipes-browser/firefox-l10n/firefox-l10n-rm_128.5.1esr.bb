# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d1cda927a5142102df0960244e01aba6"
SRC_URI[sha256sum] = "762a41a12b393a4d2bca5ebbe5e43e05ee8b6dcda5a64acb69d91c11b3c9563a"
