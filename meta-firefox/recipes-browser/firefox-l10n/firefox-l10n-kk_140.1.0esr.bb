# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c8e58974ae6c2f0bd6b4ed0c59bcf8d4"
SRC_URI[sha256sum] = "b45a8b137ccb22b9022da732163788160f595457f1e323e0ca1fc8a7c2820846"
