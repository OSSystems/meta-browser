# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "38a36fc5326f85d639b4d7011e91a9df"
SRC_URI[sha256sum] = "bba26d0f59a8ba6f5940f195901862d28d7af249ad898639532fe6be40773f0b"
