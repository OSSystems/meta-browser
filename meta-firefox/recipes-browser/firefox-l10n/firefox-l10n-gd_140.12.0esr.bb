# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2b753c3b3d71298a52ef31ad8abb5c01a89d8344659d1f7cff04ff8614481f90"
