# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7650cf0625c9e03be7ae9d4f44ecd59e"
SRC_URI[sha256sum] = "015cf1cf74ecd0c53ecfae485d4fcd9f6767febab755fbdb3b5b59773f8d541f"
