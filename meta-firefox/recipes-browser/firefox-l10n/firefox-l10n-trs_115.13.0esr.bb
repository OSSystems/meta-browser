# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6422896ebc3f75233bbcc61b96f6fd60"
SRC_URI[sha256sum] = "57a27a1e4da079bce23a1a467d652104765cee3f873da87b9ab01bb11a18a34b"
