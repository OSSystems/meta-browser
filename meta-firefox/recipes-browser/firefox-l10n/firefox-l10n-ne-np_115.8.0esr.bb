# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3d37102224a25d457d4b874b88363597"
SRC_URI[sha256sum] = "c785f4680bbe7ee4b47fe2aed7839348cef50ba69890c311d4af6b5f91d0cfd3"
