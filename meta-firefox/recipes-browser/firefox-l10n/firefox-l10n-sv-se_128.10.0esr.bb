# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9dafac05e229f72e16bbfa0fd9e276ca"
SRC_URI[sha256sum] = "590d22c59a473b3c01053ebbfa321e1d323ffe1588806de35608b1f9c7bc18f8"
