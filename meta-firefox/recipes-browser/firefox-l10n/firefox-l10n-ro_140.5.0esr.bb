# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0dcc2b212cd2f63cb5fa56a63b4b3cbf"
SRC_URI[sha256sum] = "f88c6d582d832280831a0c8cc12d4818c026c1d07351e336869fbcab4333a134"
