# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "068873de16864507423de235f137287c"
SRC_URI[sha256sum] = "7ca839e5f7547f7c3a4147c0d40a1d21234ffbe79fecd8dbdde71354e3538752"
