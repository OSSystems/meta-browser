# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "60b8a322c062f229840d5060321affb9"
SRC_URI[sha256sum] = "4bb250eea87d6b71a3dcc0b09f2e2ed24a1861bef84dc9a06aea40e19b1e51ec"
