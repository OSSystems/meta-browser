# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ce2814c7b0dc79bc12744f728b73fd39ddd57fd0448dc53483c58894b2360810"
