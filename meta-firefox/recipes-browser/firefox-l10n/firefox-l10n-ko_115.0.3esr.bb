# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e0a54c297785059390ac03048a8d86dc"
SRC_URI[sha256sum] = "8dcb52db49d3790ab6a3cd0341e9583b64328d8f94ad665f64fa574cd9857c5d"
