# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d5c00e2fffdb664acc6a100ca06d6211"
SRC_URI[sha256sum] = "8407a5d10fb131aaf9eb050062b653a602bddd68ca745f6170149373ff9a0507"
