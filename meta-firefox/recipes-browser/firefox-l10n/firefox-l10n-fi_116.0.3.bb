# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "75bff2a898c46349f1dfcce549534528"
SRC_URI[sha256sum] = "b381270ecf0b473cb54b139aec597ced61a0091b1fb6d96779cc987efb3a9078"
