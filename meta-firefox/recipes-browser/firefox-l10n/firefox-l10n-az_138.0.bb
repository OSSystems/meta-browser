# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c3ca5154fea611ac0d89568b3cf9d328"
SRC_URI[sha256sum] = "2f495e9164f419d823b04d998c048ff6986457d59075a8679a34eb216ff9b8a3"
