# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "b7c9cc75c9366fe2b89f8c6e4895c56a9e455005b3faacfcddad3bd70f66b4c5"
