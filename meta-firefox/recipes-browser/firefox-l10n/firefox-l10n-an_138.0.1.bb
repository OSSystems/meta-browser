# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "942a976e1fd8dbac32bae30116bbf303"
SRC_URI[sha256sum] = "c1ce8ca44edb6cd30a73a66cf562f934edaa8bbbbb85411ca36d56c61d00409b"
