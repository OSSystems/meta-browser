# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5f4c7af4e92807a7e68026c920e3c0fd"
SRC_URI[sha256sum] = "b0b5e6aa638047928f59286dbda5683300e46e84ea9326708d21b8520979d30f"
