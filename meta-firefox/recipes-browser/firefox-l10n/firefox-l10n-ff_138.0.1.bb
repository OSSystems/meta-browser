# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e4eef84f9e513d5f3da894b66b0793a6"
SRC_URI[sha256sum] = "95a3d287a025963f63f97d58f546f71fbfaeae8b64b3df1149566a43eda7e967"
