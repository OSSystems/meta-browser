# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "8eee54fa86e2253352187d5b7548a46cf852eb4acba503bff65c217929695c17"
