# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a2f4ce69e4b19e6eddcb1ecf04c4d739"
SRC_URI[sha256sum] = "604213ba99482234192457bf1f493d8da112094c97203244ce7c39b22f00c88d"
