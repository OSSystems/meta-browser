# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e16551ac9b24e61ae2e13f454abf4423"
SRC_URI[sha256sum] = "446fc21d3cb29e9b88bc761282b14cb0af39126fd6e7965905d23d6c7a2ff1ee"
