# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "52a1a4210a5420c4cd7138c115090c9f"
SRC_URI[sha256sum] = "7a23a6cdca117ddd0ab1aeee3a7cc7a24a2da2e035e60ff72ad6ba63a533ce64"
