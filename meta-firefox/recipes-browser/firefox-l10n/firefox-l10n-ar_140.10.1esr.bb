# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7775fd90d44e381beebf5c3a002f27a890f8b7154eb6d7aca8151d1350650e35"
