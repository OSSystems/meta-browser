# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0acdace97413a9a04aeeb8073b8f7604"
SRC_URI[sha256sum] = "b4c7fc95ef9dd306e7d2a33fc14d02efecd0772a2861fe3b8a3eca2df20fa4c2"
