# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cbf3f46185ebb0e86a5aea7b6864d26f"
SRC_URI[sha256sum] = "0ce7c75e67b0848c193872e0ed875ef54337617e8d76f81bdd6c0a50d274a356"
