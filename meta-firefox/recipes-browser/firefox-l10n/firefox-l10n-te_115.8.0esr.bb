# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4cb62ab1a966097a3b5e327794060bf4"
SRC_URI[sha256sum] = "51cd1c0783370af0822ddfe9e21649c81eee2391a4d5ede721ac744c52aae260"
