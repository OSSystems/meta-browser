# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "474cdfdf57a51ddcdf46ca551b2cf46f"
SRC_URI[sha256sum] = "e354cefeb8c55c791ba5a008f286a7f53f9bb8dad3238673242d945c5212fb44"
