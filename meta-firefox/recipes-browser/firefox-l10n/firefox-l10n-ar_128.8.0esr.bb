# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1c1dca3066168e02805ac2087bec2527"
SRC_URI[sha256sum] = "fb1b31a8710c6a26127f6b636a53d6559e7cef6014b90a0c97aa48b81bdc1ee6"
