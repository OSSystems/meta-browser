# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "86746ed33b3c8e2cd93867d85aff47f7"
SRC_URI[sha256sum] = "63b5a2da9ebc764efbd4f39dbc81e290bf9d9836f4607b3d03b3f8f89840629e"
