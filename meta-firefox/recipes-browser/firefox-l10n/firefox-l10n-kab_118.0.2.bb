# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ff243df99d50c44924592c2403629793"
SRC_URI[sha256sum] = "05daae594a335b50c1170e942bae2232a4f7766e3dc859128701c64a2443fe90"
