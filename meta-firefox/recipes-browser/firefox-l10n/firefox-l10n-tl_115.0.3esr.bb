# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5b035cddd97ad9a4bd80c6dd33ed297d"
SRC_URI[sha256sum] = "4ee81532a6128df2f5ca35c884151381b5c504b3f1552074bd8b9155f021a7b6"
