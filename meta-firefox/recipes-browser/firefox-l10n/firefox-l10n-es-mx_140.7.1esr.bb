# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ce38c95f8ff7b949ece945b090b4235d"
SRC_URI[sha256sum] = "858fa363480f1d22b1de24f4c50043c4a72703ba306edc0ee9859130de719b5d"
