# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "367e0ef521895688ff29212ed8b2d286"
SRC_URI[sha256sum] = "e2429d1856a7c097a0f09ba47d6440ad1f6e2d47da05faad962d5f66c7cc1ff4"
