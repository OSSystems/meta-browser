# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "00d7cc02ed083f38b5648c87092e6394f8bd89b6bd9d0ebcd8d3048a336c2190"
