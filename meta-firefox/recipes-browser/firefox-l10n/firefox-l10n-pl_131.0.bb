# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0f73ea6e30a52945c75bd48c8258bd31"
SRC_URI[sha256sum] = "cc38af64586e927036940c705412eda684035feee68eca33ed01c35bc14c95db"
