# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d799164e0830b96abaffb41e06119d5963c3f8e49076df96111597b0d22fd78e"
