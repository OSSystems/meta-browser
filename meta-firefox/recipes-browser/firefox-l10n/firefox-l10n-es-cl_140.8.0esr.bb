# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1042ccb5ad88286024ab3f55c933df6b"
SRC_URI[sha256sum] = "44846870e6a366ae8f7374e87412b1c0113ed28bc0ca70ed9409949aea50ece6"
