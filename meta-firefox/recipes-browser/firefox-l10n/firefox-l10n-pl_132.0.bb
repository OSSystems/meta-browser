# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2dde4489e3ec089bd8c54c32df1bab89"
SRC_URI[sha256sum] = "67ea02d25462280e5396841ea9983040cfc251c0f54bdbf34898ea054810fda8"
