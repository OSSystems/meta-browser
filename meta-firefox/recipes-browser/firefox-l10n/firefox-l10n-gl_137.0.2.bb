# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bb98c1eee27e684ac63e6346aaacbea8"
SRC_URI[sha256sum] = "97ecc1f6b3df61efd6ca0f085252d1f9b5492019b74e521e74328968a640e06a"
