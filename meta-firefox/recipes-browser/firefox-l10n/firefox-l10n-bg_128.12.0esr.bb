# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "24d41c089228a99f3a04a17297adc4ad"
SRC_URI[sha256sum] = "eb325f28df4f2e5d07af7726c9ef0c69cb41f0fe7ec7bd08ba5508a9be6e23c9"
