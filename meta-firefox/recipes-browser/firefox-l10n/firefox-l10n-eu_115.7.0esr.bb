# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c131c53d3423f57f43dc9cbc4ad1da68"
SRC_URI[sha256sum] = "3f429818adfa096c88e4ed5aa9af2658a3ed827ce88515246600e4aeb1008fb2"
