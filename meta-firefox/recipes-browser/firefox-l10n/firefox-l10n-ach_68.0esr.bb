# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7db7e71aca8e42ed7c16e7630b7f66cd"
SRC_URI[sha256sum] = "e31a6761c0e013f354b4e4a0d88b9ab145c05782f2816695a10e7f0445ccf859"
