# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c2211888d464b84d2df9659c17377d36"
SRC_URI[sha256sum] = "dbec826eafc80b97e2c3d7182648c65e2f54b3714322ce0f526eff826e70c38c"
