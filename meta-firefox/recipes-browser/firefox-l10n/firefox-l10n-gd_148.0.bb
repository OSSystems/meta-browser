# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2ad29592461dfa85642a41ec459c751b"
SRC_URI[sha256sum] = "da7dd547fa75ceecfc6cf68807f24084d1861aac2880571fb6d56d3b0c5c0a89"
