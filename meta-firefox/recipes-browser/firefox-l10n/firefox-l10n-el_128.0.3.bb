# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "17ea1f658c365278801f57c3e70f6107"
SRC_URI[sha256sum] = "81d297d50cae15b5e3a4a376067c6288a993c4ed830bde942192f24aaeadb3d4"
