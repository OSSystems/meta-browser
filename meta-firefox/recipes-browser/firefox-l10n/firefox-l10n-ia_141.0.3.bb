# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5a597331d564326a68bc016270a9c018"
SRC_URI[sha256sum] = "d1a61ec8d5f4da03a72f41e300eee7636a4c0ff63dd574f4f4564d00266dbd91"
