# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fe1f51a61e3d314ac438857c7fde8f61"
SRC_URI[sha256sum] = "74d87df78e34a88937ada70b23d470b2da77da56d944fc867b4ff310bf431ef8"
