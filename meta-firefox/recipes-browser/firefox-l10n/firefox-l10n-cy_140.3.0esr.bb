# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4edfc70bd71632d17a228b2a10e2be26"
SRC_URI[sha256sum] = "2fc52a393ff34f38a63847922ceee16f9c9686b43c0c2e06ea39a4646ebaec47"
