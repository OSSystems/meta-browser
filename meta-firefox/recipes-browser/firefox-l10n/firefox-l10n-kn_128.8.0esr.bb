# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b51660d5dc95cefeb0da79f48d49145e"
SRC_URI[sha256sum] = "96f2b49b74b58eb02aa2cc285fc77a9b2614924187e7f47d358425e9ea87982b"
