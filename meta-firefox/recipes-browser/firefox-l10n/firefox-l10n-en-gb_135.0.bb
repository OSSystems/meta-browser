# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8594f92cb9f727d67203696add049ac4"
SRC_URI[sha256sum] = "28ec62bc298653d7c86c1213cb32273bae261208963323424de0d4d07d9063b6"
