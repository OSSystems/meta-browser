# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "36a8c0c7c802d07868e319e5d9eeaf84"
SRC_URI[sha256sum] = "08bd98c7442aa1dc471c3445a814c534ed23d831dc764de0056658846f42e292"
