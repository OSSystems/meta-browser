# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "45a80e6582ba23f19f62a4e3ee435bb5"
SRC_URI[sha256sum] = "89f40991a44c8005c96fcb773ae9d84b55243ae91176c0c5c2493f77a6763abe"
