# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f46879d083f69a6c41405e1d67a8e760"
SRC_URI[sha256sum] = "aae692339ccb73b2c617ce4b483813d73007b6d5d82843dbe9dae116b4a8dfea"
