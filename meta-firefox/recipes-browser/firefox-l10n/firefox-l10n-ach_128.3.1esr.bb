# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "efef805967200abc3f17566cadf812ea"
SRC_URI[sha256sum] = "ae27d46d1f2f79b895ae39a292f5dc82a036141c56b6002be68f2e414af3b502"
