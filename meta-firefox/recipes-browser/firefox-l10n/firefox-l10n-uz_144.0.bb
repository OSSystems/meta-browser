# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "15529035e04a6cc9a6c1d70a18056155"
SRC_URI[sha256sum] = "8e782697825a434073e5a3e5e24c045f7e11a493d7323058c9b4ca38f593d247"
