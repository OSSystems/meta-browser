# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c28d3041f9235d423c93c13a5a7a4160"
SRC_URI[sha256sum] = "7dfddaf6197e1d188ef0651cbbb08513ac9f13e830bcfe87ea367c49e726260c"
