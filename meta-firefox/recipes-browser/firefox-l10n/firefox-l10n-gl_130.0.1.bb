# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b5442c6420855ae286bd441b53f31728"
SRC_URI[sha256sum] = "2d8f690a396f02d56bc611a43c748330b39bb2a80fd63dadb4a2d2a83129b23e"
