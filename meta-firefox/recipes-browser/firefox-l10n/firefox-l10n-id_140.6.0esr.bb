# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a01fd648eebeadda3fab44ff7d89f454"
SRC_URI[sha256sum] = "92087aebb242d0a918453a73c2f8cbd67601f93f899c4d6fb6a4a52f2b2221ef"
