# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c61af006d6984a3711861ca33e30c13f17bfd72fc6bd066bff3a3f1aceb3f11a"
