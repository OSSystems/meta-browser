# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aa708b6d4a097789d5ef97fc254a9bcd"
SRC_URI[sha256sum] = "901c2dadc1330dde969c8872b2527b2f1b9e4cb58f502ad7e614a36fea01c7f5"
