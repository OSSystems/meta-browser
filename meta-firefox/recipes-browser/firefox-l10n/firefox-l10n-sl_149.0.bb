# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8b5f05858cf7e8bcb1842319bd017489"
SRC_URI[sha256sum] = "6c3273c66a96d14fb5ef40f3f22702686b4276455653db3968140480e27b9c5a"
