# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "0ab62eba00634b1f71ee81835cf46f0a0ada8a72143c258e4bfcf076da51fefb"
