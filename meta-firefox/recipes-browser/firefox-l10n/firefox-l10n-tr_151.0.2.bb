# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c1e6d19cdcd4b68e4c8c95e4da147aefb61eff4d552f160e485b858297166fde"
