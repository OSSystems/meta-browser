# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "659141421b381c4806d12848366367d7"
SRC_URI[sha256sum] = "2463c0e84e59d272b60b78486e739c70d3c5577bbb346a52ddc219107335c6ff"
