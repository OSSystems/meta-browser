# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f4130774c6d5d1a9defca4f32da4faa5"
SRC_URI[sha256sum] = "deeb57f133b7956ff41cec2fa0fc024bbaf32d164e4431347f07bcae1ec68990"
