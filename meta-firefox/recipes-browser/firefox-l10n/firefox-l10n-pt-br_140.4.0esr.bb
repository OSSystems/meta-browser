# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ea755214da593b749354aeec814e6e1f"
SRC_URI[sha256sum] = "40f970eba86d7dbbf623ada516f396409d5d7686b3a2293fc230e8e49de94a3c"
