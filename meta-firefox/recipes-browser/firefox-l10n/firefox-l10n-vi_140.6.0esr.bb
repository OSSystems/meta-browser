# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8921b7b769c0b556534c24354cb2b1f5"
SRC_URI[sha256sum] = "d1c21022c61840f2ad0045340bea55d5a5589616f93672dae2b9c054afdd9256"
