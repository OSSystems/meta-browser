# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "236d8a05d14b74130d05c3b32007e48f"
SRC_URI[sha256sum] = "004d40f8a97eb525aff452c093ba0ca2f909e84c71e1e4b134d9a95e1147376d"
