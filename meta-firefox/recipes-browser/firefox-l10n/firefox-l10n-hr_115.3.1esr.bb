# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1dbe1b054c01b12cc88d1ff92d07ea23"
SRC_URI[sha256sum] = "7db61fb1e31738742b5e33a0bc65b25a5260f193ed6765f3eecd69d5bcc94343"
