# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3c57b632c534844383f89a64d43655d1"
SRC_URI[sha256sum] = "285ae4e01324fb4323417c870e6435d7e5194e1fcd6146b0a59cce9d6c8f9b53"
