# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b3bdc2d03d5a98b1dfa04da09de8aa84"
SRC_URI[sha256sum] = "69fcc6ff2044be806897edd4e629893ae83e5814ab6ec87416cd75fbcfe2c982"
