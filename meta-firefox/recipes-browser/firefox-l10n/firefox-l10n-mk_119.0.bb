# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f546ba4650b1bef178704e2da1b4c17d"
SRC_URI[sha256sum] = "cb7aba000b1f19b8e2a101d619e9d6a71c5a723a3f36dfc8926f5e8efe116b5e"
