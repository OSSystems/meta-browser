# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d462b676a11d16766ac971a8072b3631"
SRC_URI[sha256sum] = "4d426e55e283ac10a780286a3d7cf1e44a4273a4fc53b65ac3508817b06d1c13"
