# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "9f4c793e2b0330f4ab67bce44de697cb31c2992843c0a791fc3378d9f73cb0ff"
