# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1ce6c26575b4d2aed2ff52ece75b90c4"
SRC_URI[sha256sum] = "43b6e0260342684271c9c85abe6cfe72f84a59b27ac7b86963976b0c48437601"
