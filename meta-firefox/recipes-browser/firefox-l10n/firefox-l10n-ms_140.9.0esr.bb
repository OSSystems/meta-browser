# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dd47437242e1168e194647ba20d73151"
SRC_URI[sha256sum] = "aaf03db192fdd2915dcf9d86e670b838a5405cd6a9d3b108824430c43c815080"
