# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9eff00c02e86c46020086bfe0fa9bd05"
SRC_URI[sha256sum] = "196ca98956129c84e9cd4d0ee4167ae6c9676952faaa17e53acba3ce4c935dbe"
