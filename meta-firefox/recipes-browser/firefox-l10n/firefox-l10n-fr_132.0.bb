# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8db8891290a29602a6f7c84e01864582"
SRC_URI[sha256sum] = "023e262b7d4a62a6ecd5bcfded0eb8635b2edfda37dba73a7752669fdd02d2e4"
