# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c45c3d249cf49f46318881cd44eeedfb"
SRC_URI[sha256sum] = "0ee57cb9156ccd537cfec422b3e8fdc6cc3d21474db808e72861b43f06bd6109"
