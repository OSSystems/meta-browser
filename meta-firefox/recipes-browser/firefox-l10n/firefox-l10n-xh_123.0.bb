# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "be7a2bbe3bfbba04946070e7bd3bb90e"
SRC_URI[sha256sum] = "1b14173bd6aae51127dc665e71042169d9d5335ab4567ca5bc527f6ed2d33898"
