# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "56d18aca83d247829f8a3a93ae5034e9"
SRC_URI[sha256sum] = "66f847117d24c4ca8cc7907a2564c03e3d9bd4605b94ba78c316850036f7ae52"
