# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "893260c28b9bf94b410c70fd788e0b95"
SRC_URI[sha256sum] = "3e7b00b6cb2155cc2d150fed16dd6336c365eeb775060b403bbd2ed29bb49ebb"
