# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ecb455c0f86906c3d49aa2c26c8b9aa"
SRC_URI[sha256sum] = "6ff2fb3c8af12d55628e2a836fc264a4da223afda69e18dfb0c9f926378dda70"
