# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "70ef696adfde03f18dd0f1ecb206a5f0"
SRC_URI[sha256sum] = "d59bc4069312297d44ac0ac1de7e31cdb182263786efac510819ce3c21bf3df8"
