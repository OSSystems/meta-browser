# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "10d732ae598acb385b25659fc66b23d288c90c3b36ae0a9f11773f8a0f13af67"
