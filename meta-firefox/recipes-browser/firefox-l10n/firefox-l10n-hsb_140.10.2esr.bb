# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "fc894481ef22733752f7b726542aa9cb40a14ffa037d10ad7e439c9e4eed6fb2"
