# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a81b46862ddab1996b669b036b7b2e4e"
SRC_URI[sha256sum] = "f314234618e88ada2484e930af141bbecacb2d063651c5d2b98ca0ad82e73fd4"
