# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "65f883f2fb1c2b8b36f713507d69e563"
SRC_URI[sha256sum] = "3064a3e0c4abe0008d9a907b435513cf2b7396684eaac5db66200bb38c782490"
