# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8b64017f2508ccd9e09e92d9633187e9"
SRC_URI[sha256sum] = "420b155e460ff375c50deceedb85747ac957ab0609e577201a9ab84cdb81fb90"
