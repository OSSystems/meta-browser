# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "25d9285367562ccd93ab65d1745f977d"
SRC_URI[sha256sum] = "bcee530ced8e41dafbd1263794af8f4d3f949c6257db6dfdae1b18056f961358"
