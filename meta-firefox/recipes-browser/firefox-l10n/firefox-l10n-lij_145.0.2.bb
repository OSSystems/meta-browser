# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5230982c92fe518653852655cafccc10"
SRC_URI[sha256sum] = "e9d5194f8d857b41f4b77767d868c3ab0d543e7f7f383dc983a2ac54af4068c8"
