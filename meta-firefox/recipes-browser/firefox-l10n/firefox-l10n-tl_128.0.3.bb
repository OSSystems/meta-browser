# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2c04154db4ee2d0d99920141b9393ff5"
SRC_URI[sha256sum] = "a7099ebfc9086948519f902db5b35689c2d38907d8aca0cbbaa11dd261a8cc58"
