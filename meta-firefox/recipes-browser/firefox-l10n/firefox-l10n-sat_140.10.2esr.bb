# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "befd72e605041dbad56e541ce8b901417ad50bf9ac359a5e949b69da3ebe5575"
