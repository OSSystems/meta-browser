# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "245e6f0307e0deee792f268df7a7926c"
SRC_URI[sha256sum] = "9287a76ea53027b1be0e6fc2295d057411ecb269cb6e712f3e810cbe7b1fe8e1"
