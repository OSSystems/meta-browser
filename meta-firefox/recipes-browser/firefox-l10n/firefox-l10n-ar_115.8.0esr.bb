# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "755697f4020235ae208767c41db73bd4"
SRC_URI[sha256sum] = "761138c1eada603b7bb853f8a04dbe1fbe84445b5791a7a3645e9c7b379bed6a"
