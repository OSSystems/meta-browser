# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ad16ea198d8469510621323eac561b76"
SRC_URI[sha256sum] = "9bf24980d87982ad19cef8eb19d35c4f5b3781cb33e427603eb77f48d18ed37b"
