# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0af8a733f309f05bd4527711f0ea2ffa"
SRC_URI[sha256sum] = "25d839ea626eec83bf586c6d1728b555ee71abda5fd69ee523e19e85686d6880"
