# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3f32676b30159d10b5b25d13ebbe194c"
SRC_URI[sha256sum] = "e29924baed25d6d0512b4da9d81ea1cba34c92f7b25694dc4b53d5d6a11f172a"
