# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a5d92b8438d716bfd8d7f35802815ae2"
SRC_URI[sha256sum] = "9af4327bd3422abb9d179ee82a63c4ddd1c21fb32417be49ba7f49bf6974d126"
