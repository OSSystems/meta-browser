# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b092eaf33b82683c5e33e24b647f00e9"
SRC_URI[sha256sum] = "16dac63ac15202fed0a352e0987ef33cde6c1dc464ded6e5469939f7bce46360"
