# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "26373fc76e01719d7518b6ae9bbce0f5"
SRC_URI[sha256sum] = "041d072f727d2359aba70db1278996a8366fa6f11bb779f0027ed92059e8506f"
