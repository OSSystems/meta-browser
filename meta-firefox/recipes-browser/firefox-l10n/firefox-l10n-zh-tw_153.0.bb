# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7d5394810eaf6101369a60fe48690581c2149243bbad0a2516a917e6b365c572"
