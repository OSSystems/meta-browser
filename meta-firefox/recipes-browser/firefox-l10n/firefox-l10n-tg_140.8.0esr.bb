# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2bc41b2de0175c7b1a3d484cf5059186"
SRC_URI[sha256sum] = "f8a411b0a1e1b14458cb59f5a55ea61d95c8001f07b216fff32cdc209e177ff2"
