# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b49030a85f0b0628399f687042847c89"
SRC_URI[sha256sum] = "0712ed6cb4088749a774dde66fbdca19cd35607ca2f14630732dd5c2a6be762f"
