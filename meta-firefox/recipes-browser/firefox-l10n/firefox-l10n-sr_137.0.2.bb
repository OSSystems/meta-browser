# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8f2e91006459691f46d43131555ce3e8"
SRC_URI[sha256sum] = "6e5cc1d3de9f12d520abd41cd33da127bf1bfaec20af8c9c975b2f048aa99bd7"
