# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b58098fd8a7d1ed45e0e75326ddf39fb"
SRC_URI[sha256sum] = "1afc0836cab569c3d89c8181c6cbb3a9c0c8e9ec8c99cbd3f0f58129b630a9a1"
