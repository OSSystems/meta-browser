# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "02864a1bcec67dfac5c6bdef6249d9d8"
SRC_URI[sha256sum] = "b1c11ce731814b5a7339c9cd0f8539702608e708398372fae7a357b397f8886f"
