# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f6d4a7a12b7736c92163db84ee73cc72"
SRC_URI[sha256sum] = "c192748effd650c180a597ddb4a5bee9a8b0f5b7f24c8c26bb2bc5611cda36d5"
