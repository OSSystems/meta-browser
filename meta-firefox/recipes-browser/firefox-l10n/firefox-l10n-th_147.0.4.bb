# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "329c76d250f0b9ccbbf702e1e57f1fff"
SRC_URI[sha256sum] = "e4222b5654bda0f6afe5d5ff9d6fa8d82602d6c77adc83a6b060db4e43c68fed"
