# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b82a82a9057a1930696eb2dda7769bb5"
SRC_URI[sha256sum] = "abd1a9bd484957d9353a39c9e8ab72ee73574791516d23abf5ce2be101eb2f5f"
