# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c33d916bb1a165254b4c52d29a18ccc0"
SRC_URI[sha256sum] = "d05da966bc0f0325a6b4500c2305123d2900edab76f209748d3198730e2c963c"
