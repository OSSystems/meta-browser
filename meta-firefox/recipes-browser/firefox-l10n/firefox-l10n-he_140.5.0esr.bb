# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3cbdb0e802578b3f08cc002230ef55ac"
SRC_URI[sha256sum] = "1fbe96dcd6923b08bee44741a580c15585d5a0e230f9257afa61144170bcd859"
