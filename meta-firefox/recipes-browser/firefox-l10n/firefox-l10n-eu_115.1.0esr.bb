# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d461aec566af09d7536ba14949d479c2"
SRC_URI[sha256sum] = "998747eab8f7b512c419be0e0a7a1f5ac2d3da398f63bd8bda74c6c654248a3f"
