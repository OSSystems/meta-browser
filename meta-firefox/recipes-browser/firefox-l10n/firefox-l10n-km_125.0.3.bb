# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f4303f00addd3ee6dd170a40188103c9"
SRC_URI[sha256sum] = "cec03bac178767db9321106c9276788e3b2d66abd3bf99095fa5d8b115b14a08"
