# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4709bf6ac5deae3ace70fdcb83608885"
SRC_URI[sha256sum] = "db7e1f882f6d5a5b3cb34ae433b125edef4e664ea579d3952ddd980f60a98ec1"
