# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c2b41fedbec28ea13c1c853379e8cad9"
SRC_URI[sha256sum] = "be6c691c62932511ab7798c2d76799b6d82c96acb05bf28644403b8deb57f029"
