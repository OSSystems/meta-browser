# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ab95da347be45cb1fa6810ee2cac8a9116dcfad09a8548bfea7a7f51804b24e0"
