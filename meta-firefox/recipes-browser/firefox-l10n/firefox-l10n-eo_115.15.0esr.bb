# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c290383527f04ae41900c7be7c5d116b"
SRC_URI[sha256sum] = "3f59524c8ecb6bfad35813cd0d1fff6dc26ee20412c14f4fa5b17ce760800b44"
