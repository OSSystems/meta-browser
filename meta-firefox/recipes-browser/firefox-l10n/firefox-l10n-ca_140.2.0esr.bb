# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1b8fe41b11591e2df7ec9d55995837aa"
SRC_URI[sha256sum] = "0469e5312b7c612c71daa149b0927fb6821dc03d3940d3af447526b114c208d3"
