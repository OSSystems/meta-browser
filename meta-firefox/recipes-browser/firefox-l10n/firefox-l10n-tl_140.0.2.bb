# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d8e8311d1e3a8dd0bd46fac5dfa892e0"
SRC_URI[sha256sum] = "2d601b996685bf6e36bd9662501e1afb3ac96421ee25cae4b0256595caf3b696"
