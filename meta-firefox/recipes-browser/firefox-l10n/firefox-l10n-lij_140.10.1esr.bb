# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "a703d1ca752d683bc2a7ebdd5f7589bccdf2e23ac82094097431b0dbc3e5198a"
