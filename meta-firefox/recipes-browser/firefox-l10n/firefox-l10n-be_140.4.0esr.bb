# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d9bf0be1921afc796669b0893dbc3b90"
SRC_URI[sha256sum] = "dd248d6202aafda4ff3fdbf535919ad89b6fea37ef3fc3632b1ff1affc31f7b5"
