# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "97ee2120efb8b105112e8331798d6908"
SRC_URI[sha256sum] = "0f4a5a7bb3ec50db2a1f81ca43da102bff3cd7dbd5a794563d2e6bc2a912482e"
