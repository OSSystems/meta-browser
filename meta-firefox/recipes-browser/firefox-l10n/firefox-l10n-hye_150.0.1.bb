# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "9b036ce366315fce4ce70e803a75bd1a8cfa380132fe5f21a5c7965e5405285a"
