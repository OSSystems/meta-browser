# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "52a129155ad43ea24fd3cede0bfadc5e"
SRC_URI[sha256sum] = "6a72799a18ded73500b5629b1a70b034335be54f815cbf13e425f4e31106addc"
