# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8a7ce8f8334c3bb5c9f65435fbceebd8"
SRC_URI[sha256sum] = "bb59b8b7663f3c28f8dadd84991b841e85dc9e69a0739248aea789d38c99ae1f"
