# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "056232c2d0e0014d9125ebdfabedbbec"
SRC_URI[sha256sum] = "05944149ec5eba3bd74eda2872aa427852fffb372e3b4ff7377e2d7526977c0d"
