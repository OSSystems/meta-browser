# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "046de7196f8e8eaf1429cc3b6a18dbe9"
SRC_URI[sha256sum] = "3942fd3023aa19c2f3e7249a399051fdeed094cfd992e2df3fd455021c4fe383"
