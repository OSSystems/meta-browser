# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c1a53f83535acdd0689d9a77ebe4754c"
SRC_URI[sha256sum] = "74d0cad45471aa325e1f72175898aeb83e8421029396104f283b3136e3bea41a"
