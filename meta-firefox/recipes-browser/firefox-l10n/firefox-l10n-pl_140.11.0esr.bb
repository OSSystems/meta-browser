# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "636f1225c114497ce214ac78beeb206cbc8ee18090c15703877b60a825cafe69"
