# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b500d3055095be8bd7352c7306691f8c"
SRC_URI[sha256sum] = "2713f90027f341748efa5e62cc1865ae5776582c90fb930d37a926d1dc1a3961"
