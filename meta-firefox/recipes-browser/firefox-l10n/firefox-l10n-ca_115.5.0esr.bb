# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a5ddbc000db106c5e582f78d0b84f9dc"
SRC_URI[sha256sum] = "ed156500f8f1b32b7c9f66519f20f8c6f888a912cd12321c9f7717f57d367b1a"
