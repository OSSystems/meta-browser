# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "03eea126ecf7af2a74c90c5f6292b85f"
SRC_URI[sha256sum] = "8f4a083d5d4f00dc0b723fbfbb5c2de4947830dc03c1111c513124ebcb4a1dfc"
