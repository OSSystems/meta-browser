# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3278015f5dc3b152c78ed8cf113d001f"
SRC_URI[sha256sum] = "068067a051596eb6be6f43d6c15fea2bf0ba1774b8c3ce92174c488d2375bdf5"
