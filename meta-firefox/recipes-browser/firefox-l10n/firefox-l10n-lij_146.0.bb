# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9416fbf1ee7aac35f4dd233cf21ae91e"
SRC_URI[sha256sum] = "99618ddf6d51de814cf3406512beb92bb261398279ff30e2578d34dbec007608"
