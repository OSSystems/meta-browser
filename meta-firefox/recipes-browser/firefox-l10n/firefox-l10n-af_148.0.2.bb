# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8d47798e5d1740bcebfb4e898c978371"
SRC_URI[sha256sum] = "d0ba2f7c9c1d2f3e6cb34565e74f5a41f92104665fa58c378c3810bf2eb40a36"
