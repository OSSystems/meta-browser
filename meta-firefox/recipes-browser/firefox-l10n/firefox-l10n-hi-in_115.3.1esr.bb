# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b4dcb86509a00f0b662b743312370154"
SRC_URI[sha256sum] = "b0a90fb1008f72ac28a5e26a7e314d962c2d8a97f4d0c0f08eec9db1d3f24324"
