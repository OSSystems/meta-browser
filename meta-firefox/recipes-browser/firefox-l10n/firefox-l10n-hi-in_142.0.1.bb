# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3aecb48d56edb9d868fa8c1276629987"
SRC_URI[sha256sum] = "409392f24f9fcef02e57de5f1be31035abb8533ba50b2066541a7a97bff1d2f1"
