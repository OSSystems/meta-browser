# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5b2a12149d300c7fff247954787ba6c3"
SRC_URI[sha256sum] = "560fc736f1093d68977e825766f7073089181a6919f98cbf7ae0ea3191a614bd"
