# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a32a3884c0e123c3350302b5dda906cb"
SRC_URI[sha256sum] = "9dfa78e17f8a2cfedaaff925864f5dbb092a8c6ccc2b621e3c4be34d1be5deea"
