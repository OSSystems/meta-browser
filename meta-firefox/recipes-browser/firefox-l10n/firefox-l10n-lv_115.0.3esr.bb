# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dddc7b84465787ab86e2351257fe67b4"
SRC_URI[sha256sum] = "0846129e9bbca894c87c8f1734959b9039578c8ba48f18be6c6c46e322694c30"
