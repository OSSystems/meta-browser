# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4c583692ad5f5df52dcd544d9690a443"
SRC_URI[sha256sum] = "e1d11bf5e9c7df5a5a98735e00006f2766b561768217da4175e880a1c83ff276"
