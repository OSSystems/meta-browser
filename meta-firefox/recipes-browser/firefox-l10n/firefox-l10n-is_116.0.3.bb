# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5298b3a3b96b821d2d20620f5e8272fd"
SRC_URI[sha256sum] = "25903bcf4341c4aae8c7a84a1bde58337391ceb1be28bdd420d838a76f680567"
