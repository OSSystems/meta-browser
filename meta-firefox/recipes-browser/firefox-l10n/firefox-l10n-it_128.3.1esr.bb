# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b046d0a885017478bf59d1fcd2456ede"
SRC_URI[sha256sum] = "04ef085240f3a1c064d95b8db7ef17c96c67d869310b3a838ad27749c8eaffd4"
