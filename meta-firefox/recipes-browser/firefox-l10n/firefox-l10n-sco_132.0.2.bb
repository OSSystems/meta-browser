# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5d55231441aa972dcf5811de76809843"
SRC_URI[sha256sum] = "413730d754d068ab757598357541b5c8283fe212710e1d5dc0840285363fcd7d"
