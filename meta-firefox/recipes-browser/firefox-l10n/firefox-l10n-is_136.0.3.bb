# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "19722ca3a7974cb08e0996b993043fb3"
SRC_URI[sha256sum] = "3feeae9c1431c15c5e0f4b69c3daa64b7b6cc475140ad761fb0f3236f4895cf0"
