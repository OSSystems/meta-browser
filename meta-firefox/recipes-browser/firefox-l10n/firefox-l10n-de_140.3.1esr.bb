# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f98f374ac981028a819e1d2c73e904a3"
SRC_URI[sha256sum] = "c87ee56017b46902f0d042846bc0fcde38e3081db4b626784de7de05c2eef24d"
