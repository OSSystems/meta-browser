# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8e313e077aff76b48b5f51a874d7e175"
SRC_URI[sha256sum] = "74a02d4f7c3bcedbbf496df3033c364a61e98abca693fa58861d2a5b6294dfae"
