# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "504254ecf431efa2cf1d64ca92238d3f"
SRC_URI[sha256sum] = "917802c4c725d0150287c71a41b83cca28e7c4c4af1936fe1dc38b0f1ed32bcf"
