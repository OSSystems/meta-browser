# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6e2641926c6fa42f644b8e3d36804ccc"
SRC_URI[sha256sum] = "a8772a58897c2717c6d197a0c38514fe8f36a248e028c0d27b702a4b840753f7"
