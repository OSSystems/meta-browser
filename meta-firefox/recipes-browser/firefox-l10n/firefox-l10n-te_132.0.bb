# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "33e288faccf2968ec6a798c661fe2c10"
SRC_URI[sha256sum] = "f3fbfe9df6f6a1794ffc9ad0fc906a22c96e9e0e4d21ec18c48fb3963d636899"
