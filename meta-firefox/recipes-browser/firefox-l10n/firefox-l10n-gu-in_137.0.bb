# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f5c77dcbede74e2df62cfa3841f68b61"
SRC_URI[sha256sum] = "1cd2f09a3e46fcc919b057a4a84414e249a0d73ae538eb63d523e3959195a7be"
