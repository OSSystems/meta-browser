# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fe95b0d494a248c682021a17b796803d"
SRC_URI[sha256sum] = "845adc7305a4e4338fd105113845a924119b56d8bab259dbea6d56d01ce69e85"
