# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "300ad06b0d5b2f709b87b0ee5270bb23"
SRC_URI[sha256sum] = "bc5247ae05ac96f511c8d0a92df2114e5bb4eb2aeea8b14f0b8f1679ecb9fa88"
