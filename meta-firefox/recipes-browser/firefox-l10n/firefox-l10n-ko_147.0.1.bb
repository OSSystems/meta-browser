# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6de50cfd365431c07e7286186dad671c"
SRC_URI[sha256sum] = "e2f08ed4ad58d1e3dd294d956ef67c90e5827d1dc4c5dd230098d2a2be9d3570"
