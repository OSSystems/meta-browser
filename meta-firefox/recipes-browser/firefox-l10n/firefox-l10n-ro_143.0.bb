# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a3e81dc7f3a21770e34836e3695132fd"
SRC_URI[sha256sum] = "bbbe81980f5bd0f0355b2792f90537d20347211c81c9ec6519aeada20243fec7"
