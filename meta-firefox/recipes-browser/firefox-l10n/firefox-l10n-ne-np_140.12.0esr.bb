# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7bb1514a90d6bada66d03dcfdf29b75a64e8b33d01f4320e1d7591fd18adeb2a"
