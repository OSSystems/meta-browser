# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "9c7afbb6b4cf1424dad5ba2cba339fa951369e77301c6e3cda39d815d416fb27"
