# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a0d6957c7c6ae4e97b3ea8bc0ef9875e"
SRC_URI[sha256sum] = "f1d0fd24ff2e69cd84621601f1db49d445be6b66c4df2057ec5173fa9a80f1c1"
