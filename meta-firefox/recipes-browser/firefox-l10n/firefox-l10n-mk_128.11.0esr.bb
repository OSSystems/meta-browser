# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2ee9f4d263c0393613daffd6780e7bf0"
SRC_URI[sha256sum] = "18336c9c0cc6e194df8c87df24833ea572a48720a5f1cf598691e8c9029bce60"
