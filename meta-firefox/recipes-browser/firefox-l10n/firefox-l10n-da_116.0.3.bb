# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b92bcba1d4d4bd3c514bf3f60a6a6d9f"
SRC_URI[sha256sum] = "1238b132312c934094b15d16e0e1e11c85888d0a19f66a9a92708dbf7075abab"
