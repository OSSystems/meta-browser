# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "148b8af8fbe49efdf874f79673997d32"
SRC_URI[sha256sum] = "195b9c7285b974887571c73bf65b0b5b53c0f61c01efdcb127063d08f31d1977"
