# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e51bb2e2f82c2335a287f30dc2c8fab7"
SRC_URI[sha256sum] = "50e1fefaf82dd268e17c2c79e7298cc823763ccb5f0ef60f0f15f7ccf38d54df"
