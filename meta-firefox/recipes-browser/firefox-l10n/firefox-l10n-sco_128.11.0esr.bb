# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c7b5586cc72fb8c0046f86d5d1627e8e"
SRC_URI[sha256sum] = "b0802c9f695924f852876f7b9b6b88d50e63c57961d369e046281d2f0d6c95fd"
