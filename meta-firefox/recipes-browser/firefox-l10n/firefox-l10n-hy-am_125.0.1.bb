# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "32c2f1ecad1c5b4b970a977d8bf9707b"
SRC_URI[sha256sum] = "02005a0a9395e8cf1a3e6465d860ef5b72cbccc4a73c7e401549aa7b56f0bb0a"
