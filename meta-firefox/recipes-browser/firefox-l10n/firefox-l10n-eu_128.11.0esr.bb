# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ad93a6ce02b48978c28c861383db0e00"
SRC_URI[sha256sum] = "e1b56ddde165ce954bce54097acfc350fd3d4b9e14e8cd77c532f7c464b0c94e"
