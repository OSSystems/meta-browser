# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d95e2f17833c9ba803fa9824d719acf7"
SRC_URI[sha256sum] = "2018081383c509f55bea02db87cc50893c255f05cf7323f482e69e8f02094a9b"
