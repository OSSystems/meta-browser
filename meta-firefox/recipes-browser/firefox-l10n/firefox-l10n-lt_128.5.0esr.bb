# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "279287dc0288905f23f3b002f354ce03"
SRC_URI[sha256sum] = "2404bd0a010c4452cf7e39695464d0c2665b9bd65214f33f7a074b188ffa654f"
