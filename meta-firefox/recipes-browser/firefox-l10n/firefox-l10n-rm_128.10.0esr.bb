# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "429200143952e5d966b1f688e12c009d"
SRC_URI[sha256sum] = "965d3cfcc6b557660b8fb566535bd056cf57b8bd9b8513b32fb7233f1ff9b748"
