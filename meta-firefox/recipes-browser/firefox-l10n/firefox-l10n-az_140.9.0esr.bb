# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "830c90965115ed158243d254f5c7a600"
SRC_URI[sha256sum] = "fd91dbe27543b3812e2278c6ac39280c6338de77a9934fc7913bfe8d5b8af4fe"
