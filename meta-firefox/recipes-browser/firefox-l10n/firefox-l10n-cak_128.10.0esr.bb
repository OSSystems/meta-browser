# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5fa865f71b2cea04e740e21c11fc7d67"
SRC_URI[sha256sum] = "911ddc06dc9b944d83832010ce61026436fa5a5e75b5722de0c61f9d4ef47245"
