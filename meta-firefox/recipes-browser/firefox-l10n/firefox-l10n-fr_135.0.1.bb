# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5cee346dd6d4fd2e5f184a37c8be3bf7"
SRC_URI[sha256sum] = "a5e100572cbaaee5f1e5d5dbc75988ef2d8eb06d0fec7e3a7697e75c411e4475"
