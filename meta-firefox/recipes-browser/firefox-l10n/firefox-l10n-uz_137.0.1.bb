# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "60774c62e22f3631a4eae6cfb875594a"
SRC_URI[sha256sum] = "f1e2601457787a1941cf784677661c0462f694d2a1f1074b8668e090bd0b1c03"
