# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eae03415b433fcaf26c6d3940657d97d"
SRC_URI[sha256sum] = "4ab506d9923f81e9cf136536a16fa96bb45aba291c2b991d3d6f23e6a9603a58"
