# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "55a225d53cf6dddeb9144d5daeab2013"
SRC_URI[sha256sum] = "1400bf26e65ce776f47468ae305d65dd9b1d9ec74746cbacaf47c4224ae9bbf1"
