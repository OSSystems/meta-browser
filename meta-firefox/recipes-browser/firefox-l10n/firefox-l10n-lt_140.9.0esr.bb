# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "479b40be50dea9c73063ac1e22ba6b4a"
SRC_URI[sha256sum] = "8a480e894929c96ab3c861a9db62aae12f3779616f8cdf0b5a449cb8fdb31e33"
