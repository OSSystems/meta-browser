# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a821a1e9b36dca57439dd542ce540fd2"
SRC_URI[sha256sum] = "504eca7bd23e932cbc536c717655cc1795fde345b039ef49d00200ba802063ea"
