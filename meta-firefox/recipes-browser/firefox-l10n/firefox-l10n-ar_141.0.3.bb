# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c3518a5d9ad3d7dd5bbff663c7e56df7"
SRC_URI[sha256sum] = "74e156bf9cb6ae7d1dae4518a3203e376b2f26d142c82ff3dec72cd2f368573d"
