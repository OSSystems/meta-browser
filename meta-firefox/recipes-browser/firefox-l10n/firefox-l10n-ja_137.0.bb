# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4339a11c260e663554a4daaf8db33f94"
SRC_URI[sha256sum] = "b218aff745cbb54e2f8a0b827933af8922269904beae593b481dace2dc26eb0a"
