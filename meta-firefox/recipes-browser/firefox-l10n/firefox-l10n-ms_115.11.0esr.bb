# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d041d586174de82c14f17ea45cfee0e8"
SRC_URI[sha256sum] = "c79e240cc355a93d042395d1e84f57c04e628bc8aed5feaa4bdb2c8fa9c24320"
