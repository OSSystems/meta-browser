# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "21f1d8640e1da44fab52d36b4a2fcd5a"
SRC_URI[sha256sum] = "f010cbad223dbb5271896ade5d5ba78f434df05e416fa77b13f855543108ce53"
