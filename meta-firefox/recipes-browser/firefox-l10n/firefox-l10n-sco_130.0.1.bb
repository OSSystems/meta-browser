# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8bcb24ad1aadabfddf6db80d47eeed38"
SRC_URI[sha256sum] = "bdd6708b3e1e8e99efa6b704c1378b11a3567689cec8a7589da216dddfa98574"
