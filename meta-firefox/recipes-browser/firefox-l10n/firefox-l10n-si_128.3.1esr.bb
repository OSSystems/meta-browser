# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e755c28516d18d0d9cbc30326186dd7b"
SRC_URI[sha256sum] = "b78f7c9172eaaf18b837671017c4a2707beb146b4adb826c7ce262a506de8f96"
