# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "56476ee1386973d2bc253d4c718c5abd"
SRC_URI[sha256sum] = "275ecd7c6fcebab0cc00564747822988e9b2029e3f0fa033cd700583034bfd7c"
