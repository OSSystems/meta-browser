# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5bc98329cb9594151d7996e33d1a94e3"
SRC_URI[sha256sum] = "6939156212a24666b260ddb9385c529dd597890ff466b431a68441b7c7f85e1b"
