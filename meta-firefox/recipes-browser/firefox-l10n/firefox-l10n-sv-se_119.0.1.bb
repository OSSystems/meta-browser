# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "19a0f621522fa4e06a83c92173b12d0d"
SRC_URI[sha256sum] = "c47d9ce786a654706acc2310e75aa5cadd2572f14ef07fbd0517feb9c7928088"
