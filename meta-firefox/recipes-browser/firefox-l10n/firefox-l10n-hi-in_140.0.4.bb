# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d02b42576ba3dd727e6aac82123e06c5"
SRC_URI[sha256sum] = "9bb172df22bbaccd7440fa0e3879286876d18535a18e4db5b270e8284b587bd3"
