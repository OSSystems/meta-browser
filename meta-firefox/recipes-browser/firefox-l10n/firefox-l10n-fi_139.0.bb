# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ae53dc95bb2c0740c12b75eddab6c9e4"
SRC_URI[sha256sum] = "be6f16c4d05116fed74addced7d1114dde476e79db78d2aab19dc0b0abe7c233"
