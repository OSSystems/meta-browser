# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dd7b764c334e9fd5f342b0882de3192a"
SRC_URI[sha256sum] = "a5c138ba84c6999bfff132e915baeb67e2b248ab370a1000f3db4969c20e3993"
