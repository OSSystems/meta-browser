# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "87615732b9b0f58f404466ea0be94b56e9be379cd88b910c42de438bd5a54676"
