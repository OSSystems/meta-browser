# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c9606859c5b943e5bada01f34b42cb8db781ef03d3a820a40d69fe116e28998e"
