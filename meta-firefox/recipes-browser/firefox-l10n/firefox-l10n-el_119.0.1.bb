# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7f1e8fd90da65871a8d7226b93c883b9"
SRC_URI[sha256sum] = "9226605aa5a5ea88f6d1006625373cf116300fb1b5a63141c6f4af93d5431867"
