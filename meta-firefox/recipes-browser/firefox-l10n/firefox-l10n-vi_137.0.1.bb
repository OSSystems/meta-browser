# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7f88979e1fe0585548c209c1a313aa72"
SRC_URI[sha256sum] = "51953b4cf87baf395f3e79a2f8b5e35fd9ab5120e3bf663f61680a85c99bcb91"
