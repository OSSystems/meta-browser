# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0f3c3f80839e6b1535d928f4685751e1"
SRC_URI[sha256sum] = "9eb57b71a6d38b297cf844ee0918b2f597b81cab9144fa32ec823b2aaabeb224"
