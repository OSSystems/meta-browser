# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "37b7e8f5b45d51ac0b37bdd95110f049"
SRC_URI[sha256sum] = "0b52472847eb32d0aaec4069923a764c7c2bc215b48aef59578589fdeb96505e"
