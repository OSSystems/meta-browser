# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "594d3c44ac4cfdcdee87a3034726d1f1"
SRC_URI[sha256sum] = "6237c012dde9ea2ca40566513eadbd04c7ac09d39d2c20a50419b80131dd0968"
