# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ba40469a36319224af5011c86e0f8081"
SRC_URI[sha256sum] = "2abb7bba38f36b138b9ec2becd5608e69c18a0d242cb6b2f3f792abe8f40be53"
