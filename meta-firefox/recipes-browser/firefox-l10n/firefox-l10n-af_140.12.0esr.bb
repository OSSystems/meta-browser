# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "540c89111ac7e04d2aabf83aabd9a21e188b5bee7d59fd8ee1bcacdd1671b8b7"
