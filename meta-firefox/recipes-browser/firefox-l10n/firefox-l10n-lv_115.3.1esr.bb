# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5bcea48c7efda83cbad0718a0b58e97b"
SRC_URI[sha256sum] = "3e6c606de88d111a4eae5b1cf4384bcaac1db0a5afb4af46a30757c81fa92ce9"
