# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b96a71f08d42581b44c32db80786b7ab"
SRC_URI[sha256sum] = "87c32e07df5d0848783695ee6aa9070e4123a4718f0454d90270e0d9f52eebc3"
