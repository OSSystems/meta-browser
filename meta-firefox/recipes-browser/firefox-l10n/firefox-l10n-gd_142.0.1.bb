# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5c34b16f92a6d1e23648af88c3359eaa"
SRC_URI[sha256sum] = "20639ef19abbfe537854ef3a9eb8ad269b71690597a38ea4bb3985de78ae6420"
