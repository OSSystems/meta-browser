# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "242ed8022814f5c0e875fcb301051c7e"
SRC_URI[sha256sum] = "66da2d734f57ea905c3c3b8ca7d69a1d60defa6aa3af82601944b9d135553ea2"
