# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b2af858e0f69d98368f57c37b0d83195"
SRC_URI[sha256sum] = "a1c05a2387625f32200043d82f6f53d254e7e7fd9a1a9f641476565f10ced008"
