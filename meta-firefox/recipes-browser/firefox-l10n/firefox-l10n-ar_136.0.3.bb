# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b71e6e230b38e7e8d9194e186be98ff0"
SRC_URI[sha256sum] = "ebd047d8d128e071165e307656ee22a5fc3a231244698b01db324f6ddc05bfbc"
