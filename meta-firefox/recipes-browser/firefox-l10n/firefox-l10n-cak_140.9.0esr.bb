# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dbd34ee6513f5cd7b12595c486a86ffd"
SRC_URI[sha256sum] = "c7478412fe9670701842dec36e1043d76817bfdf5725b5a5e2d40406f6a5fe74"
