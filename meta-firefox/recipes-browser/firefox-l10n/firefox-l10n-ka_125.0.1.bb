# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "377f2372571a254d748f3c9d6cd19f32"
SRC_URI[sha256sum] = "0a883765ced27f8d2a6452a7e74ec0cfcead81efc9f6f553b7bd8c032e55c75d"
