# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f48cfb1fe9ddedcc7eedca7f2906c9ca"
SRC_URI[sha256sum] = "75ed9682b2de045d41670b50e3ae57e9805166892d4e97f343ab064c50d2056d"
