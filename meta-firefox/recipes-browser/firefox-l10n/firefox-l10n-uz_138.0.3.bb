# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1949a59621e57054eff0e6ef097e487d"
SRC_URI[sha256sum] = "4734949157e330c613aecdf18ce4be207db8f2f40b57906fbbda871ba71808b7"
