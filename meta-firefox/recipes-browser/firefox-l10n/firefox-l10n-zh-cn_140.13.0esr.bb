# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "fed7170efc2bf6d2ebea8e1cc81094842ccd14c94a5c87e640fae691ff918d31"
