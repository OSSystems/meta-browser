# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e959a565e93bafcee194dff22fee5c34"
SRC_URI[sha256sum] = "23fcb03ea29659c630dc48e13da4e747a0ebd9685adca23e121bf89ac84df0a5"
