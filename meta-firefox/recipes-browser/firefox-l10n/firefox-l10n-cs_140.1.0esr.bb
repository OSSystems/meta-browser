# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0dbaa221e658b47e2f56ff293e037260"
SRC_URI[sha256sum] = "d6dca04d276930e72dc4ec8bd9d070eae67a08eff387fb2bf3b27760d7301a0c"
