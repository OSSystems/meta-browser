# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9e020fdd335cd73cad0b8bf5fa651038"
SRC_URI[sha256sum] = "6c896f207d561a4a5cae37dfb41474ff8e20d850391cab49ff109f3eb82fb89a"
