# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2e7134b73a591996250f6dc2bbe14168"
SRC_URI[sha256sum] = "6fb6f4e4ed408a1042cea588122912abd3829250e65178f2662182360d6d4270"
