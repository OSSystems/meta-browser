# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "98eeff1279ca443ca4cb9342f24d41fa"
SRC_URI[sha256sum] = "e37a8db0f2d82e46bd63b679cf08d3317a21f2c609c3ddad97276446a2c67df4"
