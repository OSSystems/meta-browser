# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2933bff646c4d1dd01d2a53a2b38be77"
SRC_URI[sha256sum] = "844f76842a9270ac1742b382ce895b1fbde63a8810cc1fe2f7f32d65d1d63a60"
