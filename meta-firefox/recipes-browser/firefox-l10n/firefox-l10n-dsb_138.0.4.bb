# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a2e5bce0d69890709a9d010df87700be"
SRC_URI[sha256sum] = "d4afd58fbfc2b08340c99737fdc068891ff814b38a64f2b2806263b0b67b961f"
