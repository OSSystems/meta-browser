# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c2d469264f5c49e4d0129cc3f3b20a7b"
SRC_URI[sha256sum] = "8c2ef2f0b00817b907813814241c20fc718b3cf78f0e1a2c5f15c02d4ad33761"
