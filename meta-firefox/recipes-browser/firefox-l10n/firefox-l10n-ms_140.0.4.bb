# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1b24afc8ddb1bfa27e38d93667db33cb"
SRC_URI[sha256sum] = "9007d0ffaecc1cc6f22c2b796239e04a912336a9987f5f3122ec90347a8f570e"
