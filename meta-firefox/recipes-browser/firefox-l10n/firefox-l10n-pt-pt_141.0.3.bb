# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b6e02ce62e701c446f787ea2bafb6bed"
SRC_URI[sha256sum] = "8e8aae7affb007508cfc31139a6513114e75a32119a66936d6e79a815a109ef0"
