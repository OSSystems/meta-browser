# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "130ac2504eac60cc138ded70cdc31df6"
SRC_URI[sha256sum] = "bb080a6cfbff052c1b4e266f7fef94ef363abf6a8f7aecb8b00b1f42ae74d164"
