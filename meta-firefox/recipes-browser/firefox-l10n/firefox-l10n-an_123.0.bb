# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d3f8026199fe7ebcfadd1b94408300f5"
SRC_URI[sha256sum] = "4a17bc2781265e1aeb96bafad1884ae26ad9578d212f3a707496823a0da5fde2"
