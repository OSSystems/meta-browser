# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0b2befe46255c7d4b24e2edd3cd99fc8"
SRC_URI[sha256sum] = "516804fdc55b092a7f063586ba9e6ace36c1d2b0936d57581d0a738924095c52"
