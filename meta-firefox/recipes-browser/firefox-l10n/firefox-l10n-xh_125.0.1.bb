# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "06e4865d9a3a01224af204752946eaf3"
SRC_URI[sha256sum] = "a32ba5185eebc267e02a99029f47636f8d7f9877eb7c6306e1483e047d3f1b58"
