# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d1116eae8911fdca5493ff211908e9c3"
SRC_URI[sha256sum] = "45e8a24d49640ece6bcebeaba146d1a0be0e372e88d0ab93336a0da5bb22901f"
