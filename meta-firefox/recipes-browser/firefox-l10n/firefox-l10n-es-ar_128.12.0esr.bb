# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6774395a798bcee706df64e2643c82ad"
SRC_URI[sha256sum] = "02e1fc935fbb32db4c59d5f588da210530b6a4dc1c0c270385ae531ae9a37009"
