# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "5cfdf23148ca955382ae70f22b5c3d7390cba2aa524a85da87ee7239c72fa509"
