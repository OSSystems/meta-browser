# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3337f4589d6e6da6b4f4e46776f1f1f3"
SRC_URI[sha256sum] = "5e033f58b7183032a9eb19d8a18ce6925cbd3a117b3ee27c16ed9b1fd27f9ca3"
