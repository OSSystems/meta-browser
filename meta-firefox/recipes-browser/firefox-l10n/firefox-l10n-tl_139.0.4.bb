# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6da8cd1b790012da67674ba5c68dfb80"
SRC_URI[sha256sum] = "6bac2b8a816a348eb64ca750f2ebda10e34aa6d9d0e5b46b4e9debd97e498bae"
