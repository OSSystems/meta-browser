# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bb86b76e77626d7c5fa7e8961e02e45c"
SRC_URI[sha256sum] = "e141ecb647bd561fc8fe1eac55cde361f8aab48cc9ab18f87199c95e156c7b9e"
