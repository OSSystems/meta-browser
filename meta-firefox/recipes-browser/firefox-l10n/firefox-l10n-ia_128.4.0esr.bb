# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ebe99fc6de198454378af89d0febd475"
SRC_URI[sha256sum] = "fab43b7655c87bb9a582095f71c2c72a9f55e161d7d50ea71cb9504fb5819e1f"
