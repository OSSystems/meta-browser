# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c2dcd3932865737c47d8741bb32b14c7"
SRC_URI[sha256sum] = "1ccf29ef10352f00e2e685d420ff08cfc5f563faeab4da1bed0f41226b83ec1d"
