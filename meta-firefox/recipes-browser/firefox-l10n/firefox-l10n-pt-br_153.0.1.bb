# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "71b30d025021602b267e589ca97438cc54affabeea5a0ea7ace42b02f1ce49c3"
