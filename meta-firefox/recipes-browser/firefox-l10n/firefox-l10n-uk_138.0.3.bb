# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "55a2123caf6998cf741313413ffc0644"
SRC_URI[sha256sum] = "65471eb4e69f39c60901703abc25eadd0d14848eb94206a9ed6f5894b8015abd"
