# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2b2899702c974fc27006820d06cd00bd"
SRC_URI[sha256sum] = "3bdbc78cfd92e615c4d432c0344794961dbe9f2fd60cd81adeeb37786cd47b5f"
