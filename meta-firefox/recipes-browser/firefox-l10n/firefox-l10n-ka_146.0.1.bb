# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "58992badbd391d5c6ecf29f851bc018e"
SRC_URI[sha256sum] = "954c21308a02d5734eaf00b1ea3104fc02cd88dc602a7cb5dc1c6a53b957221e"
