# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "567c4958d7f1a89908949829f86c87e3"
SRC_URI[sha256sum] = "d472dc8b109c0d6c46814d2d55b2bfdc51f915af16c9132c502bc62923e246d1"
