# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a009e99a3dac5a5d7bf232a583f2adc1"
SRC_URI[sha256sum] = "0ece58443d3486a59b917c5a7e322ebb5fde5cfe60b54edfdb10a0cd9ae652c0"
