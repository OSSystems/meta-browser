# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9a9d44e0cc408adbec34e7ae9724c876"
SRC_URI[sha256sum] = "a21d05eb9ca221d59ca76a6da59a8fb33bea7bc722e6746a2acfc7353ca59e76"
