# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a84a4c39bb6531c2ca14119e23892f3c"
SRC_URI[sha256sum] = "027b4bde6833f610d28bacb1615ade4916e816bab16b3053378eb581256d9511"
