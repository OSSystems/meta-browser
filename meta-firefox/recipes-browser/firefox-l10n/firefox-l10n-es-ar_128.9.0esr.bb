# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "168ae63eed5f6e2aac56481d6d530e59"
SRC_URI[sha256sum] = "a7702152b69548353489186c8de341f6f6eca9994d2615c5c02a4c7f4a6c884e"
