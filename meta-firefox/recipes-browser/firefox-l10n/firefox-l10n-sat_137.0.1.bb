# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "663546c72342abc022b6533a5617f24a"
SRC_URI[sha256sum] = "f101c83c20d080ebaa3bf41fdb34137bd54d5feeec2e5a7333f9770e5f57c23c"
