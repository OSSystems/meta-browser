# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2f0e617904d8cfb1dd21bd78251edfc6912fd7505c9667660942354cec03f613"
