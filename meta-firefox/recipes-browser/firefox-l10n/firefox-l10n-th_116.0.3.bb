# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8c06d50f0725969677f6218c464b8cad"
SRC_URI[sha256sum] = "f1108555a0f1f0c8d0755f2f3809b28408ca6373aebcf495dc0686113e8bd1f2"
