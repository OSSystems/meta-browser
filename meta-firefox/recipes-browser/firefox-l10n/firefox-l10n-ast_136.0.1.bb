# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7df20aca2ed2f0096c31e02f2df2ac18"
SRC_URI[sha256sum] = "eed5a1813d359aa5f767ca098a450dbcffd88b23307faa6bcac77b6b6909288d"
