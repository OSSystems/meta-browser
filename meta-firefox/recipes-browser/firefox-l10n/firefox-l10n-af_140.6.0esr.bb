# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e8c0572363bce19ef511aa366e10600f"
SRC_URI[sha256sum] = "bdb564b972c3fa281d5600820681788211ff0962318fd9c2dd812dbbcd9611ce"
