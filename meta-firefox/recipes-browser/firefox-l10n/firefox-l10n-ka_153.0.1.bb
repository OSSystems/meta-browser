# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d824aecb28b022c0c97baf563561b0c771c6fc043827d9bd4be47f607cca9e2b"
