# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f1b5fa68c6b87028ff0dcfb90a0f82a6"
SRC_URI[sha256sum] = "b8112e9d24e62669c9a5652a897af3eb790d08a0cda0b243e28d6d94a47614de"
