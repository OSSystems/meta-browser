# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5b23871a089dcf6c480824e037f84632"
SRC_URI[sha256sum] = "57c416b37e497df894afa8bbf8457c0329197198ca59cf6a1a17a4011e9e36f8"
