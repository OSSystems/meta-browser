# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2498f7182da14925d6a750fedbe935ab"
SRC_URI[sha256sum] = "f25f3fec4b0720f2dc162f44b5161326860bbacd85651d6c82eaed4fbd88247a"
