# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4a74a0e411422d2f97a38c560375ba10"
SRC_URI[sha256sum] = "698dc415535806e4ef51f5056f61827400aed50a9c13c1282b601d80a006a9e0"
