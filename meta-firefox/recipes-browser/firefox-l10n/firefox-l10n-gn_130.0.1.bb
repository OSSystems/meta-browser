# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "135fcc55d8674f221b64e6c9f3ffc28e"
SRC_URI[sha256sum] = "be11761d0726d66bfb9dda1115c28e79138771e1aad5477a8408bae0abf08f81"
