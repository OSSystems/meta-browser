# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "12370e280b36d0f47ba455be2f0c1c1d"
SRC_URI[sha256sum] = "d3a32f453fb323ad6e4cc7d67fbfdbbc6d706aad0c45abaa0de10c15a40cd00f"
