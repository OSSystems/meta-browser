# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "356049b8a11a5cbc69079cf0aebb97e7"
SRC_URI[sha256sum] = "c81e6de5ab7c71be41a32ee26f284720db134d433a34afe3bedfb5dd06a81fd8"
