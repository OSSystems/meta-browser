# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d2baa9646cc5cbc1f9a18eb1bb3f5ffd"
SRC_URI[sha256sum] = "ff246f18f4b5833bc993b0f257068e7d5c0d93c0df2efd9650823a7a50872de0"
