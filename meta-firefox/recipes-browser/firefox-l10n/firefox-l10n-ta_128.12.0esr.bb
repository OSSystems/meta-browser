# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "00abf5638af80acd0640c5bf9d719fe7"
SRC_URI[sha256sum] = "2a01ebd552e4a332fbbed06ea9eea7cbe6ca61007b802e5dcbbbe5f2f4a29286"
