# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "da6e1bbfec7d78b2ec03f1a322f9f822"
SRC_URI[sha256sum] = "ac4900fa1cefb0f8ff3e03062471c84b9f577298890b80d8f7aaabc4d5ae4910"
