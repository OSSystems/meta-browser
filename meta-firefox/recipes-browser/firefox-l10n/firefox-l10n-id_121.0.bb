# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d0e4edd0bba5f8c93b7c3b7bc42a15d8"
SRC_URI[sha256sum] = "e27b31e65ac9d8d9f284adb3f4fdffc876a38bb66e3f534d84699e4d966d2969"
