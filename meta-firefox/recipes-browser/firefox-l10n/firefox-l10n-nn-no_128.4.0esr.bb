# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "84e1d0fde7ceb3daf776c01fa6a92346"
SRC_URI[sha256sum] = "b996962a7acf14ebc6284204773a6ba85a7d059c59f0217c3c624daa9ef88ac4"
