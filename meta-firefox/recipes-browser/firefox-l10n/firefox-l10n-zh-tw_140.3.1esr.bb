# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c67c9ebf8eb31eeb8a58ee1035bb8706"
SRC_URI[sha256sum] = "b2da4503094b42581732d3ce2d1e3cdad9164435d6edd97ed38d605775956880"
