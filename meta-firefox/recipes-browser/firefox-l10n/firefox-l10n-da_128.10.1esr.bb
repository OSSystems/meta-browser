# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9a5cd028b5a023e29cf5616653968033"
SRC_URI[sha256sum] = "124faf43e14ca3ab67ab11f6c50d36070f83d0a5cd1ccbeddc565dcb5db3f2d2"
