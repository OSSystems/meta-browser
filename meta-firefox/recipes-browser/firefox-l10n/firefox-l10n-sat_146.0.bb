# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dd40c3185caa02aac1fc5a49578c4955"
SRC_URI[sha256sum] = "70e801d9422656e2b8caba3399629fdf799f68545f21a6b22b029e033f5a7043"
