# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b17bae3120a707a9b065ecb3d385585b"
SRC_URI[sha256sum] = "30e2df599f363d87bf22ddf04b5c04aa9ed307b07ba1b3463faa7f6c6f7b9f5c"
