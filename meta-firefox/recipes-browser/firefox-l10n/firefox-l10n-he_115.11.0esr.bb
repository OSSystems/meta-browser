# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5bd607f6955bcc5524de26aadca6610d"
SRC_URI[sha256sum] = "818e353aeda12ee09ac15c6d47b4573d7bd57b1fd46bc259ac60f637b9d8ad73"
