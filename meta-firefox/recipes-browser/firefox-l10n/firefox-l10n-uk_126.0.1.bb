# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7e4a301ced59182798acf5b67f09cb63"
SRC_URI[sha256sum] = "4794aafb3e37099c0999f5cd9ad8cf708990c7bfa715538101db2fee863fa5d4"
