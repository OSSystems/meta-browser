# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c0f72dab130260994c21a0bde749e359"
SRC_URI[sha256sum] = "2f440eaf625ff3c4683e77ffdfc4dd2603581a2cc36f1551a0ed1fcd331f381e"
