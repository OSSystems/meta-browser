# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "234b7a4b58e33a0d207746def9fe34a8"
SRC_URI[sha256sum] = "0d7645161c2cf4d5ab1106f22a97cfe5029427389587eff4971a3b2e03f305da"
