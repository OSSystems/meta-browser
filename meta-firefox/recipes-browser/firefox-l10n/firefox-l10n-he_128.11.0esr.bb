# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "189ab55c8e53468b9662d0f067306112"
SRC_URI[sha256sum] = "2e680cee93f616ccb742034ceb95ed7425743ef12af48d8e4e0ac53a679525ca"
