# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8a3616b627c103e474c6edb490f616b6"
SRC_URI[sha256sum] = "29c92ca0dfeb3099aa5368d1ff1d33dc0411dce8d1e25b07c2a90ffddab0bbaa"
