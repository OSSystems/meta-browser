# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e1c72793d977a4076c07291468cbcf22"
SRC_URI[sha256sum] = "d870b654e112f88e24d5867f7032d72f56766b3138d65a5b45fb77e3743c4475"
