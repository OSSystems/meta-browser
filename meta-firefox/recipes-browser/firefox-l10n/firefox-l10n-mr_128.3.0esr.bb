# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "76da5c38008d00cd30069d3248f13d06"
SRC_URI[sha256sum] = "dda10e73559ad0b1c4cd9d674e6f61b730fc3674356c126fdc6063c33431f33b"
