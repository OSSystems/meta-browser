# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8559fce392e2741efadfcec4fa324270"
SRC_URI[sha256sum] = "505252221ee5ffea7b91af972902d27f2c6813eb3de45ee53582ee64b9ab67cb"
