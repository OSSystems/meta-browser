# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "04b100ddb2dc3815095936e88d3b335ae612b84e041de5e327ad427e7cf6da7a"
