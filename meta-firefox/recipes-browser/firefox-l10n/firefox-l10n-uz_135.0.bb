# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "606936fc0df1880bbc3ebbab52334050"
SRC_URI[sha256sum] = "8dabd013ec7b634db648f37f3d9ef0069d235fc651db9950d96e5c49557aa14c"
