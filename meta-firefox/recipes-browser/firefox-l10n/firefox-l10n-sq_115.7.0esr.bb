# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d6153b3c21e4df10afc886e097a14e36"
SRC_URI[sha256sum] = "bfe2f5079badaa6cbd456ddddc65565686fce4cbd361f24acf7fadde5b82e6cd"
