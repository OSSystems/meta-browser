# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d42d3cbe6ed24fac0155ac9a9df29116"
SRC_URI[sha256sum] = "74038751a9132ca893742eb9ec858165900938e4e2ff6a76eb2c3681fe8fbffe"
