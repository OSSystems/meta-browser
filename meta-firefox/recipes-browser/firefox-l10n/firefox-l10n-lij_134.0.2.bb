# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0933b87f95e8d88421996627047ac942"
SRC_URI[sha256sum] = "7aa67d94c00d51f3b886219aaec99f68392970f77a4ca54cc2937a15f8aa33b7"
