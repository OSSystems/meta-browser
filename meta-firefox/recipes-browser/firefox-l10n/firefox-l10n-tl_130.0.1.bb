# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ff7918ac8bef1b426ef081d99547db0a"
SRC_URI[sha256sum] = "08f28482fa786b8801d38aa1ccb242963578070355d7617b09ddd43fa959c9cc"
