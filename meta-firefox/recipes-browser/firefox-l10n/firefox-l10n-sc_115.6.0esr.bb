# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2ba93b4a2954996381f5d26278c47d56"
SRC_URI[sha256sum] = "ff32e14a5c9744393d1127915ec981b1228856c0c40078fd2ac2eb7232d8587f"
