# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "1a5af90b760317167c96ac6e87ff0973d128592c8689d5c0a398ccc5a8baff35"
