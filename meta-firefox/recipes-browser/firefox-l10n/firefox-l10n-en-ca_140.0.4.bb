# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "44027e41ab814379ebc6f17af93dfddb"
SRC_URI[sha256sum] = "df74177b4ff0f357698262644ee4203af2e46b10e0bff4ca13ef190d78ce39f8"
