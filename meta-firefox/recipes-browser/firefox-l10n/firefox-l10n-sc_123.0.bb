# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3bbc111de8f51626012bfa0ec55c7cc6"
SRC_URI[sha256sum] = "03c2b4fdf3cf0a26a1ddd18b9ef034d248a7b4e7102a856d27dab41755cd6d7a"
