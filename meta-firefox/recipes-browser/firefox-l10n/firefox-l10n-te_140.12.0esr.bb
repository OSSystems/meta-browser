# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "4dbd75e5df18423781f20e0749f364a292f2d6507a79b1e5495733f8761e6154"
