# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "df4de75cbfb47cb8f076dfaf29931239"
SRC_URI[sha256sum] = "40534394804ce47efa39b6d399ca61c04d44fb4c73a74931fed51f190e7dc47d"
