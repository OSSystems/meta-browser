# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "13c3ea0409ac87ace47341c88ea888e4"
SRC_URI[sha256sum] = "2039ce6d5dd1e622e3afc4c7eead2d81c537270662fc1fca4efa0eeb038affa9"
