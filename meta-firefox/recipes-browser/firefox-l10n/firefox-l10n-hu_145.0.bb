# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3395b7e350bd39b119278f5967de02cb"
SRC_URI[sha256sum] = "a0e9c0b4849b7d2c825f300e31a39b7faf01b108038c6b92925d61047f563ea8"
