# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b770cab3f876177672ddd09b1e218bfd"
SRC_URI[sha256sum] = "b78e314f5b47a3260b0391aa4d048f192b76db7a03fcf85faf54548b8eb77a2c"
