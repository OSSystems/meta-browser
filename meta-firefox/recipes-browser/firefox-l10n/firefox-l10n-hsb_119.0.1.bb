# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7fa06413b7023d691391cb6fee984127"
SRC_URI[sha256sum] = "44a96912f281140343aff14a870a3b381b6f0ab5a96e374f05fb6631a2dfc17e"
