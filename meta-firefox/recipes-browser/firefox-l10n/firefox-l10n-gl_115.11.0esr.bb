# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8c13d927ce99e9c12e0f169c8cf85b4c"
SRC_URI[sha256sum] = "db52a2447ddc26bf2af24af2a5ac13fcb5105914b8b9cd253fcfc66e19a20fb3"
