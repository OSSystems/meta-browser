# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "543ed7ef3affe0f5d4a35e2e4a1e9b0b"
SRC_URI[sha256sum] = "4dd3c368bca9b1ae532bc2282674a80cae2dda9c15aadb7dff465b411af5b00e"
