# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b32804fd23dfb76b6fd20ded35012d45"
SRC_URI[sha256sum] = "d23e91deeed0d604de50b30d704c9793a1ffa1579047e596bb5258b099849a8c"
