# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3834bb8780662a5e3b1703852520311a"
SRC_URI[sha256sum] = "33f7eb7891699bbd18c85154cc7be5c63c734b7c2f608e69c40da43e73d9584b"
