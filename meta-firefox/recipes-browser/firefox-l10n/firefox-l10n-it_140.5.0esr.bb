# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b146875ceaf0e178eefe14f83733a1d5"
SRC_URI[sha256sum] = "59d28b07c35ba98214647887c667c8ee3bd5f4f8112df5b7da0dd5244d93d4a1"
