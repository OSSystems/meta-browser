# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "779c353214ef15c1421d2e5d377b2512"
SRC_URI[sha256sum] = "627c7d78622860db1a3b14300857f42a807fea7208f92a32b793ae9b3103df6b"
