# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d2e037bc04f2e53601e291e2d94236a5"
SRC_URI[sha256sum] = "0d006fd242073d6ca1643281ece062c932572a81c65acf66c5acfafa517ef356"
