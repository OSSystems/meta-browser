# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2c411de9f84d34aefabbfc930de4700f"
SRC_URI[sha256sum] = "cf0e815c1cb34100bc188e726e50fe02a00d18097f7438bbbccee02f941527a7"
