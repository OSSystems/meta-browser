# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2e0819bb9b3f86d1ae8c21f11840e655"
SRC_URI[sha256sum] = "ce0e876952358d01ab3d076b34131a1baa2eb18e7f9f2b4ab441fa53d98c602c"
