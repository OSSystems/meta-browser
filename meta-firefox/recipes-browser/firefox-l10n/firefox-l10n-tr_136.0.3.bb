# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "65cb5fb585828c136fa4c6612cd0aceb"
SRC_URI[sha256sum] = "2aeb5e79d4350daf3d150bca624608ef95d97b17e756c26490704aa0d8de4a81"
