# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "32422be0b6f12b11afaf2c29e5b5a3b8"
SRC_URI[sha256sum] = "831b8f6da70b51cac8647e3df67c45d97c2d1e701532979fbc0508661df672ee"
