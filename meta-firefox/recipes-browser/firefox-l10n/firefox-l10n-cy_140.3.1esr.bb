# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2ef22388c89a305b61c306daba640f37"
SRC_URI[sha256sum] = "53d8d139fbee3f8cf7deb85bbd00c55985f2d44feb85afcd2c4fe08afa80046b"
