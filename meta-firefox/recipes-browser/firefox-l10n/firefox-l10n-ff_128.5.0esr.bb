# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ada8c72bfab15353e38b5047e10ff0d"
SRC_URI[sha256sum] = "c47980fa24b5a0f3218bc2b301ac7e31bee0b2dabcb5f0276ba293cdb6cd964a"
