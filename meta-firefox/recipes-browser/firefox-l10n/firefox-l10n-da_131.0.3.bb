# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "586b2915881a4ef819447f74ce019cef"
SRC_URI[sha256sum] = "6b8f78033b738fe34e33e862c46d6fa0582daa1710c1382fd6aabf4fc5fe8c6e"
