# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "98a0e5d8069c5f079d274326571d7d26d06aad24083e54abd20caf0df120ef20"
