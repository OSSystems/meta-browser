# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "858a8caa7e54d500e5c7400360b23742"
SRC_URI[sha256sum] = "22bfc3d14ccaf366acd2e41a0da9ae8397b16e93d782325ec0278693ee87f0b3"
