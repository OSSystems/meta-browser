# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6f801a8c78588f3a38fe4e6e599a4be9"
SRC_URI[sha256sum] = "ad8b6b5ea25d5fe226b90ef85dddfbdefbeba5c2f3799d7a7983d1a8ec5ab6f7"
