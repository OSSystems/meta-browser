# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c053383e8c436bf7aa6acceb6da507b5"
SRC_URI[sha256sum] = "0f4c79892e6c526a04a2c3d6ff774bc4f8d2c237550a6a558257cb0d3c92da91"
