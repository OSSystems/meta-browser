# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "830ff48766d8741132e8ae26037ac4ac"
SRC_URI[sha256sum] = "7dee8d77a384edef5929540f9dfd48537a68ff0a21a6f768bbf5d89eb0db4261"
