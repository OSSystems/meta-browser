# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "801021b4662df0c720a89046c6a97cfc"
SRC_URI[sha256sum] = "71f40b5dc43e67932e8a5b0ece09df16eb1cf1f04a6209b4ab41cdce358557c6"
