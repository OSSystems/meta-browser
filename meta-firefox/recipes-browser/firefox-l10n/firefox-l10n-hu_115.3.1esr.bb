# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0d9fc99b130edb1716536837276b6d40"
SRC_URI[sha256sum] = "eb1190320d3c64e07d81cff6af16fa7299d9c1f4dd40555bb1b8a3f4ebbb22dc"
