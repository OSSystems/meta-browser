# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a30aa9f9717d390153ddff82a6911f5f"
SRC_URI[sha256sum] = "71010012b16e1204b69461d454962a20745468c44228d18f8ce92f30505dcbc3"
