# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "10d5d74ea2d05ceac3228267fb609484"
SRC_URI[sha256sum] = "1f0000a80456f3ddb01e7fc493b1e0351c0d7369763a6f25e9cb800c9acec059"
