# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f319390e9ef71cabf6a09ad4a62ac3fa"
SRC_URI[sha256sum] = "15e16539d704bcda90bf70a31407341cb6b85a55ceb5278ab314d84331e8fe19"
