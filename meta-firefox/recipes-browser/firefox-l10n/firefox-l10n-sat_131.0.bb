# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c1c974dae11dd7fd5b806bded3821610"
SRC_URI[sha256sum] = "b0e632c9c3cb74645cf6940b193789c2095b2be5d6722db7ccb3c1b96a259a43"
