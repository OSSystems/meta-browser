# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "9a95649e83298bec92e4a00e7fad82cb7f515f04612eb49c6879293a93fa3769"
