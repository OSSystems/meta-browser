# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a0b6fa8a89c0536b3ec3ee31b6e984be"
SRC_URI[sha256sum] = "becd43643b1d646f60b50034a0116f8b7351279e0b2242482d8584b234fac9dd"
