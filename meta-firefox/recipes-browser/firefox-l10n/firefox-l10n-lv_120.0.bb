# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3a8167c2c17f20804b510f1fdd214e97"
SRC_URI[sha256sum] = "f63a5f3f903f8c3f06dbb61ee67b128312b847a4596e11a68adb4bc51e96636d"
