# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fc104d2f9cee7c2da61fe72a4bf935a6"
SRC_URI[sha256sum] = "39f55ad8c153695b153e4a833b8f1139cb09fe45a25f0f2cfb55e2e2ff1da701"
