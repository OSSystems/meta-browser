# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6fe25af2369f7bf3e82b14b47c79ba1c"
SRC_URI[sha256sum] = "c417f1684d6a79d672c3098b62f5b9ca19148abff14a3143b85240bc3f5b2c35"
