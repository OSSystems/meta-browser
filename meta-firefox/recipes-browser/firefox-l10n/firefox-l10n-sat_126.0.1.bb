# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a70575bb3fc1e0e1d925bca735e16e20"
SRC_URI[sha256sum] = "d93c6ea40e4df387e291349d9305e4fb02f84444fde4d0b22090c8a13b80f9a1"
