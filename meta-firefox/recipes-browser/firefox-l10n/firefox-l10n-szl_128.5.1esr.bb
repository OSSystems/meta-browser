# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "60a99a181c4a76cde5227710d3ac61c2"
SRC_URI[sha256sum] = "df2acc4a695a7b87e0f72b78a59baa0bf23dbab4d3a077dbd49fe2db1249a018"
