# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5ef0e099daddd2c4a98a7c74cf44489b"
SRC_URI[sha256sum] = "f44dfd31bd4e3294d7d21260aa2dfa8faed9f6e118db00fe5ed4a0e68e88d5e8"
