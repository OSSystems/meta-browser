# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "04358788e4f8d623d4edf32a4e9c941e"
SRC_URI[sha256sum] = "e1bd2e5c51b22094da62b04cfab6bd7e8ab7b968e7f089dd52e3b051b022ddce"
