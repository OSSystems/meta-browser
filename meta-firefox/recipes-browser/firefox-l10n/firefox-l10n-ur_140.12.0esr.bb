# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "68cecb8058f03e2879af16bedebb4dead3192cc8ceeae8610b9d1824c87622fd"
