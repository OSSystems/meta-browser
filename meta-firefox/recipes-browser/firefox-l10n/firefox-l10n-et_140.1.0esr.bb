# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "90c7f495e01febc8f1a20ac9aeb04af4"
SRC_URI[sha256sum] = "7afbd38386dbc967e12070d6e0dfc827d4d2c9e8628531ef4fac3b747d84bab6"
