# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "a98de9a9145103d3533dc54cb8f3f04907aa5eaa518fadfc950f79d18721035c"
