# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "30f572cce44c4a2ed276082d783b069f"
SRC_URI[sha256sum] = "259764dee242ffca2ce116d1602aea8fea3533cf00c177883df9122d7d7b5ebd"
