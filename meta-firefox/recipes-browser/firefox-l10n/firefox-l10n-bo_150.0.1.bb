# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "f497d2f9fd5a3c811af1ee22892d658b9a1e0744963cb6702e1d75008dc92230"
