# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ef41ca9992188e3e69ced3a439666a8c"
SRC_URI[sha256sum] = "901d1b4d37a6c42fe6f454f66510187254e25e1829225e4434f76f85b5e83032"
