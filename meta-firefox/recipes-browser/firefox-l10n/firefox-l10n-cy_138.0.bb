# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bb0861de0dabb3f7cdfa708fe146c87d"
SRC_URI[sha256sum] = "7ce828fdc1a93cc479a4ab76a3c3af83e7d52eb9f1f61c2350163e13eedf4d00"
