# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e0a220e7c88d736f603afbc80ddffcbe"
SRC_URI[sha256sum] = "310af55f1a4375a90fa80c522ba160a7728ac2c99b2a9bc01632ee80cd43e247"
