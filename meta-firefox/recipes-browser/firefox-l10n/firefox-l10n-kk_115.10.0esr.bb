# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "34389b3fe213d5b356e0991e6c9341b2"
SRC_URI[sha256sum] = "c9b1b9aeda1915f1f6b1787365ec80abfc2c177dc211bcae3af3c70dc226cae5"
