# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fa8dc32731607b3a8df7fc64cb57d354"
SRC_URI[sha256sum] = "67804729e113942ed7e747fda1d6e6037f2751e6b39d579657793a2208962be5"
