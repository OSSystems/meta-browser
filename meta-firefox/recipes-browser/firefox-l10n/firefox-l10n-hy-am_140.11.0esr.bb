# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "dc98790a73d618feac0fb78efe7e8040263e7c9a9d51e41e4c3291357f7e04f8"
