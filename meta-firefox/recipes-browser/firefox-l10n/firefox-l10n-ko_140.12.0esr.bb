# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "45bdc8d22e3cc20dded551fa5a7b4b55cfbf1ab50f1033566b6a7d3e8bde6542"
