# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "434d7dfb74f72770a434d88e1827a4e4"
SRC_URI[sha256sum] = "465b1b59029a28ad768def41b834f65108e908fdcf27eee292b116193e286c9a"
