# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fbb83f091101dd6e54b774f73d0b62ac"
SRC_URI[sha256sum] = "f9233c86f7a711d4aaee83af5b284846af67c7165f99fe121a5497254c161cdc"
