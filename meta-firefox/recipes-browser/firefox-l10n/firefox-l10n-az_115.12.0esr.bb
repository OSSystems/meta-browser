# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "28f8e3f40dc27605477fc0274671975e"
SRC_URI[sha256sum] = "5cdeb9e23fec1f610b48656ad20782d3a1bb6ab86b702a51f4fc2b73a514fe3f"
