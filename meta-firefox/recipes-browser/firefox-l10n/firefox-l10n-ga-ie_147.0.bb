# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dd59aceb4ad456b77f40361c308aaa17"
SRC_URI[sha256sum] = "4a21766a7c68730384393b048e707cdf53c693fdd0954ce6801e684ec9d4fd2e"
