# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f4ebb7466ffd73c88f653eaaa7a5dfda"
SRC_URI[sha256sum] = "352c9d66a7f2b1ba911ae66283e35fd72b01ca242d454ccf3e3721106b90af41"
