# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e980e98c7e11edec3beccb6db1b90a47"
SRC_URI[sha256sum] = "92655ca29fbb5e077d82eb56e02c454bd8c670ea2aafd924159c1c27a31c8e90"
