# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0fbafcba744c12f074d63202f30d84fa"
SRC_URI[sha256sum] = "a70a08c3ae7773a49f187e7d0a259c0dab495dbc6643fa7a945f333e64b6af9e"
