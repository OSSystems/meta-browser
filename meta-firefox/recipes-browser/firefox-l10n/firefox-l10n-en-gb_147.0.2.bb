# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "32eb814b3b372c31bfa4acd922768a76"
SRC_URI[sha256sum] = "3ac039dbfe755f0bf41e52780d04994aac7ced999cf265c4dc7e14071abb1fda"
