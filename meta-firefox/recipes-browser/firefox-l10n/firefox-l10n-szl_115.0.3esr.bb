# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f346dfa60a63d30e129ebb8aa14f0b03"
SRC_URI[sha256sum] = "565038c276ee28dae0bc4ff2c464323107e178683057850861a7eb94b42c8346"
