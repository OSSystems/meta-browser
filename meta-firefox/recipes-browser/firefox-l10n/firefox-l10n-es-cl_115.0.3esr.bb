# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2f768edea858df05fe1b7ba9765f107b"
SRC_URI[sha256sum] = "e735715ac65a9f62abf4be669b207e08905c0a602dff60fdc72c46081cd66c88"
