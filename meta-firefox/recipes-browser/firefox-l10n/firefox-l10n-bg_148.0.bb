# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d7421120b032580cb806fef23f8abaee"
SRC_URI[sha256sum] = "8e4292bebe2a92da96b04ad5080f389fdff6baf4214d6e90b270f7672bdbac8b"
