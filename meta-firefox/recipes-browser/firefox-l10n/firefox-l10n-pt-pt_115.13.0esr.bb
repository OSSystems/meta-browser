# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4bbbf62872ea3edd088f460cee3587e1"
SRC_URI[sha256sum] = "fe5c4da798a443e67148f0a601e770dcbd774306d4ca3ab864b6174c6ccc6ca3"
