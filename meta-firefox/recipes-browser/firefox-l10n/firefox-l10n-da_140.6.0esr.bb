# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "34c8cf27da93e547def5a2af8279f3a8"
SRC_URI[sha256sum] = "c56a497614484c668456bd95e6750576a4af804f9ca3c4f534c854c93e397d97"
