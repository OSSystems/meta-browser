# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bb56fea1cb92347fd4618a3a458c673d"
SRC_URI[sha256sum] = "b233e299f6974c1f7d7aafb1eb4523566ae3a92698390cca5b4cbee91cce95a4"
