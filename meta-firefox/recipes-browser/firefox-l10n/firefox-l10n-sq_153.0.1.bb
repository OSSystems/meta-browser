# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "949cd447654091f5c4a882bc533b4b93cf3c5fa208bc59e97e6fef4399bc91ed"
