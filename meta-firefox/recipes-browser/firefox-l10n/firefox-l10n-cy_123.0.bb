# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7e346324bdb492ff5626379d7b07b5fb"
SRC_URI[sha256sum] = "6f9ebef63f72d16584486a04e14f26b78c5a824680bbe730be7f9780493891fa"
