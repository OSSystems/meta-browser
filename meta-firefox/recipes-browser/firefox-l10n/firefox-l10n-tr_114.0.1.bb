# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8ee29e27b49c5b19815fe28d846e259e"
SRC_URI[sha256sum] = "966598c7c93ea703969f26984f2261f9c461d8e4cbf5115da5c200b7ea870ce9"
