# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "42a5245d171ff0368497fa5df31d5ada"
SRC_URI[sha256sum] = "8d1d8cc6bc34852413f891659599715ef105d37daf8d0503beea3ec805165678"
