# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "499c416fb97b80aef9493157f56de7ef2d0f579608261759d06e18e824f36f8f"
