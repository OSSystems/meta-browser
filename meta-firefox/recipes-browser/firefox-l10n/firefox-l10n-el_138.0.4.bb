# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "16bde552b72c3398bc121691dcf4d94a"
SRC_URI[sha256sum] = "7348ed9914ad2d8d478c1a03cdd6a42a58526f002bd687cb8eeec448b380fa03"
