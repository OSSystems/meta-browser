# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ffd2b595c2d053bc685314d21e30d160"
SRC_URI[sha256sum] = "dce49fec086e97ac754532ba460c53fb7bd485f702fe56f124a0ff9476675876"
