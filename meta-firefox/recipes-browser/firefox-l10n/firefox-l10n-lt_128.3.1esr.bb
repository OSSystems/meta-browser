# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "590a749b8bfaf3131d2dce1c62f8336e"
SRC_URI[sha256sum] = "118823191f4133e5950d765ea568e944cc2ed753322d2e656d8535feb3c2f1df"
