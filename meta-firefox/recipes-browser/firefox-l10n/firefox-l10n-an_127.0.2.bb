# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1d1142f76e9517a62750e3c3ef4a2a52"
SRC_URI[sha256sum] = "bb0a6d0eb8d7f92303de9ff6b6f8ce502db171dfd2be5186cbcc63f03afc8437"
