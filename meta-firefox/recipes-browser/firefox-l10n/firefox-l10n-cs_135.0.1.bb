# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cf86168b81233e1b545abb5f43cb70b9"
SRC_URI[sha256sum] = "3fc62047c7637cce876d23296afbfc1acc59ba7293458b7d0b443b8161f6b88c"
