# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8bf61df5b756a9e420aba7483d3081e3"
SRC_URI[sha256sum] = "009f1c7067250b029073466c5066ecec8423551af89771b997d8fdb4a165aae9"
