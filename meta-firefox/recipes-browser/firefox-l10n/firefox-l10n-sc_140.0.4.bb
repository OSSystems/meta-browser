# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c8536dfae34f147a8f731728cb10dac6"
SRC_URI[sha256sum] = "f9a5d83d653c6fbae0e9d5d079245e817aebdccf1b84c55a808cb3e927b1b52e"
