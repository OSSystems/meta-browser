# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0847a2615fe734a1781955d891aa3b35"
SRC_URI[sha256sum] = "d1c2f4b384e660c76ab58c6ecd1a041ced113ae0117ac0a0fc991113079eab78"
