# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c66297683a66c275b12a500c3e470868"
SRC_URI[sha256sum] = "5f06e2f2165406fbd3bd648910337b00a25d7f487f9d39af67c0bc5a7cf1bbb1"
