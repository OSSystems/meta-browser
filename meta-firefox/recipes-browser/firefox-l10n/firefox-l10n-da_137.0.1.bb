# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "050df90557e850191dd78698453729d4"
SRC_URI[sha256sum] = "5eed41ba9b9b374fd0164d62f26fa887abf46c47e9c655f2d711d5849ee0db19"
