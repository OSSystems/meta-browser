# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7a9ed8bb3d833aca80c41075af62ed11"
SRC_URI[sha256sum] = "3fc4c4a633d685f2691cac2e4843058561ca6424b94b6e6b9e30dd207d7ee350"
