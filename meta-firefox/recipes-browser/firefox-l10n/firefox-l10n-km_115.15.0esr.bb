# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0f4966ffda4589a5a1011c0322ebbf93"
SRC_URI[sha256sum] = "e1140eeec54f353322a73af517e48aca1f6b18b55a6a4cdabedb07d605690184"
