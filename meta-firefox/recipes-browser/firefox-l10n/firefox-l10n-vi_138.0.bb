# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bd15f6fef865e1d5e8efc8393ce20412"
SRC_URI[sha256sum] = "01ec2abab32816b47846fda5f68ec90416768c45a361d44bd7637499587bcf70"
