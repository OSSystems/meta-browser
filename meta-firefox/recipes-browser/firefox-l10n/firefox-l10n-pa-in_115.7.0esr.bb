# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "58190706ad7215f431e7b1ac27ccc1e2"
SRC_URI[sha256sum] = "bbc5feaf38acd27e946f672ec04ec597e97bea309e5e8bcdb69f3923f9c659ab"
