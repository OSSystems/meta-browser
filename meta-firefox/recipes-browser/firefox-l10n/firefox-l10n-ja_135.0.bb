# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dadb09bcf45e29741b4710fd1d2f118c"
SRC_URI[sha256sum] = "c7b86cb56c01d45c65aea2e6d86560a10fdb6aa61dffac819519a8eac23a86f5"
