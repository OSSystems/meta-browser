# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c6e4924c2a85b0dfa5c7091fc5c3a17f"
SRC_URI[sha256sum] = "49cebbeb0836499e409da548b152fe39a553f07d8dc4514f3f822876bc7fa81a"
