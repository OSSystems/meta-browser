# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ea60795df755ddaf3fa042356a5aec7d"
SRC_URI[sha256sum] = "91a035a50e079f739e5c857072aba6d78f3d8c8dfc311065ad50719e5b2bd255"
