# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "abc117b9819c2acacc7e0a0245326a71"
SRC_URI[sha256sum] = "3dc9faae673b699c8144f92656b44bd2dee7d44189343258de3e07f060f7385d"
