# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "00287784826af9d90021eb7a1e501df8"
SRC_URI[sha256sum] = "266b1cc004ca1fbb844f34225653f1e55ba3fe1c5493ad4c0c2954be9db28ddc"
