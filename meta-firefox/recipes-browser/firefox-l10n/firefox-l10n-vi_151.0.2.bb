# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "22fc0e006bf6d52d5ccf876082758f7a7ccf48514b9c417cb9a1832c51f7e5e4"
