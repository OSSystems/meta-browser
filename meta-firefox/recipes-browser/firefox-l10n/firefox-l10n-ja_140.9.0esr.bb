# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c6af140407b101ff768e136b2801ef48"
SRC_URI[sha256sum] = "f291a0fdefebeb581f356dacc45258121472590ccec46784666b198960abce7e"
