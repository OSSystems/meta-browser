# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c27a347d264d2bd36be1fc317232dd8fc0050f8665b20073ccfcc5ebf65934da"
