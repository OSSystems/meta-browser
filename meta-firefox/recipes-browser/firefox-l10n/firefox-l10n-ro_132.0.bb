# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2e7010ecac39938cea9554713523351d"
SRC_URI[sha256sum] = "6c0da664a3e43581231e32be4013315afacb2cbd3126d5d2d499c00b7a5adcdc"
