# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ee62e64b440cfb0119729630b717da6d"
SRC_URI[sha256sum] = "4c8174d81a4279cf3adff596a4af7530f4219dd5b26aae5d39318cbd930f920a"
