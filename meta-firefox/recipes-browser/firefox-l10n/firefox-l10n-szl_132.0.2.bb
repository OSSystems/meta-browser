# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c349369e59033de6b65aed86743eab6d"
SRC_URI[sha256sum] = "9b9297e216e42a99c1d20f340a32307d68e8f327f4f466cd32ac3fa182113a18"
