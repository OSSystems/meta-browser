# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eb24ddf899c1f4b8153733fc470b76bd"
SRC_URI[sha256sum] = "3f236158168ef9d144c320c6b7571c4ed0507b2508ea97fc825778ca28d5e22a"
