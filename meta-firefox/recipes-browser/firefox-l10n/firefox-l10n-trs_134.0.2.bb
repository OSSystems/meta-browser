# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c9259f9e06eedaa47a01816239b65246"
SRC_URI[sha256sum] = "0b2bd0decfc61c6f64c7d9e5f776820eed3647040842f37e76539005d959b396"
