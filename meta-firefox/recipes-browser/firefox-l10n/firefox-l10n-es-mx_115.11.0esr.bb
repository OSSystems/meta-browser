# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e964afe27285a88ac3a8d9af09211fbc"
SRC_URI[sha256sum] = "3be1248d55c119dd61fc543475f459fd84ff117786f5a7dc671914c0f8592d66"
