# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "84fb6ac617a077f84844e809d1bfb831"
SRC_URI[sha256sum] = "425ceb7cec997646636b58f3800c65907cdc6ced36742f7c349aaf587fa7f38c"
