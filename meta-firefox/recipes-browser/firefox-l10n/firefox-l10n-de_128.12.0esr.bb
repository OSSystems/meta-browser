# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3d60cfa7248ae9e052d9b3993fe4342b"
SRC_URI[sha256sum] = "22eb47f650d87e9500a04369566febcba594aff6d44e32e8ad0d341b29c912f0"
