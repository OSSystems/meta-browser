# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dac5e22e6836372b90c8bef9fcaff56d"
SRC_URI[sha256sum] = "2fcc923897a0f0c0c70e446f126515995557a5ae2f3f3d3b7b95b1c7f1e56dea"
