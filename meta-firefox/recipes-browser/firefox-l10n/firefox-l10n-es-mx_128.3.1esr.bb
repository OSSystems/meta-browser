# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2b1cfa619273584314792e73c7f2c4e4"
SRC_URI[sha256sum] = "ec86739d7c9c69c86c1e62a27e3f6fe81e8a9d2a0edfb91688d80c0c53e1ffcc"
