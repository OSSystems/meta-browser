# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f8c1f160e4217445be8f2dc95c200ca1"
SRC_URI[sha256sum] = "b58f36f83b3f163076ea2aedc98a484d573f59b7640886bee853c2220ca59fef"
