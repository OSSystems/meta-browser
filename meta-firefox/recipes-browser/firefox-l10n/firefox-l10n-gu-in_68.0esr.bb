# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dd019bdfe69d2a5565f0ecca879bb067"
SRC_URI[sha256sum] = "3bab1f3f4d20d7d68c3d1488492a5eee9a35d9d2e88a2b14e493a921aab62c91"
