# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "f6b42384020b33459c021a1c3bb1bdda5ef906b7eb813730000d49bc54d874cf"
