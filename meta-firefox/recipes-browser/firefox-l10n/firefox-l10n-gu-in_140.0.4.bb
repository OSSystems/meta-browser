# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e66d7ba6c87b9db24bd8ac9b0d99c391"
SRC_URI[sha256sum] = "35d811e4f3cac4d1f5fac3e9386fe0bb8bff4dafaa9adbce22a24a371e68b40c"
