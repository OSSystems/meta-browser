# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6b352d5d79000bc852a8d4b596d24a6f"
SRC_URI[sha256sum] = "4bd5984d5ced6c509c3116147bdfcf63ab57992ccd13dc55bc79a4d7486fe300"
