# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "63546becb2a320010dcd56e5309a7fdecbfa0d17d0194bf9a7e64961df08cf2c"
