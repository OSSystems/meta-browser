# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0f4e5a890f63331101e02ccf29a7b24f"
SRC_URI[sha256sum] = "07d228eb94a4a76bc9a175ae31241ef03804991f2438797c2d337bdf5b0ebb2d"
