# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "4287243cdc0190039cbc780b66784931f01cbfb9626b325de31665eada8b20b1"
