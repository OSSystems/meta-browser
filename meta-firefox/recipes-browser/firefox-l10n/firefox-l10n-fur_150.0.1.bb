# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "370c5aca76a74b2ff78b1cb359938cecf9cda6b878f1197c06a78af37129eb90"
