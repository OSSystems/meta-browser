# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4767138f4ff001dea12f355dc4f18818"
SRC_URI[sha256sum] = "975e9806966dc33a2110a378002c3ed764fc9360b1324dea6c2d06cbcfeddd4a"
