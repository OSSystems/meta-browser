# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "53e3e3b75e4137bca0e938fe21ab03d2"
SRC_URI[sha256sum] = "e3768f608f38dee02eb3a53ea86c0293ec0a19aa65e955c5fa47d5dbe9323d92"
