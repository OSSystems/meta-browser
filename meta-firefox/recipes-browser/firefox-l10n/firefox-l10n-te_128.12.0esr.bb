# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "352c9e87b29dbcd754b7e3d88704068c"
SRC_URI[sha256sum] = "36228cab78cb7ffb1cfb24dc32c71db6f23c07ba3b5480468c44b791b1b1f5fa"
