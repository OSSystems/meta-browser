# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "4b1f6354465ccec406935f7826ecddf48ee9fcf9d034e88dff527c6d8a6b47fa"
