# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c9afba7b99ce93c8f6f12af4b2610a7"
SRC_URI[sha256sum] = "f6251824980ff93036929aff2a8584a0f1e5ca7249d82073bcbefc8d5f206297"
