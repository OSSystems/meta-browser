# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e8b6b1aa5c987098e5cf97a084152785"
SRC_URI[sha256sum] = "d7084a9ca11af54064aa030f66d362a0e6ce990941239a03ad30716e96720f99"
