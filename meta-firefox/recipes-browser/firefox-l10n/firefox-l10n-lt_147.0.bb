# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f3805169ade0885d60e5998c910af606"
SRC_URI[sha256sum] = "a795ad0c951e801c11e526c5e6555c51b7e205b4554b140434aec4552a222d9b"
