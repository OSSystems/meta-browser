# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4edd5b2d8ae8fa63b89a614ebbd8381e"
SRC_URI[sha256sum] = "6bb63a820b3b92db7a55c26bca680ee3f4d904073df9fea35a1d9ed583b2ad88"
