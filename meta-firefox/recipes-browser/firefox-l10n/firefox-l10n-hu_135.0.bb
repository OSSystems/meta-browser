# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "15957479f00169966afad8cbec2b4849"
SRC_URI[sha256sum] = "82632d2b4726820a14bbb277eeb55fdb41563987213d1a2e9fe634680827dffa"
