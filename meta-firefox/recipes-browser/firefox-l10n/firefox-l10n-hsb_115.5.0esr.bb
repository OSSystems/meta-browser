# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c7a195c18ef7ab1c86be73bf6b315198"
SRC_URI[sha256sum] = "fadd9153edd9dee18b65326f39b9aac84087f90906ed514f7bd7a1dc0bb9e2fe"
