# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dc7007dfc7c10523a7adf0cf1e037503"
SRC_URI[sha256sum] = "bc6d1d21672c1c8b4599e97f765f4150eddcd93f26028b186319ae51d529127b"
