# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "547b4c6a1d2e7023258a126e4f24da07"
SRC_URI[sha256sum] = "75076d4c3c8851e81c576a0af9e758a250364eb2a01b868a34ff6d8ee3b12fc2"
