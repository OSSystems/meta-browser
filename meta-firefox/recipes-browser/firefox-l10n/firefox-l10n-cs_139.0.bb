# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f95f2d3c0c959d00466e6ef7edd7ceb7"
SRC_URI[sha256sum] = "92d441ec6ad86ea8c4e060a944ab1a2f72a0f06864af77d80858bf52d0530fd0"
