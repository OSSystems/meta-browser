# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "159ff5254291830be40a4109c5334316"
SRC_URI[sha256sum] = "4819ef18f538bc951181a091e4665d37bf9cc452da59fbe8ec451b8e3472efbf"
