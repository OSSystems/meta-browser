# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ee9198b59da458b0deb318c2073e063f"
SRC_URI[sha256sum] = "eaa04e5f9358e5f1cd791135b135da5daaa36a150f545fa5e0facb61175e1957"
