# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2981e3634d19be95258e5f03a77193b3"
SRC_URI[sha256sum] = "2af3fa82b6a4214afdeb9758016a2012da5217457a9a706f47471e2262671b0f"
