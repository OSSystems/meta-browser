# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "26ef787337971ff896e8d8dc21f1ee6c"
SRC_URI[sha256sum] = "8e68e059bf79c71f558ce369db87a5b4c96c34227dffdeb1c453f46911a444f5"
