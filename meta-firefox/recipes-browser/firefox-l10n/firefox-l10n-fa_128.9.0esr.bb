# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c9d3e4d7348b0d134d6d9d39f3ff112c"
SRC_URI[sha256sum] = "75d9a82b263bced88e096cb1156bbe58ef1971ef6e5d57bd4c47ae83b8503507"
