# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0971c1df7f654a39ab35f9389296e41d"
SRC_URI[sha256sum] = "fb63279c2c1c6cceb83554b123f807b2c761c386841ca292611e82ff72adf553"
