# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "4e5cbe7707ae13b5b530cbc5bc3f5b5d076cc6518f7403a4e579216fb65c34c1"
