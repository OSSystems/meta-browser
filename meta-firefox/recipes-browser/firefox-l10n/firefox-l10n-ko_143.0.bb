# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8703ac9d00fcb017422d57293a87bcc6"
SRC_URI[sha256sum] = "8759a0a1e93b6b77fce2b7decb1ac9ecf327ccc642606ca690ad5790e3e61795"
