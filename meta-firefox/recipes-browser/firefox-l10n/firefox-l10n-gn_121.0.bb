# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d2e3ce24dfd0adf9a3b52dba914425cd"
SRC_URI[sha256sum] = "3767e1f222304d7fa291df7dfd0030761153e5c35d9fb9d51943f71b22784263"
