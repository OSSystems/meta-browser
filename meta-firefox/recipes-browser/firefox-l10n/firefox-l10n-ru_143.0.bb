# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "99acc9eedb1e7f7741f5eb6c7ce301af"
SRC_URI[sha256sum] = "1ce74de443bcf0f9a54c2ab9f13c52e97e877e6a63e67cb65cb879a6c8f983f2"
