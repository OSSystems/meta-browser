# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f506252e15869a3f8458897a715998f5"
SRC_URI[sha256sum] = "3da8f4559bb34d4b9b94a8c3945acd5a937ac27878b50f7b70a5dc37ac15ed5e"
