# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "57edaa82ed6c8bf4f307cc0c62ae0286"
SRC_URI[sha256sum] = "7fb6515c52f775984ce007069d817622a57b960ab1003c1ef861d068e6722f7f"
