# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "49ec9d0cdcdb107477fd455b295409ec"
SRC_URI[sha256sum] = "04aa8381a458dc3dd6ef0dd2aae2f1413d41f9e8503e61e0a8c0274b8e7bfa92"
