# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f9949b1e1847b6c9a08d2f1a9b909648"
SRC_URI[sha256sum] = "4ef108a98984d378aafb2aa3a52d5d1cde632252a00baea8e4b45ed22f47962d"
