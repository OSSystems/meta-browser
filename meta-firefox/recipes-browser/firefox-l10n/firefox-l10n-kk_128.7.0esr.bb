# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bf09be3c47b6828daf72ec2f19bd79c1"
SRC_URI[sha256sum] = "8d6d201f7b2b0524fcea8cc2849f1230632961cf0f3e2feddd1c64f7795693d3"
