# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ff3906786f0dfc824017149b54950ed7"
SRC_URI[sha256sum] = "0ca32d1c862b4e78be215e81edf82b92d442bc7081eeaf48d8f071a94cbf15bd"
