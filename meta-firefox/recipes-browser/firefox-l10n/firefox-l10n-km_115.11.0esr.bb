# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b534c9a37cbf949ceee151b3f7726d02"
SRC_URI[sha256sum] = "71fa31a607b0b8795054a27d57ed26b0282921a3fed5b8cee5d7a849955d098a"
