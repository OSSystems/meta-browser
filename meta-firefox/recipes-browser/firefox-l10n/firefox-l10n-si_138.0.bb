# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cdc5e6a681052149799fbc8445bebb98"
SRC_URI[sha256sum] = "2ad9b07d5050f2f1c122111a842632f213356fbca8d4eb668da1f763c7a1dd81"
