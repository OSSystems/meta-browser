# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5865ab52fb8e8e35db66a4156185ae45"
SRC_URI[sha256sum] = "6d1c736a4dc985cf4854863e204ff4727085bcb52b1544fcae80046cb0eae27c"
