# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6a6a85060ecf321face40232d8823cc7"
SRC_URI[sha256sum] = "2d42a6f13a2e2d77e22b181668367d93eddf2152df207de41e2142f739ccc2b4"
