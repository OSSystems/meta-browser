# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bf25162fd1be5b84a9ff3563a76f95e2"
SRC_URI[sha256sum] = "cd65d4413a92932f35896a8b3f2fbd566f4011e5dcc22cb6cc670c40e9d720bb"
