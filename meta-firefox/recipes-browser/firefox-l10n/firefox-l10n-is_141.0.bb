# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1d97fd267e1f39f2ab6baaf68e1bac77"
SRC_URI[sha256sum] = "c83679a10ff4fac6fe8cf78190fcef60160481ed77b4fceb51e0162a69d08f1a"
