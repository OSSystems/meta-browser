# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8785fded27054859f8eb742d77526909"
SRC_URI[sha256sum] = "a83f8735ac9240d781a792a5258468f7073b09a3009956aa767b5db3b27d85c0"
