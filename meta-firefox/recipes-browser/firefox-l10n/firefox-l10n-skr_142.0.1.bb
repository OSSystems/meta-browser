# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ff5c016bbb2475d69c22b9338cbc118d"
SRC_URI[sha256sum] = "d3ebe49c6da7899ef92309d43327dc5869d7fe1c626cdfb0129349d590d4e8fd"
