# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f34b78f36b37e1105b3dae81e116786c"
SRC_URI[sha256sum] = "d98700ad9661ddc0aa618bb7e18c634b1afe1c326013b7518202ada95f64c152"
