# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e788a218be00bd2555694a2b7d51aabfb385c894c2ee39a95e7088a3bb482f2b"
