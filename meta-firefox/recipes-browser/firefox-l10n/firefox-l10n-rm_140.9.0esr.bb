# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "76359d471e8d136b7b99804f18602000"
SRC_URI[sha256sum] = "4d6e55789a2156e2882861b4356149e535284f2b2340fdc5f77a341d3320d509"
