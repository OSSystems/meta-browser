# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0a89981fc5b8e0e67865c135d8722890"
SRC_URI[sha256sum] = "ed185b763af2beaa479939fcce9d20fd9e44ab09333c5fa76ce15b4c46569241"
