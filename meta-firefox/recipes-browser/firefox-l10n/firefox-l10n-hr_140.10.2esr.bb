# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3fb98c3c2a673ec9237982812dac35b8d728d5ec7e44aae3775f09119705a4d5"
