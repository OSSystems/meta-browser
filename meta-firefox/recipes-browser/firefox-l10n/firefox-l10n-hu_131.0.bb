# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b105312421c244d5fe47fa12f86a6a29"
SRC_URI[sha256sum] = "0663f415b3c7d6bb432dad6b951e94b5c1ed27be50e9a42b779a85da2a21a221"
