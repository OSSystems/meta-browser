# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "da3213f28ba22f7c1558826edbcc18df"
SRC_URI[sha256sum] = "cf3fd542c50e777d336fa946256597cf3028bbb33542730aadd5cb3f1127672f"
