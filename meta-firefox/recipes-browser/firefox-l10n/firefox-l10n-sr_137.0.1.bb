# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "533d28c4fcb0008a3aa8b20b82e36622"
SRC_URI[sha256sum] = "f83d6b36f870408877398e61a65dfd83267c3ccbe954f7d48e79275e90c28e2f"
