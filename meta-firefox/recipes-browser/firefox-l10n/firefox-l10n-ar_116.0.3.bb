# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2b19f5b3846269f3215d69073c940c43"
SRC_URI[sha256sum] = "5ec1e2ae0f022cf54b640e90437f14cd4a9c25a208caceb745c5f537c4f6801f"
