# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6e4dbe956763be8f40fb8a54eb6af0ec"
SRC_URI[sha256sum] = "14b2a1131bd76421101923a8817b596530e5543147a43b5d46d042ba082a9801"
