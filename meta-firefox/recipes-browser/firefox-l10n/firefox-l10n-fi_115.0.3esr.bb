# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "05c957395d8ee4b88d84e41908fb2dd6"
SRC_URI[sha256sum] = "1dcf82a47ba394f24dbf8097a517dc7d1c1a511d677c46c1990b253b4baf2ef9"
