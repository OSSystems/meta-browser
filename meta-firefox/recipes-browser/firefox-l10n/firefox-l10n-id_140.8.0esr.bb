# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b0d940ee2a0d3a4a71984900ae032894"
SRC_URI[sha256sum] = "e82839786600d4a5df6ac0a1220b07738bc2350256a1673a59f4e82b6dc8bc42"
