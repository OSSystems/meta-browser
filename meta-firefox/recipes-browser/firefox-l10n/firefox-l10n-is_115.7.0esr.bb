# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9938020476e37c682e38a51959b44c51"
SRC_URI[sha256sum] = "5e945f826b4dda35eb0d01e0cb940916f5f2751768aac488c5530321cf498545"
