# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "86de97b2833dc3848976623041cba2fb"
SRC_URI[sha256sum] = "5c5c7e1eeae6748426e1fc9c72c1e51ba8e5f219996cfdf67cc049b520323f0b"
