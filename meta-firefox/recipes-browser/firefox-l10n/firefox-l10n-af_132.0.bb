# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d992d156b1efc119e5422a95f08c2aa6"
SRC_URI[sha256sum] = "38a33738216da3bd3ba0d82f8f8c0880ee0e8d5dd39e6e65c0e8cb17ce6d2dc3"
