# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "204a61970cccc7525f40061e22ed5efe"
SRC_URI[sha256sum] = "c873c1deb6138ba49f9ca50002e0d2ef9f4732350c4d2e8bbef87860a759993f"
