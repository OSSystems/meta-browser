# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b22cb041b4407e9a8e9440fbd7d6d168"
SRC_URI[sha256sum] = "e19ef49a57ea049deb6a66eb51fb5f7472a73545dc5e968477ead8ecd50d08fd"
