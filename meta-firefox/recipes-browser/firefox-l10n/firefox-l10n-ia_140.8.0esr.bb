# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8e6e83df854b0a12772cfede4acf2c1e"
SRC_URI[sha256sum] = "119f7a8dbd0174710dc8dbb219e8f36911caae1655ac653139d579a87e5fd6a3"
