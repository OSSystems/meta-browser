# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d8846e2f7cf637e5c30cdec6a4a520dc7e003fc35a8e9361410b5c304e2d98e4"
