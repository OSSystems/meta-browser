# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c8d3f99ffe3242a546098f49f6eeadb9"
SRC_URI[sha256sum] = "3605d3c3e65afb2a3e46ab679a34f90818d8ebb16286289d8d9529e01c2513fd"
