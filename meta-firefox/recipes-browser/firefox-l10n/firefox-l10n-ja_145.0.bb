# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f397aa2abd4581ea02d8317fdfae3aa0"
SRC_URI[sha256sum] = "2b7b862a7e6ff4b98fee0bd2cc07957250306c097d414a0a77073905d9c603b6"
