# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "52605ae9ecd9d9c81b8e9806827ab6ed"
SRC_URI[sha256sum] = "5cc8bb2e37d16640e606f409f48a3058c039a8af82f6556d5df15478a29131da"
