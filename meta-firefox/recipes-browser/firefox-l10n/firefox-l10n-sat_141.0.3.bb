# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f7a5e77dafffd9995fddfada18cc8dc4"
SRC_URI[sha256sum] = "161d015f1544e2865f6f2abb264e1e913e07570b045ef00e4ea38d27311ce461"
