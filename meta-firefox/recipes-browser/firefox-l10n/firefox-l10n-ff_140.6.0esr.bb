# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6ad830e59238d9a02a4ddda3ae95582f"
SRC_URI[sha256sum] = "9325712358fdd5a069d8f493ba7378d121f1d15dfaf80f922ce83d27ae034e60"
