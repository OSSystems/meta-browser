# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "296d402d3544b5ee93709b351ab1bb13"
SRC_URI[sha256sum] = "5f841761d500215dd6d747924473709bc6b457e9153b751ea3ac50d8a24744df"
