# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0de7fdcdae9c2c93e765755ab7082025"
SRC_URI[sha256sum] = "a35d3246476026fac885a1094db11a4891c1d31dfc35367b37a0a64f618f9a27"
