# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d24b2429edf1771933ee464675369e89"
SRC_URI[sha256sum] = "9a97cc7184379efcc83584a927afc911275949f060cef13cbcb1b4d6e70ec4b4"
