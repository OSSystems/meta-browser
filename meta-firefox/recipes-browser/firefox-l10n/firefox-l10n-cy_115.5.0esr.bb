# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "69fe3aa9825fad517592918cb7557703"
SRC_URI[sha256sum] = "f6803b12afb7b16130b18197b7584a8325a5af38be8fd955518dc76427920c2c"
