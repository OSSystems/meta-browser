# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7ab3bd257fd9def4b4867cea00627237"
SRC_URI[sha256sum] = "b58a5850261ba3da4c4656a4397e96321661d15bf1d132e4e584eb000775aa0b"
