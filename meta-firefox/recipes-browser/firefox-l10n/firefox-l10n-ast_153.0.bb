# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "f0e989aa393959e9d76df758d7c0d10ae96c6be781cca4f6728ad3fb446bd43a"
