# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "76819f0c045def08bc7dd71390a50f2c5999a0b1c87e95030fbacebf4de04a7f"
