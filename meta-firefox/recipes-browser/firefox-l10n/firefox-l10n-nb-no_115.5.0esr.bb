# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0387477414b0536533f7e078e4aeca9a"
SRC_URI[sha256sum] = "02f757a2335a0623b9ac758f5f47b4ab3e505410d1dfac38aac99354a7c44920"
