# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "afabc8eb0442f6bc53f9e65c3aab12e1"
SRC_URI[sha256sum] = "b8345fb1dbaeae4ec4eaa1574be7e0beffbb171adfc34e06b481c528a307700e"
