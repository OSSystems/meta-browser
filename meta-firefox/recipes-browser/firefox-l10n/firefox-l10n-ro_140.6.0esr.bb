# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "83561c46d55da9b1ed0fdb0b7ed236e6"
SRC_URI[sha256sum] = "b325f79df39afe680e91ab953b2bc34aab613757889ac0979f021f50f2b38c63"
