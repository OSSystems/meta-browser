# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "57c39d272b1bea364cb38213e33d8a82"
SRC_URI[sha256sum] = "9bad412fddef8a523c428d04cce1ddb1b144cf14fd4c1a0134414573039967af"
