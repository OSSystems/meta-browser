# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c7b0ef04dcd7a87f07932f2fa2447c35"
SRC_URI[sha256sum] = "af62dee0c2dd80ff16c8bf00664939eae2d75d076a6ccb37ddd2667a5c8d7054"
