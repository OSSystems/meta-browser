# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a070fe8e1a37bb0dfc07ba3321ac160c"
SRC_URI[sha256sum] = "d22a80e883bc5423d006dcdddc04b3f2864c91dca006a1891886d250e316170c"
