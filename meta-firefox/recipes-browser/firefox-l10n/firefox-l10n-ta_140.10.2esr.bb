# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "4f66042cf2d954445fd4402e9063e3373f31524056797bf6a2afc94247534fb8"
