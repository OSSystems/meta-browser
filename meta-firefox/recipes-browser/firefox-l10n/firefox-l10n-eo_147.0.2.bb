# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c336f61e0e7cc89abc891e88144af5b2"
SRC_URI[sha256sum] = "a313fa24b316288630cd5c611f182eb4f25c1c7e3340f633740fb99a60fe3ee8"
