# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a21b9c1edc82dac421b0638d83128865"
SRC_URI[sha256sum] = "8d478da9393f165a8c6b5b7d32b687cf807cb524fa454cc15661dd970586cea1"
