# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1cb91f278877bf646aa062e87dc35735"
SRC_URI[sha256sum] = "35473a2305ad32e18fe88caadb8e6eee79a8e55558e11ceaad4e0e6e2d8a9e7f"
