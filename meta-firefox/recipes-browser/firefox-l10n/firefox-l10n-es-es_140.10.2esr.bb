# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "dcccdb0147108c4f3f59534ea24a0069b08a413a680363dceff059bdda6b1c10"
