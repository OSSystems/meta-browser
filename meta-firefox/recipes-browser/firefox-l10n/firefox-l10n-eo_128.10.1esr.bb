# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "221d4e256e547db072bc849cf407e04d"
SRC_URI[sha256sum] = "09229bc7e4a3ff15e26e76022087aa99149d9d656aef1ed1926f12134c4187c3"
