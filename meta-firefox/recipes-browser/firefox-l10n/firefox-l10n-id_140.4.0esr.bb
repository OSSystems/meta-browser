# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dc1597dce1d3bec2d906a37ae8d77dd7"
SRC_URI[sha256sum] = "a988fd07aa31dab430aa4c4f0b78ef126984f4fd076aff707943952e700e1cb7"
