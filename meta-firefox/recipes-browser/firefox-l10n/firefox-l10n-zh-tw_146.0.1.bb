# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0422d663ad406152f101340c137335e5"
SRC_URI[sha256sum] = "e43353f67c993b2db78e7290ed116483bb9c0fabba345ba10267254f660e5aac"
