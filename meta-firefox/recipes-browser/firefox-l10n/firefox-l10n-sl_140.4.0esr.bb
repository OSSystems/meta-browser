# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7948a4668dd74cd88b4bf96501cf4029"
SRC_URI[sha256sum] = "cd0db358b5e3413ef18e71505c9f969ebaef36440f32eef9da9fb91a04593cbd"
