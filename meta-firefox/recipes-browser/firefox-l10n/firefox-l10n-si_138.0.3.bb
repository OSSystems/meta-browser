# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "67dfe36f10854ef4be9791b3a2a8e2b7"
SRC_URI[sha256sum] = "fe72fcf911c83a318001b6d151ff6220705ba69b8a520d0cb58f30d273358b7d"
