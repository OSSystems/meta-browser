# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "11c42c0c544b7d2fc7100228c658b62f"
SRC_URI[sha256sum] = "80950a2d75ff876a65587a0bd4bd4904fb11d920bae9b79d6bcb8c263e66dda3"
