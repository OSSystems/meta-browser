# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "19c748c12f86a840d8a5e77f186c3aeb"
SRC_URI[sha256sum] = "b5dd5d0f467c5f4451c56f8204aa40ce325f3da879dd4d2a9c7373625896dfdf"
