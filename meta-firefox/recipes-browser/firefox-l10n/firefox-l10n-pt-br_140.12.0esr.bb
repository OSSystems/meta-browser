# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "23fc5e65c9d18335016ee14fc607ef366c3e5d301a7eec09dcfbe1ae547fa33e"
