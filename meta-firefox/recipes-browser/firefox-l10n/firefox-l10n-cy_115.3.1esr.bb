# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9f8e20caec9269dda2fc7ab33b84dd92"
SRC_URI[sha256sum] = "d6d9f39fd035f59b6089d494fa4c36c4f972f42f636018fd0176990288f6d58e"
