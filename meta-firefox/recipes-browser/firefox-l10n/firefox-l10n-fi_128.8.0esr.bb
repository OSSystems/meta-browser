# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4c0c7f39edc5a9b1cdc4a8a1b309b3a8"
SRC_URI[sha256sum] = "7c79ff9c0a9211c1cdccf6b0e0258ca602ac9b61a11551cb360d9004328b5fdf"
