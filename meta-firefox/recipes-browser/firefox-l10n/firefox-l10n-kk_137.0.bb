# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4c7c411adb80f08cc16ec58b479ef54d"
SRC_URI[sha256sum] = "3bee0fccdedbf51f28c670c48ff1307b755de194dd3e6ab164c0690a1865d0e1"
