# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fed5eed9fac376baf1cb03437d2bd66e"
SRC_URI[sha256sum] = "51dc6d21e8fcdb26a13c3f396654546d41e10fb71d7974f594e8b88ba65a84c1"
