# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "55b234044998245b5d753d5ca5562ac6"
SRC_URI[sha256sum] = "89d4634cfc59a0c4efaef2c163f74074f4338a32ca10fde41c4cf5aadb1de88f"
