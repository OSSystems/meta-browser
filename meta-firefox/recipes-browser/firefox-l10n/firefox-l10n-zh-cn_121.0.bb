# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1ac78a3012bae2f9d6bd1d0b13a3c4ed"
SRC_URI[sha256sum] = "5c4d9e259e07715d69bf54e92a07185fdc32f0f7c858a464b05ab8106f40ba1a"
