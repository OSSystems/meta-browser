# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "dc93f4547ebcac3dd63325c50c79ab1438ca2211a981e52cc5824b4822aa4422"
