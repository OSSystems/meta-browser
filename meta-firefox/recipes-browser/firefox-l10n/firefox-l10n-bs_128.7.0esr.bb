# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d19643d80a82512586c6822d54e220e3"
SRC_URI[sha256sum] = "8d2f27bb270ec34f49a9403d214248ed0e8bce5a3859cfdb3cf9305055f2bd27"
