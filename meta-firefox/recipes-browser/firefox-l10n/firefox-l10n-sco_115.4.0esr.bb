# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5644b989fe0f3ccbe9e2fe6ce512ad2a"
SRC_URI[sha256sum] = "e02cfc656c932d1a222971d9a59b115f4fcd501649f9dcd9a86cfb35260d9560"
