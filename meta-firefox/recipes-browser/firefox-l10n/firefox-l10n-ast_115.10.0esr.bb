# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9a877fd0134d74701359a3778e969fdd"
SRC_URI[sha256sum] = "b752304b0747c677bb5eac0f36f9e63c1c7f05402287a6cac305f25c7a16642c"
