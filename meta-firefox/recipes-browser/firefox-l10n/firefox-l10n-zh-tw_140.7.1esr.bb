# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aaafe449a4c5bea955aeae8155f287ce"
SRC_URI[sha256sum] = "b48abdcf8ed94f485e1e8568d2a740b011dedf68f114e221837ce445f98f673c"
