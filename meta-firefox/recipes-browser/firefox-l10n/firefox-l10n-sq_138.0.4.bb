# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cb26242991b8a4661d6388c5762e22af"
SRC_URI[sha256sum] = "df39b49bba933c5a4b4df4f76973360b5eb469c415ad7df41cf1af9f604830e8"
