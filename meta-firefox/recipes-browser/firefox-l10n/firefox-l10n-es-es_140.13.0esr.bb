# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "6b79b83873699beeaf11da545dee2503aa69ca0ec466c1301d31dbf459972b86"
