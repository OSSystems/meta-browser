# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f1e3e50f6a6418595c9abb9a2d75ab39"
SRC_URI[sha256sum] = "2c344753fc7ceb36f9512a10bcd2ef39f84eb409e2cdf8507bfff4ee6621e755"
