# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fe9c49126c9ef93bb64bab4ae43d916a"
SRC_URI[sha256sum] = "a79954e154ebb8b74af683b395f3bf7f600db0fdadfb1d14b452918a4bcd800a"
