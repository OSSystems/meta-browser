# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9bd2cc4294a3ced05b8c9c5298f99ec9"
SRC_URI[sha256sum] = "23a683ca1c9e98cef78a0b7ad3d237b0926b8d242aace28896669ecbb7d0d696"
