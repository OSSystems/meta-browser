# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9203e0105b1621726d8018109cc3858f"
SRC_URI[sha256sum] = "48535a2fff72f645dae96ac410d95170d755184b32c4ecae9875856e05abe373"
