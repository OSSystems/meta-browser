# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "f40d3b812ce707849864cf0f5a3cbe081adc7dd405d437ecc27526e98443b947"
