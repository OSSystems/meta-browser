# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "f9cb95ab3cb97df5657e96a744953258d4c26ca53ddfbe0d4c85886283436c0e"
