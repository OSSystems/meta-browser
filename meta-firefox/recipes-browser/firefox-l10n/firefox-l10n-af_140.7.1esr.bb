# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "153284c4d4afb0afaeff1c1174f093d3"
SRC_URI[sha256sum] = "e1b5f853668c073dc1ec8b4bb7cfd5978af69eae166b5b76f67f4b7190c0c903"
