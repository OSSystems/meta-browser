# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "57820077e899cf9d4c7c475f6d48d45d"
SRC_URI[sha256sum] = "7f46db330e70d60227acdbcf9881efe17c5161dab39eaa6e71cde30587e87bb2"
