# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "32fe3f1d1e54260d031cb95e59494592"
SRC_URI[sha256sum] = "1cb21c4aface0111a0c39a90c17bf7cd505ebc52d734b9987e1d432acf2ae3a0"
