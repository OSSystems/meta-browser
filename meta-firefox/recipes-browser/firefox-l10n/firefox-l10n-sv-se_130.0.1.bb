# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b55d0e60b1981afc83af7731869bbbcd"
SRC_URI[sha256sum] = "91b0d5938642dad86e69f5fc35c8b91be52035ea8f4fad62fd4b03dcd78d14e2"
