# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ad22aa39f382b5c6b0e6eb315d027f5a"
SRC_URI[sha256sum] = "bdea5ae8b2df98853f3346f2ff3ac03cbb6ae7cbeac8808198161f4fcf3695db"
