# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ade971ed1709dcda5c4c85aa39bf037d"
SRC_URI[sha256sum] = "4bca6bad428af46863723bbda3bfad188b41fe1595bda07f2ea6eabcdbe43eda"
