# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "818f6cbc3b51a0b2aa82ba52f1844294"
SRC_URI[sha256sum] = "24f50a2754446e1c31f7a716307ee5621cbbea86d96ae9d2c7919c00c8aaa95d"
