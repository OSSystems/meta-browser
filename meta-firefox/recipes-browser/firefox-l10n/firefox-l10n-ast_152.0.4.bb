# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ac42cb52613bf49b09b81519a1e314c531df4211a6b58b4afeb443748c99f9fb"
