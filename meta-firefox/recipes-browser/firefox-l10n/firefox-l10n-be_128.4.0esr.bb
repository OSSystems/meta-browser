# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4ef150182754bb5700f95eba90a4fd1f"
SRC_URI[sha256sum] = "ecd35b9281942d6753ebadd4238617d2397b71bca0ac0b5f2e6e399e68fa7694"
