# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "17e38736cbaf40a2020510f8ebfba300"
SRC_URI[sha256sum] = "c6542de6516005d45cec396fc2ec8c2396b440a14aa42b0ce0e18c09c6fc5680"
