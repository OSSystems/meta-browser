# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "23a754fda92f182a9ed03d0ad75b13e7"
SRC_URI[sha256sum] = "fe81e5c98958956e2ac27dee7f29092e3358a76bcd0925469a2f7f4080d81aaa"
