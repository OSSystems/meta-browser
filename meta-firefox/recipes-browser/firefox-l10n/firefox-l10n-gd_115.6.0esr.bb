# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1e8ea3175bb7a6b7df40a0aec5ccfb36"
SRC_URI[sha256sum] = "18ebba4c0ba8f2f78d6167fedb5cd93cc37ea0a32e4a1b5236c7e07d22d50bfb"
