# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e2b2eea442a90a156217efdcaa535f64"
SRC_URI[sha256sum] = "bc515be952a33e74315a1b932c20bb7ea3d4d59fb0b44f87d3555028540629f1"
