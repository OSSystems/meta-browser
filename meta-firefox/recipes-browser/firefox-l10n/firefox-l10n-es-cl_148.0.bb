# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ac3f87b1df1608359c287ff472c43df9"
SRC_URI[sha256sum] = "1cb448a82e9a872151e8a5351809a79315b686b341ca42ba2d371338ae6672eb"
