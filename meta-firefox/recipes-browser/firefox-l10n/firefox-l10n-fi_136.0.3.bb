# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bc26218b84f2df7654bc05ce6d3e19f6"
SRC_URI[sha256sum] = "032bf8a57fc0b56e09009b5866b7f6a5f39a91d9c8eedb094126e7416269f875"
