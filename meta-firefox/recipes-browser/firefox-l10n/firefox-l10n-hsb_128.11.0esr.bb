# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db750ad4f1f6f89ffae082919c0e9327"
SRC_URI[sha256sum] = "343b6017550687308037a0ae946c472589d3abd422b8e2237a5c3bd296ff1f62"
