# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f35ce748a9eb7c5db43327195206918d"
SRC_URI[sha256sum] = "3b0fce1811d387e739c09779c0afd942aa141ca360a540e7e92a3e634a43280c"
