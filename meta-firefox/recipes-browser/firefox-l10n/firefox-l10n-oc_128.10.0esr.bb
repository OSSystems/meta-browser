# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "360844cb0dd0958692dd2d766fc4c51a"
SRC_URI[sha256sum] = "a14b58d98f80078afbe5d1c107944458bbeeecc27de062602bbc5a5812975277"
