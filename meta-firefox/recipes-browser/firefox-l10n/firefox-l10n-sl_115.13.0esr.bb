# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "379ea67071306e7084bc7216307eb1a2"
SRC_URI[sha256sum] = "99b7e5fadcc37d94c1c2dc0f657403e9e6cb6b47711a1e47e05ed4b1e1c888dd"
