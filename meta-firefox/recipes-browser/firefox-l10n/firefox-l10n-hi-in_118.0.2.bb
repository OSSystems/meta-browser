# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "20a615b5b2d919d5b6c80efa84e2198a"
SRC_URI[sha256sum] = "657083d8f09b2d41ea60a51bfdc230259a79b5970e93579f4c20a8bce6459693"
