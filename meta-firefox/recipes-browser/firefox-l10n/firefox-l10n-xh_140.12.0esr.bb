# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "6ff0a281ae1e9218ba763475dd4f7c73da820f35310241a593c420c32a4df09f"
