# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "69497eff6c307158ac80a3a61a7e2e7c"
SRC_URI[sha256sum] = "9b8f8a6609bd968de4c2a0f3e5fe0f7c80d0099b2f6cdaf5e0f6d8a014b15f59"
