# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "31fa340a150dcdf91d89f2640c41eac1"
SRC_URI[sha256sum] = "83080973c83cd398b8bc67068314a083c6cb56aaa8c9714599ea50ae6bf2a365"
