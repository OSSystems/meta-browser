# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f55772154dd0386f57ed40d970b29ff9"
SRC_URI[sha256sum] = "b82e5fa2ca9ce4852398e347a9baa898a5a8116169b5af861f190f127e0e5d56"
