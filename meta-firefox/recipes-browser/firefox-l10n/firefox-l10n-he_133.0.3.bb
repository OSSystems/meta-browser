# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e9558f2a62738583f859daa7b69d2a38"
SRC_URI[sha256sum] = "bdb945ae7ae061e87b1205288521c526c96092409611ddc97bc5d95716be4cb1"
