# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3817231921ea3b6db08001fb20dbb24d"
SRC_URI[sha256sum] = "f24b016d1a47cdbf9d903c8163890be4029fe57f213ea16962cc854674f9c1b5"
