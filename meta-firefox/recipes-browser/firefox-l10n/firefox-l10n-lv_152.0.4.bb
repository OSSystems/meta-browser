# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d81a10b46bbbc947205e9b2246f94490ee99b0dda993df426902b39363236a6e"
