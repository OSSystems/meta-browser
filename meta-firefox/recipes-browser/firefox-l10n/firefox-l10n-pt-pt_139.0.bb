# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bca3f18fa0a86a269e4c608191c65fa1"
SRC_URI[sha256sum] = "7f36e257cf88f963b708e59a4e3cc8f1ecfda6702a2bb9691dee0d9031aac8d8"
