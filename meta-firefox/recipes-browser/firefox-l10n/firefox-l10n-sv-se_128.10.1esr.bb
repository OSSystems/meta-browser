# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3b49386ff5749790cbd1af2ef9174131"
SRC_URI[sha256sum] = "f67e73bb334d13cff4ac954f6232fcc971a3b8ff7c475ee006424bbda27906f5"
