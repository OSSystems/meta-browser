# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ede4c44d80df6e1b374696bab76857d6"
SRC_URI[sha256sum] = "9e908fddcb43140474009ccd9b114b59532580021d58d44abafba2456e56cf33"
