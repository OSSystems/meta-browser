# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cf4fda4dc8a41afb9775e71255623266"
SRC_URI[sha256sum] = "ee7ac2e8cf41895cc8f5e62946d503e81bf7e0669941dfd1ea83b22459f8c8be"
