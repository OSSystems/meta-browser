# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9fa70d62f08262d78be7cad210fc3560"
SRC_URI[sha256sum] = "2f8fed63ce9a1b593a8bf4dc7c13ecd4641025ed390b379dd3517ff503b671cb"
