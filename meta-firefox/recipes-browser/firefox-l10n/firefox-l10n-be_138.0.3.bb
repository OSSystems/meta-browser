# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aff8e8af9af1aaf6ea15826e7cd0308d"
SRC_URI[sha256sum] = "f551fb0cafd6ae3ff042e2c5d34db77db7ddd9418f9367cfecac78455454e189"
