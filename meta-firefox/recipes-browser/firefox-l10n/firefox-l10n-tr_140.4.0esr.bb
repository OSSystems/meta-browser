# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c14b50a0a46aff8272950cd40f6605e3"
SRC_URI[sha256sum] = "f75d5ea66d09d186af2411a0bb33c6202561276d8b19ff33e528a15e2d3e84b2"
