# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "1843577a92f7d601b1173e13c4e20c2d1e8564d3ff342e23b85cb6f5da9dc426"
