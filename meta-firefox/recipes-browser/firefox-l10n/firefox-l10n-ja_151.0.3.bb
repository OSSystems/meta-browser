# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "64a639d76ebf5eecb3be5b82c640e3f408d320924d0efdd1407979a6b8d608d7"
