# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "14f38f334b0d2cf3d08ea2e58eda3166"
SRC_URI[sha256sum] = "befc528e9701e0460d87014ae8f77e6c605c7d2edf38b5db37fdc0b2452f336e"
