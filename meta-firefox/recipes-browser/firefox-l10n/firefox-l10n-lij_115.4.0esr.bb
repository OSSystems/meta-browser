# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b510aea354b1547c4b252f5dbd920f5e"
SRC_URI[sha256sum] = "a724205430fbae3f73bf354eec7ab341e7d887b1f3e80df53ec011c66213f396"
