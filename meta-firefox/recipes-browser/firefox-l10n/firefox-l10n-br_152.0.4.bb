# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c2826dee4a21118d14a7c173faad85bb98931e381f92ebcc95f0f85afcfbdd47"
