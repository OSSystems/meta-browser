# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "90cd432e8a1514ef09bfe569a6eca2ba"
SRC_URI[sha256sum] = "19cdd41c105f1783129f206b2a1e07da9f9d2b559b47d65bc26611feeaddc5a1"
