# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "632b7c9ae79f8a71cd0af079444e5035"
SRC_URI[sha256sum] = "0204652593867199966434824fe727fbc0c513f305d353ccc6ebb15cd5be78b9"
