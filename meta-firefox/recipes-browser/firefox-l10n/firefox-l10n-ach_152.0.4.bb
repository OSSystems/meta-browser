# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "b7168c0d75675c56a0a4684e3841e16ac92619358b65f50b0854357dadf18e54"
