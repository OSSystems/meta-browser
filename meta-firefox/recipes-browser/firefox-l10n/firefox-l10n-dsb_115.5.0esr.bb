# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b8241104fad80a3041580b54464f6360"
SRC_URI[sha256sum] = "612d162621451cdf1ef3e005b77311d63b969669cce48999071b9a8891f8eaec"
