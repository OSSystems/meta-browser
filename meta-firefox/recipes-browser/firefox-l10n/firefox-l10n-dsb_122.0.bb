# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1f446dab7107b57e225e3da5b58158e9"
SRC_URI[sha256sum] = "05c6a971317913b6cc640abf79470f5c8f9077c2013ab8995e1c14d31201ead2"
