# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "16e5ce5fde75c349ab31040f711f42b5"
SRC_URI[sha256sum] = "e86ecf86c41d8ce527c386e6a0c33e1b89d7aed2df4d0caf02e5b1c94c3e9bc3"
