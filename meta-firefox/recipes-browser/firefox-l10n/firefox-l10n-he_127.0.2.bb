# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b40e619b05893b969af6a78680dbe3e9"
SRC_URI[sha256sum] = "e4c4d8900f7e44555130717e53c1ed5a125ded11924610dd00bbf6e736f34bc0"
