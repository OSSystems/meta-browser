# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "fc1b4d2b26f75a0544b652c6e4a9403ee2cfaab5372512875c715c7a5e63de1b"
