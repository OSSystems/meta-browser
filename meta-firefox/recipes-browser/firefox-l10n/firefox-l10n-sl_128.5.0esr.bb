# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a8283e5b22fad1dd6af18a8dec147fe1"
SRC_URI[sha256sum] = "e2ba8a04d829a8a75c8e6ab4b9abbfa9e99d82dca788bc41e6368142a50d19dd"
