# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d3258d34d4b3c4eb17a594724bda04d32965eea0fa0f971cd72d33d0db9a6b4f"
