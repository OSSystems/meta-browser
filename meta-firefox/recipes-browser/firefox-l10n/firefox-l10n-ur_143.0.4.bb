# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bff66afad73c6c6a0d2deb9ffa805473"
SRC_URI[sha256sum] = "3e6ddf3d67d82a5d2874a643f1b1031cdb62a66c78ec8b4ef8cb3243b8df1aab"
