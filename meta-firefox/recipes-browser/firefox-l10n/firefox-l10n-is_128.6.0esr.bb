# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9be61f557e95f4a719a34aa6a271db76"
SRC_URI[sha256sum] = "9af33fb8ffece5f3b9fcb88260cd67f1fde42557c3a1544e38748d25a8f7e464"
