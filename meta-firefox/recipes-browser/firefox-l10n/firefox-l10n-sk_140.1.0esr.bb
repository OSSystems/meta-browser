# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2e8ab39cb52daab91c30580f75604d59"
SRC_URI[sha256sum] = "f1d1d5ef2dbc2e94d05fc60e3ebf61bdb34cca82f56c992ef5d0fca5ee1247ae"
