# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "14a56bc716f57822636bc134053d35e8"
SRC_URI[sha256sum] = "ce24350200a910041477187aedd14a9b8cbe7c57c24aa45f45fbed5cb20eb61e"
