# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f9d6d580ddff5a6a985e013f3f416bba"
SRC_URI[sha256sum] = "ab07b23ba24a103222bee7139e81f47ac1a24283cc7dab26bb458639a0938533"
