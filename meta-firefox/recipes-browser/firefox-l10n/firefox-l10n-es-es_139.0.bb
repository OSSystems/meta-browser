# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dd8e7bf41829e78595b31dfbc9d255cc"
SRC_URI[sha256sum] = "359fed6074f988701ed1d9dcbaab4580956b2669ca97b32d9995828a738fa7f4"
