# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "22d69de4c5d8c76a0e95075bef0a77e6"
SRC_URI[sha256sum] = "139016bf341fe2a224688d471cd2f0a52144575875a69937d44a4e293f931e6a"
