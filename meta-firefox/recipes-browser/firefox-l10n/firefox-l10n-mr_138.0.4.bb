# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8d0e1f2f39aecdde324ccb0625b04305"
SRC_URI[sha256sum] = "ef7d3fa7ab9bf94213843de746db280cc3d1063874bfb13a85d642f5b2e82552"
