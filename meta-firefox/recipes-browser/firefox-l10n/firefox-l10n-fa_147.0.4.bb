# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e9ed2a42881fc9d1aea7db2fd46d5793"
SRC_URI[sha256sum] = "6369a8a00a0393675f0f0bc6bc7661c6d15e903807b5b466d6644195d2f44ef4"
