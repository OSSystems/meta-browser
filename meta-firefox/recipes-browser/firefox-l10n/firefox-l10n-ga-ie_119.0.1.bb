# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9658fe4c64b12d701318027ad948ba0e"
SRC_URI[sha256sum] = "97ccd8f7a0dac47e86503b4db9e61f1c9cadb27b03898799cc8900e3b2a7447f"
