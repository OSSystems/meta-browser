# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "47847d0c91d5f30d43d7bc0139f1d6d9"
SRC_URI[sha256sum] = "c6819751f1259f7872569f234e98b1b475bd0e6d2a801e3539c41e60fa37de54"
