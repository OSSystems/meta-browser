# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "be4af26611e27f2deb662b44039ac2af"
SRC_URI[sha256sum] = "4b3bea56dcf474fd981659fb178cbe5c17b0d3098ba96861696d1dbfed4a20a5"
