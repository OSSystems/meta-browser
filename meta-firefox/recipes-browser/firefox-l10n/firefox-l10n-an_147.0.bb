# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "efc38369068f7660b52154d2291e796c"
SRC_URI[sha256sum] = "ba1db7bc5f9920c7274d2d112ac5bb86b46a19b35dce72025d649c06a0a5c2af"
