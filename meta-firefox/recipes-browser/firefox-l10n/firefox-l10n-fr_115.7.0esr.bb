# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f971416206c926cba9e073cff68f08da"
SRC_URI[sha256sum] = "4ad4255b34dd006ee2d853363e3698ab062da51ea1e10a999699f2659559581c"
