# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2fb577c104c126da67338d4778e36edc"
SRC_URI[sha256sum] = "fcf592dbfc774c05675924df968856c74e1bc1a6108f7278fd3844937b1c71b1"
