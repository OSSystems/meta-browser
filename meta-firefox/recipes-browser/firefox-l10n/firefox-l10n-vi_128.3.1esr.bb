# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cc95253398fda79752fea4c2a3ba7867"
SRC_URI[sha256sum] = "7f8a1b637c2a8885a5d4609f3f70318bc964f99f3890e4a393d4831cf2d5dc39"
