# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c55010bf0865a276a43648513a34893e"
SRC_URI[sha256sum] = "be7a0f3267b423ac547153d9255ad39361698c2231a8c2fafbf343e8d728b1b9"
