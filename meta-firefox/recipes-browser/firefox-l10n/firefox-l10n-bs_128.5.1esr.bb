# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "529913f6a7232fd9071bce01ea2c836f"
SRC_URI[sha256sum] = "525f9a93292b8d77e42f9282cebc591a0a7bcc4f4b6a5ca9fa2e3ac6d1292816"
