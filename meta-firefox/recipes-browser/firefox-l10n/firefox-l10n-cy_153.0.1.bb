# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7df30be8a0e5466b852a731591b645d5fae9af974594aafcd72f9ec61444bfba"
