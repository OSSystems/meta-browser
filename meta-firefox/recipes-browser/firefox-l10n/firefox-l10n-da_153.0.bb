# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "775eba54524aad3fb6bd1feb3902449b130c8a2f1b004a859046e69ab4d282e8"
