# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6b6e278cdc0c93519486f9a657335e9b"
SRC_URI[sha256sum] = "36797b185a8b9edc452e0c8081328986305935bdbee34cb02869301d45d6810f"
