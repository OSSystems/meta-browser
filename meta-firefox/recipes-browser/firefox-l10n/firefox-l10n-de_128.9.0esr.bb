# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dccad1b7b594edba9ab75c1699a92e0b"
SRC_URI[sha256sum] = "d9cf7b105c4eedc9b1f141d570811c0dd1e185764102fe002f84f67eec7506f6"
