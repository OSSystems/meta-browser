# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4af7158cb16cdf0b90ff2fb64791bf99"
SRC_URI[sha256sum] = "2ee8feed9d8a270d9fd9b25bd98049daf404795dd09759c741d935c114b7b45b"
