# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3fc39f4efe7ebdfaefa2648dd668ac9163089241fe27282925833349d34ab646"
