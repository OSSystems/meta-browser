# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f3d965aad7d619c3b92743a7148549d7"
SRC_URI[sha256sum] = "227dc8d4c51051ad9808917cd83adb274f75ee2b819952734a19ad08a39742ca"
