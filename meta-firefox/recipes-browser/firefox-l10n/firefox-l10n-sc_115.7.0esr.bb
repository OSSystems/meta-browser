# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "93799d88e4120453fe75ae2114c246ae"
SRC_URI[sha256sum] = "bbbfe857eda2db08425e240c28469833afb808b7b1869b4ea1eaee41ce2c29f0"
