# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ff69e366d19bc3bf918053d418dffccb"
SRC_URI[sha256sum] = "d77169cbbff8e7cd4bf8561b723f05dfd223b1119cc340e626dc8626179953db"
