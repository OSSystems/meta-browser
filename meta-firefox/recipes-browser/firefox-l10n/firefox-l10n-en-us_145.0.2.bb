# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "64f55a23b95c63c5c87126dcdf20c17a"
SRC_URI[sha256sum] = "6dac89525840bab33d39c9fd7b499381e2f48a69cd39f0ecf8e3101e562c1127"
