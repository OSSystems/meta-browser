# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "41d0fc4998caad94801b6a37cd705ec1"
SRC_URI[sha256sum] = "5064be6a8389c216a0d08b879f0db13242bae81831abbefd2166387ff191eae8"
