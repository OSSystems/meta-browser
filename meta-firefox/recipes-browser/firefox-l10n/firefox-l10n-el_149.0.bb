# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "61a5a699c62969defb1ddc492b64d7cf"
SRC_URI[sha256sum] = "17fbbbf4e82efd375900ec7017ebaa20fa09968201097d38c741c6e43604a328"
