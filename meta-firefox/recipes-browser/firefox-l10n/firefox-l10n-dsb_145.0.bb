# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "faa8d9b80a5a91795418579f064565ae"
SRC_URI[sha256sum] = "54057c4153dc305d76976f952a21f45598bb0b8e843297bf28a0d59641e9c111"
