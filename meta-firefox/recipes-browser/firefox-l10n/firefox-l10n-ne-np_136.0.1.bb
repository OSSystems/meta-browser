# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "889ea87711c96707fe1b150503b4d300"
SRC_URI[sha256sum] = "7b05baec462487d52e3c45d1751f8494822565f6b47d2a95833cdd224fd97a71"
