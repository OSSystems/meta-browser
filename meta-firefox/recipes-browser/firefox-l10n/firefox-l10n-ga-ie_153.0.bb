# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "361fefc9fba1be40e40ddf3f0d794fb2a39ee8090cc066f15a520059699e382c"
