# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "42cf785321c58978a97296ee1f315313"
SRC_URI[sha256sum] = "1a8cc7b399e970e93fbe4f1fd11f820b34738e118731c0260fa05396c7de13bc"
