# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "b7623e672c4fdae2232bdf48405ee1ff756047d7b2e63dbedeee5a38468e3798"
