# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "61249b5f4925b81af6ffa076519de6a2"
SRC_URI[sha256sum] = "720b009aa71df603f5c87b4599d29f5667582af8dc0ddc693e5638d2dccc814e"
