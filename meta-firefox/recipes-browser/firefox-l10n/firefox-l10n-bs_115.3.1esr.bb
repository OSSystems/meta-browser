# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "785f071c74529623658a38433c8c6f90"
SRC_URI[sha256sum] = "52cde5a7941b41dcfbf0dca4f4f9a6fca99215f3eded95792746090e7d80b956"
