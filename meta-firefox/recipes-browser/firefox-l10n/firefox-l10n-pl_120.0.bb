# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "950b04911477bbe4d340d4d76cf0a8e6"
SRC_URI[sha256sum] = "a1efa8ab9ae86818afaee20a6538d44019a8ceff002ea09493fdf9f04c08c1c7"
