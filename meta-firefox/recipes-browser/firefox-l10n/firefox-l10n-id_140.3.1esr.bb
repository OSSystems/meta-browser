# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "296985e55b4d88ad3c89980bc55dc40e"
SRC_URI[sha256sum] = "0f6ea06d78c607aecf54e58a5cd12d75c230780361ec3122978e92ba6a153945"
