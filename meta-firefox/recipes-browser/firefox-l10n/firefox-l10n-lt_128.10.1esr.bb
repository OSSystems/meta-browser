# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "309001272bfed3af660d424dc873abea"
SRC_URI[sha256sum] = "4cc776825329ba3e8ee7a054263987e28d4805ab5d845ecaf7c9c2e3e91840bd"
