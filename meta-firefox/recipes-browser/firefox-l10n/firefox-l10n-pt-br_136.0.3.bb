# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9eb6925a57a69cb3961d5e3d80e8393a"
SRC_URI[sha256sum] = "86d8cd5c4e46fc5acfe6f76adf392d190b55c8e54d7deb08744d2cf175a9660d"
