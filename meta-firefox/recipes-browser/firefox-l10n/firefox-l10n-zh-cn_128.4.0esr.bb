# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "50892e4eee34894128f629946fd6294a"
SRC_URI[sha256sum] = "336047b278e3e2c3ff5c4429a7ce3260c6b98d956f555d8bed20cf2544ff60d6"
