# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "152a0a576d21412c3daf04cd4c4c849b"
SRC_URI[sha256sum] = "4317262e108cd4d46dc51811e5f7273e8b619c7ec3742c4c48473c6fc5864b3c"
