# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ad88289d382edeef36aafd096f8e887f"
SRC_URI[sha256sum] = "ce24c3dcde81c71b46ca8f32b88b27acbd4f3e6cb0d42a5541109117d12c4ad5"
