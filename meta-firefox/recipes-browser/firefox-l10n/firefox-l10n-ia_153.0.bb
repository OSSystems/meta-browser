# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "04a652acb8bd5ec0401e05b81b5aac5215a8b0f8b1a66a06bc9adaa7cd912090"
