# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e3f47a9808313a6eed341ea14a7961a9"
SRC_URI[sha256sum] = "e9951ed18c8befbc2bbd6d5967d6aea3fe154c7326b034fef793c06d20ca824b"
