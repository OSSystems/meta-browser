# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "9897673ef0bc96faeecf8d7e97f0939128e0bca60b2ad79bfb373d5a1e801bbb"
