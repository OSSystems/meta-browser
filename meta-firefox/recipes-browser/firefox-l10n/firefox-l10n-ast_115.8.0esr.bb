# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c9148de9a04146001268aec62ba62f9b"
SRC_URI[sha256sum] = "87ed62010af0790dd649a51398abe64f78670c89bebc305f9b9c4d28ea158956"
