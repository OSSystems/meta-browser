# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d5d985d2e404df879a4901a3f371b432"
SRC_URI[sha256sum] = "4fee4a55c4be88f6ddc1b5672e2acaed739dfc96a0c51d0df924f838fa805b2d"
