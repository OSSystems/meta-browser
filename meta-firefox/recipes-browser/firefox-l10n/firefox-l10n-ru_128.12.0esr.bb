# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "133b6cb42e385b3d436017ff68fd1981"
SRC_URI[sha256sum] = "b6fc91b50a7de5bf478f91f4d1c76d88ba83f47044a4308796ac98f11f73e629"
