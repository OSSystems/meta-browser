# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2479ca19ec9daf649389063727a39c38"
SRC_URI[sha256sum] = "4ca6e1a8fd51561cb43e01a503b82ab8bba7ba1edd27643171b56d09ed0ed71b"
