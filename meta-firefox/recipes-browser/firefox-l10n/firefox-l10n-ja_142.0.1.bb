# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a46711aced076343a4e6833f6d88ec40"
SRC_URI[sha256sum] = "aa35d0f50d7672be0e7b0d5aad078b2f88b5eff3f9da69ab4d7c09a0533e9e31"
