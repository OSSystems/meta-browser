# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e621be78590f2ec862fa327bafa4af6b"
SRC_URI[sha256sum] = "7181c6d9e62cf3f9c8bd2c081f2c4df835ee3944ccaac9a6dc4643e97db4aed5"
