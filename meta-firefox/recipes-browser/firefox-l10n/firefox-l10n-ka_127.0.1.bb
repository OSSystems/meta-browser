# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "46303f5acd0c6641a50ee739c25e0289"
SRC_URI[sha256sum] = "47e2fc5381cd3ee9869c578f58042656fd4f4c11c521ea1f432a1f81aa635102"
