# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "09e4c7faede1dfa7a96b61cb0ded1c5d"
SRC_URI[sha256sum] = "d1fabcf932df4a94373a8e2795dec265a00795972bfc35dbf0a3adee5b9cfc3f"
