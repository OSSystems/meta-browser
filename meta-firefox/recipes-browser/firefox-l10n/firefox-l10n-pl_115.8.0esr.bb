# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a52e832573b6df42ca188b068c529b45"
SRC_URI[sha256sum] = "a12ab37c64cc6d4a39a13bf159028fae92bb4e0f2cb20be4e2e043b695e35c92"
