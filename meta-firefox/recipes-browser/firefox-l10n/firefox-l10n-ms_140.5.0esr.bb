# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3b51375dc57f8540bad830cb8981013a"
SRC_URI[sha256sum] = "37e039b0d29b0de5bf6e33bf797c0ae42ed5d1f7b68c1e7255d6a9298f6e3e39"
