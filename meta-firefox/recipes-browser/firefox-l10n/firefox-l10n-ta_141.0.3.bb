# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1b93df7754bcbdbbdca8bf94adfe0d88"
SRC_URI[sha256sum] = "96236927863ff53ef2d95f0028e2427c40bec37e5fc1da04f1689b5e90bff408"
