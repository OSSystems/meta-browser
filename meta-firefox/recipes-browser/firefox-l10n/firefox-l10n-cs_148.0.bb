# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "395f1eddec55f1206aef575f8920bd30"
SRC_URI[sha256sum] = "59bc6230f5f96cc866c8110c7f93b032a24a6b4df555ab67bfc91c0fa59af8bc"
