# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4e4228f5f1b4fc48f4e27b08c8ff3b4e"
SRC_URI[sha256sum] = "78766aa327976eac847262faad507d4914028064b7cd729f4dd711619b7dcfb9"
