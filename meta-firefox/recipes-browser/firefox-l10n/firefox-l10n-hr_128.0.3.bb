# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "70b013a42ae1f4b80577fc9ea6196091"
SRC_URI[sha256sum] = "d09eb6341278a56cb20ae87947863039b97c7d5b09e7ea9ad8cf0c8ab62a4918"
