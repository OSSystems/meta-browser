# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9969d1842444ac1b897714f822078451"
SRC_URI[sha256sum] = "91379265cd0a4c8fa4c19d49a2914bcfa8d75f2e02f38c32c47c83542cf5ad72"
