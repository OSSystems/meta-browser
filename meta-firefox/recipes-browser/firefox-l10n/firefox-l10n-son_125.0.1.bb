# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b48508c19e178bbb82113b908811185f"
SRC_URI[sha256sum] = "7147433f3496b66102b38436beec1c10fb6cfa59c2ffb8d21ccce69307ab3e05"
