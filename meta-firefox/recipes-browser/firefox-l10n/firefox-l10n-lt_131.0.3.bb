# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "04be242149e05e05e1247fd86ec59054"
SRC_URI[sha256sum] = "291cfc745fb93689607c905cabc8c5aa325e2ce36f57e8560976510c546cd9f9"
