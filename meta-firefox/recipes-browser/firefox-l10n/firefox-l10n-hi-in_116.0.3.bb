# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "513157a05d30964b6c62b0cac35380ad"
SRC_URI[sha256sum] = "43936c160aedceaa45f93b5ede9d81882207dfe4069ba8622ebd5f809053e5cb"
