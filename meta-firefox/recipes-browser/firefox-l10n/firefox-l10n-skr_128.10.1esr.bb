# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5a84384099ee642281dbb88f9fdeb46b"
SRC_URI[sha256sum] = "ef911f87f135677168e6da40ad060f6aba0b94524d48dffcf96997ec3f8ba30c"
