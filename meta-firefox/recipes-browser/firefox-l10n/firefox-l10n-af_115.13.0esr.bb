# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4cd42cbc9e88ac3573e7c6c4010e3c88"
SRC_URI[sha256sum] = "28fe5e4e78e628c6fd2cf1af75f85c696cefa5f459df2e5e75cbc22b60891ad4"
