# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7d3ac166dba978190406b66734970edc1c2d52dfd9d1633f684eb6922b833f81"
