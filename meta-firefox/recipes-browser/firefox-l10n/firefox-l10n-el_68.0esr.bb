# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c9c70735681799cbcd602febb0ccf9f3"
SRC_URI[sha256sum] = "621f562715f86ab0eeeafcff68e09006b6647ed9ec3fe4043115ed04d6d13f78"
