# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ac9b3e37d37c3044e38921c95be83b3f"
SRC_URI[sha256sum] = "f42ab5fc3a9f49a05831ace66ccbbb07139075486ef804cf3a1db2b7912fd3de"
