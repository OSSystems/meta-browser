# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fdc0c5b36881d46a33b91678872dfb7c"
SRC_URI[sha256sum] = "adb8d5b825360f237b73d0bc7f3d8362fadd1586d464b25021095a55f9399d81"
