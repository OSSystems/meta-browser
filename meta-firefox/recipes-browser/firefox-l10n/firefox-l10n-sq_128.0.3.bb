# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "84af5a128abfa61243dd1ca7f06c2514"
SRC_URI[sha256sum] = "fb0fdbb4cef00fda45ec5e9283aa917f79bedc62821fada233c9b3a55e6a0959"
