# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "876f5cb74ec15e356c931546064ec9fc"
SRC_URI[sha256sum] = "92f7f74aec380a095ac6fa457e8f6257e46869ace3ec6d1c8e40aee43bf6c849"
