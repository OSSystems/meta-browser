# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c83c760941c7d72dbafc9a59efc93fc4"
SRC_URI[sha256sum] = "92e4f6cebc05875c9f81c6b6ee102288bcfc3b1ce94bb08c7b3714b6cee89c64"
