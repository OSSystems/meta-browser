# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e96037f4631588b97fd6b3228c47f641"
SRC_URI[sha256sum] = "609ad40eb31964762069b9b5d51814c304fcccf01d6966540e2c5da05af4abb8"
