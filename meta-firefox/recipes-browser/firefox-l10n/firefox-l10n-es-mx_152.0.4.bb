# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2adfd7eae5c277f6fe3efb0cfd4053806870b9da714c5d1bc8a443a1a7a8319c"
