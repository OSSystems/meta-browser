# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f59fda571be15a7ae5faf0335c161614"
SRC_URI[sha256sum] = "10f8f5a1df6bb7d605b8d92c08cb09ac746a4e2899d16728249b086715b8b313"
