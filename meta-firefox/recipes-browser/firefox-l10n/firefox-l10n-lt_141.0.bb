# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c1d883ed57afb51343411968dfe20ed0"
SRC_URI[sha256sum] = "b48a7da909fad07dfa5666b9af439d9b0ab1e5e70e748b9330c72d19a12c2fe6"
