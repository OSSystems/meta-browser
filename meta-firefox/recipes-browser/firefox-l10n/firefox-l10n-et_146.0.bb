# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cbddf453e53a2e289faa3d80611d42aa"
SRC_URI[sha256sum] = "2b91cfc4c35157ce822be543df467ef130461ad545c5b0630ff110e3553d8040"
