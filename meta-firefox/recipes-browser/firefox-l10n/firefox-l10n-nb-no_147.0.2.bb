# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "616cb3b458c0810b19af42ee6e066ec9"
SRC_URI[sha256sum] = "fc22dd17498c974b65a48ae6c4e1c0e70c0fb93491bf95ae1c646ab9053ad119"
