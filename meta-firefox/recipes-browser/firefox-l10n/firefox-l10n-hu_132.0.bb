# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "00e4ff3912c74be657092f07b1c69fd7"
SRC_URI[sha256sum] = "69008cbf47ca9b95d79f88f0dde6c7fc18e8bff650677cbc06dc020b22c13788"
