# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "abeef6e5f082d7b12e8525632e806d86da41066c7167b5440aa38daa83638e3f"
