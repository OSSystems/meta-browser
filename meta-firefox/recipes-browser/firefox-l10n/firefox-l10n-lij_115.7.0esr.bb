# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e60d83857ac6f51ca75daae784595cc7"
SRC_URI[sha256sum] = "4021cf4bd55075081c4b43a4e60eb8a052256c91dfa43c406b08abdb047ef4a1"
