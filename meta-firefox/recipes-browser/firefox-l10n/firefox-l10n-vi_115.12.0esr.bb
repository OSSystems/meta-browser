# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ead1b02edbad5ab1ca4441e8b11fa696"
SRC_URI[sha256sum] = "909b266f55a9bcdb4127290dfa9498bcd84475a05655f8d78495bd68b5c64aad"
