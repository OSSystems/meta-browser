# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b0d1dee31db954291a21e36b6a5b2c85"
SRC_URI[sha256sum] = "49fedfc3980e4986545d39247327483159b0a54760dff3cbb4f1d7dde885cd30"
