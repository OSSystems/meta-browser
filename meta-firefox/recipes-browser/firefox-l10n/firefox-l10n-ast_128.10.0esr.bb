# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "efa2f6174a71b499fa768b95e5d1bc84"
SRC_URI[sha256sum] = "2ea227cfd894d96e5fe2c3d1e998afd8ead4bd36478e9ba275b0316dd0614cc6"
