# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4aa05dfcf0acf3647ee50021d3b6d124"
SRC_URI[sha256sum] = "99714dbb35b491a16c8eae340a643b87b519325d836508d03cd19c28a426499e"
