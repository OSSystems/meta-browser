# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "85da091804d2fe85c026e82ffd5392b6"
SRC_URI[sha256sum] = "24854eb38e4959fdc35dd244aff2e90fb1dea21464235c7a03fe63329915564e"
