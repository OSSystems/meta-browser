# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "88de194426cd5b919bd98fcf4c2d9ef7d707285d66d71f42187ada93e0c69f5f"
