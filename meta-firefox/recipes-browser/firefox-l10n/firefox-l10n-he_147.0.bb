# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ad0e887f44c25efb599fa32eafad536d"
SRC_URI[sha256sum] = "3ec88c47540b81bc9471c0b2bc820f413237fb6e7c5eb826756ffdb8aab7293d"
