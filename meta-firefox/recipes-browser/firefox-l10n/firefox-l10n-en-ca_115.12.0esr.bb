# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8945e5859e8c14edb1e1504baec759a9"
SRC_URI[sha256sum] = "485bc3cbe050762daea8f6048f3ac264e5524daed91410711cbaae79c418ffe1"
