# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "bb5f313b3dbbc77639d6a781ecc5825f06f487cc1d4f0702ff1d959e6e457fa7"
