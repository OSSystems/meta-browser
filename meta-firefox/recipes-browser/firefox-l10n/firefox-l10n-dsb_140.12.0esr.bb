# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d2a694d73e769f1c395e2179f3b4f0e8fd5ba5b929c2f48b4a760ec487592d19"
