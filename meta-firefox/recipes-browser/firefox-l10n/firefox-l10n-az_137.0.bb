# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c6245dd923c620029a205e0c90a237e8"
SRC_URI[sha256sum] = "e2d4aae42019a00bd8cb3b1dc125c73f717c189ab2613d6e706bae95196eeec0"
