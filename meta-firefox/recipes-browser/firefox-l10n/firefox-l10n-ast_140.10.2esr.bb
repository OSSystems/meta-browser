# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c9fe8971c77ede2d3019b139d8cfd07d121e1e802256e4e0117a7adcbdbe146e"
