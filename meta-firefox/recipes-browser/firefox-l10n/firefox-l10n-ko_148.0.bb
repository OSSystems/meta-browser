# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e6a33867f1e633d52a83bbfcfbae7edb"
SRC_URI[sha256sum] = "ff512b67e7bbb79f92ceddcff80c110cfa29f55fa20e2df120d5188cd0f46189"
