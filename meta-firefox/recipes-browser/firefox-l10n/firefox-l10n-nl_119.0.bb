# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d27078409807469a233e6729efd33ba3"
SRC_URI[sha256sum] = "03e24657a56113b98bed0b9e4a1756a15d093eb019b499241a7dd1bbe004e384"
