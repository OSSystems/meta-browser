# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8cb01a0f1cd537504ba20f1b414e4f01"
SRC_URI[sha256sum] = "71d5e78a59cadde7e9e69f2655a8209937f8d46a8d1110ddccb77fd2f91da794"
