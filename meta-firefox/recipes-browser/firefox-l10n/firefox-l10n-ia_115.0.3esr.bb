# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "015f402390916f38e9f4ec428115d72f"
SRC_URI[sha256sum] = "9a3880442bbc8a5d153c554595dd937cf18c4b9e128f1f4c7090b780642339d2"
