# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9f5e11641914b009a375728df7562ba4"
SRC_URI[sha256sum] = "527cfc70668f55ab07256a6f4320529240afe655c099c9f6b391f62c4045c0f2"
