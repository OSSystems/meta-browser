# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "5bed75ffababf24a75cbc7f63e6bac68497de1aecba8c48193859cbd1ae79e74"
