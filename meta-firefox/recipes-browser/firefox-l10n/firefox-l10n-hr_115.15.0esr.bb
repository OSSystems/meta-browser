# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ab239a3e7f67d408a7539ba0e8addedb"
SRC_URI[sha256sum] = "6895aee80ddf8c3553fb6777218a6e7c017ba8db4bb9d1c46497aa88b37a196d"
