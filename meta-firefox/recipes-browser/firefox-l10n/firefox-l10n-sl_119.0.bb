# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e0ed25a36ceb638861689b5caf3989c2"
SRC_URI[sha256sum] = "9ac35f3e0739c53f99ad45124e405eb8c734d190e4acf23dd3e98ef6b11e0cb9"
