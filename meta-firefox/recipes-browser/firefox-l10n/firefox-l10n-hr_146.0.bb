# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "51b96963d3086a932443f7b5d323b1cc"
SRC_URI[sha256sum] = "e9a333cbb089658b59fc5941693bfe923ad231545ebe8a5c631c3c937fb7780d"
