# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "b1c0058fbfa0ba26dd27623eeac6bd1d9747a19663787090bf483f259841e7c4"
