# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5e932dff71a89ff7d8483b23dff4ce03"
SRC_URI[sha256sum] = "9b6b55b904e079c5b01b80f803a84c79e79e54d0f356423e375bf42ed57ae5a2"
