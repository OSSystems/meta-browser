# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "19e78d7e01d18c2be6e490672fff82a3"
SRC_URI[sha256sum] = "f08208c41f6d18761376c995bc307ecbf32b5a931d715263f183b60a8effc749"
