# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "426c6f9ee8c299e2c545114aa43abfcd"
SRC_URI[sha256sum] = "39b7ac194c51b63b37275c50312ab7f2b7c944897d88e58648c1837bf437541d"
