# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "acb116580bb33bc55b42d6ef37bde5bf"
SRC_URI[sha256sum] = "9cc01bd516736bfee1964af41d85ed79389f7419055a3b798690952bebe7bf85"
