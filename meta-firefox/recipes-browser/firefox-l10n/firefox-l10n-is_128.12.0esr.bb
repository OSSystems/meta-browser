# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1bc6e3c15d12cacf93bdfb538ccba814"
SRC_URI[sha256sum] = "80fc29e137ab62e799a225f8d55877270cf47bfa552fdbce85f4036febff7361"
