# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "791ea5185d6717aa47b5fa2ca0f45687"
SRC_URI[sha256sum] = "86790b6d14c1e7a6013020c4d2d73d0805aaaebe6f6fb40d6c665f044270256f"
