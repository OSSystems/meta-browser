# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d52b5efd9b08de5dd3daf84902aa66a4"
SRC_URI[sha256sum] = "f400ff55c9ba7192644881ff8fe3c9465b44e1a4a7fe89f555129ae0193c5438"
