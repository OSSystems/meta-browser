# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9c3014cfb7facf3ef72d345d0fe75d16"
SRC_URI[sha256sum] = "5457c90978dfbe610adc57351eb64a1921307ca0644c019cb2be714b163648fb"
