# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4a2a1162030bfbf9b6e29cd34ddee7ab"
SRC_URI[sha256sum] = "8d772ad6c708e3984c7b60f20df2a3d61ac0d2cc85b88faa0952dab379273894"
