# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8387b33c9a82f1cae101400677f58992"
SRC_URI[sha256sum] = "af496bdad21d96405c2911fc44c0b35b4c88b28b74f6e70407d077e25a22470d"
