# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1b6b20d66a85e5f295a4dac1ba3b28df"
SRC_URI[sha256sum] = "3ae1e72d06c2988d50994aebcf6c877b10c343e8c903d66a4e32cd711b912723"
