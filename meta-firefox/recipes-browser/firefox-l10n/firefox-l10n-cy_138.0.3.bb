# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cbc60dc6260500d72cb2d6ee102974dc"
SRC_URI[sha256sum] = "ca1c4c35e549a18e1b75c779340fbbfa68f7d0595c4aa302dc4a1fee2870763f"
