# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "72e0bad4bc961f153bcfcdf04b9ac6f5"
SRC_URI[sha256sum] = "db4caeacf1987a7ace09f750b035c0f62e19febde90d8a6af8e7f257fc6ae7d8"
