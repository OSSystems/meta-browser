# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b28c10edbaf32b58b87e46d8da0f9238"
SRC_URI[sha256sum] = "e504b68e4cf5e9fa5411ee7ba6c80b97ca7eeb835ab5d38cadaa88a4e66c03b9"
