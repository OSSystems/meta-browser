# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e69c30c1767a3ece1b22cf01fe0c5047"
SRC_URI[sha256sum] = "934c3c983eafd2c79a814e08510d3fd8a6ca00abae2672d15f520748578e0862"
