# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4a88e7f8509335a5107ca57ac24ada76"
SRC_URI[sha256sum] = "6291707b677258797fa64f22c0936f136b8dff5b6b101a731f3c66bf64b8dbe0"
