# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8551f031a5276381151cce97b8e79757"
SRC_URI[sha256sum] = "87c8109d8acdf9a3c5281860b3285f58eec55e267be8d2d721ade00f1b889658"
