# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1caf368e493eeeddfb050f5f67c39ef5"
SRC_URI[sha256sum] = "36e0eca843592fced5cc829eb2f5a87ca6baad1fd9b3aa1b90cda131df7f4ab5"
