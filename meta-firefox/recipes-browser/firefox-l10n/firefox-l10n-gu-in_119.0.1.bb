# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3c8166c4f4ba325eb3b7653ff7edef83"
SRC_URI[sha256sum] = "c481f37c9a70744f470885d6a2664156c900b02d1de484c55664cf077c3b819a"
