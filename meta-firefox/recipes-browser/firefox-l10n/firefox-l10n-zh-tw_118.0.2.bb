# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "079edaa4f274c2b4fe4d9b8c5b47da43"
SRC_URI[sha256sum] = "2703bd28310b554b8d6675842f7cc65fdb60f2411e0accb2132139160a54a6ff"
