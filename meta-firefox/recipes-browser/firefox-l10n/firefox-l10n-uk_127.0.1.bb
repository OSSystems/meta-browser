# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "397172bb90468a06bacc94ded8a31350"
SRC_URI[sha256sum] = "6a61ec360f9421218e2b78bf3e2583795373e4842a6b75359b437435aab0bf3a"
