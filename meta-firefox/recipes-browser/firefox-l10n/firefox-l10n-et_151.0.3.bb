# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "47e4db6baa31506432fb8f45bc10dbda0beb55f6febd1396f21721edeb8e168e"
