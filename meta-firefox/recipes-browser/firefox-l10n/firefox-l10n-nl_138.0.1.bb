# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "854c8bc6c15e855ab8e5b043abb5dc99"
SRC_URI[sha256sum] = "e649912b19b2646ca98f876ceda1a6e4e3d792fbef2b7c5c40f70986b5606ccd"
