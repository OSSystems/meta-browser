# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8f3be9cd07afd27684baa2a2bfc5e9b6"
SRC_URI[sha256sum] = "4b4e61e9ca9ea2d64f4a499f5eddf8e93be710a22be738592632f09b3e8f8fa4"
