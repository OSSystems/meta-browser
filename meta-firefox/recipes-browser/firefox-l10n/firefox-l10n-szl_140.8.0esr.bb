# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "23971419706b8b98cf5dfc199b115990"
SRC_URI[sha256sum] = "ba028d0c34335cfd02012925fc2177fcd9970cc75763737e41fa644575b44b73"
