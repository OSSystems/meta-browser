# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ee4ef20ac147b66ca7fe0309aa5f920"
SRC_URI[sha256sum] = "457825cfe8dbc0c750f5e609b2b3cb6441127d5105217d8abb3695f9c19744a9"
