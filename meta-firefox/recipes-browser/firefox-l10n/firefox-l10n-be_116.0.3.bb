# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6ad77162875fe2d2cb573b1161002c09"
SRC_URI[sha256sum] = "bda77ceafbd84204e0c2d9d72e78061ed1eab43e4554cb47fd46758eb69e1fcc"
