# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "36f4c222bf1b116099f250202153ff0b"
SRC_URI[sha256sum] = "09d2ed617f60efbf3379a9e7a4fa58ce94949974cff4107f24f3935010bf4038"
