# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "fc5f6f18e5e730713903b9c7dece712b11b8b8cdc5c43332100da96cbe2351ba"
