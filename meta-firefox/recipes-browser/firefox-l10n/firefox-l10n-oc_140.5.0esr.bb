# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ee92fb8fc2c4fc83bb87d4cc9b3b91ac"
SRC_URI[sha256sum] = "a276e92d4de94e535371086e6439391dfebb8e80d7edfa22ee5c634af812f870"
