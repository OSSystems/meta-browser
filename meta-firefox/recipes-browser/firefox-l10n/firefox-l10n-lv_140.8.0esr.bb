# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "866116231da99ef18b1c3e6654304cf2"
SRC_URI[sha256sum] = "020c90a1e4d9b8bfbae26e858810e061e9812330cdabb26d6b3e1386579cb2e5"
