# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "23f91612c44adce1defe0df8f5ebc206"
SRC_URI[sha256sum] = "1e9f20fc3ce5da4c425dd436f697568b9e623b0669007f363f8476ad7b4282c0"
