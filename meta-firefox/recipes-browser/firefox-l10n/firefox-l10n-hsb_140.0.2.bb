# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "92984f7a47dbaad5ab6d9c81cea6e7ae"
SRC_URI[sha256sum] = "4e8cd4fca7d44791fcb7e0d33e08703485dae656ae40ae56fe89faab32b936e4"
