# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a591d8bb37423044cb6efdb593111f4b"
SRC_URI[sha256sum] = "459a754459aae5ce31d5e482234251bac1fdc2be030df9f2272daa19dee8ac02"
