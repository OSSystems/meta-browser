# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fbec2fa7c701523de363268241d6b1d8"
SRC_URI[sha256sum] = "f6be0a66e87a9c7086a5d52aa6f0ca79d8433b94ab07a24691b22c21199fa10f"
