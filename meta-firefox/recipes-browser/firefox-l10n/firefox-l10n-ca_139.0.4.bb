# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b9faa26e3891fbe1ab180ae788f35e9c"
SRC_URI[sha256sum] = "88f9565317f6c8570f6a77dda6185a34028888e8266adb53da6153e7b1283de8"
