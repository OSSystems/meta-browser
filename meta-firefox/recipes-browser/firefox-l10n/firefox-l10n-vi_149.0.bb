# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4615d7775706331e32ea34078c1621df"
SRC_URI[sha256sum] = "23b8796cfa02f1fdd211a97f7e348ec65cf78721f37689fb75521b50a0b06f9d"
