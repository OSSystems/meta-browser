# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fe6541ef078a1684ee2d561b01d92f36"
SRC_URI[sha256sum] = "b9479599243305e3e3887b33ed330f14a4483f46e28642009dd7913b091e247d"
