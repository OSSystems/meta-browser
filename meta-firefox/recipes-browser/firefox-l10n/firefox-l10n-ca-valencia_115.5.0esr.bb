# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a8f80080de3808814d7b685c543fc7d2"
SRC_URI[sha256sum] = "b0fe203e355501ff70492259ce02f2afc4a981a82662b93d50c2812218cf3fd8"
