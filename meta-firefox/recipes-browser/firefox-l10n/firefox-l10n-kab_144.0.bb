# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8d3edaf0040d7d967195305098d9a1b7"
SRC_URI[sha256sum] = "2eefc4230666b6d17df9a48c987924e595a5ac45452730d97173923837b3e531"
