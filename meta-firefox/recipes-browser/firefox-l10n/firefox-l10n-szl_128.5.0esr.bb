# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "75f65ce774d02fe096480b02608cf699"
SRC_URI[sha256sum] = "58e7314969a1a75ca61a286d30ad3d2235a271818cec895c3e9878b90c1c4220"
