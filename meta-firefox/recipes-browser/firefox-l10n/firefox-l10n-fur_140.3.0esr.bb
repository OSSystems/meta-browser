# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6fcd8a5914324b3a8e9a1b14ec7062d3"
SRC_URI[sha256sum] = "985a58b0bf736f30b1149d522189067697da1e4b6ac21c874c24b202f75bd2a7"
