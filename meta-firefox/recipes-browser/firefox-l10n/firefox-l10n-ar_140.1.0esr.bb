# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a24309657c3105460fd5132222550850"
SRC_URI[sha256sum] = "385a81f6c46f1ecc410f18d1fc5c6ea96e44a393738701695c9314f9e73c52be"
