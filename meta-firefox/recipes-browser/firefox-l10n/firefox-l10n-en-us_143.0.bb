# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f436b30ce7470ff72d2970d42e0b9c93"
SRC_URI[sha256sum] = "c3270a8c2e1d13d4c9c936b66b3e8e744accdf52734568837febc51155d431d6"
