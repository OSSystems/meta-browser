# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "51cbc56be8834f3fd1058f5b8b7d0e0a"
SRC_URI[sha256sum] = "4b34ad2a60bbaab1f779f8f7d8ae57449278cf76636044b79c85083b0b4efcf4"
