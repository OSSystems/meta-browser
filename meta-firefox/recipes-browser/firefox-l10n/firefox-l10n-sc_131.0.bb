# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ce4afddf3cebb54a3e590874db990630"
SRC_URI[sha256sum] = "8ef5f5f9819b825304da9cf9ee4faebc50099a3f0bee74bdd6313781014dea32"
