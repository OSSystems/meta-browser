# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b669b68d15392da7e34e2697a857f656"
SRC_URI[sha256sum] = "1fdb9b9320c2ca4d0be05deb3a7c75c5ead55974cb996ec681ad8c2b52ece0c0"
