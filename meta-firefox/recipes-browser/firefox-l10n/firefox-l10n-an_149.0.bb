# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4f9bf7cd17ac69e23b46050757b7999e"
SRC_URI[sha256sum] = "d993799448894e688fe7ba4577a8ff79c1e395c11879e511805e4b2e4950a4f9"
