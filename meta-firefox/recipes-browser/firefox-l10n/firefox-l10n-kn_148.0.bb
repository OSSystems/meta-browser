# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e7c5e01e06bfb146c9ded378675414cf"
SRC_URI[sha256sum] = "d624e5dc81a38e2dd1c381bc8c2643ca14df9de231acc3f84dff3c879890a35a"
