# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b25933d6d447ccefd228e7c961e85d0d"
SRC_URI[sha256sum] = "2b5b9860df7d07687b4288a82556bdb247ce43f76180e17807f3d87775e3e96a"
