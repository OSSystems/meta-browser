# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "72b4b974098cf7997437c886edd0589d"
SRC_URI[sha256sum] = "aad14613eeb905aa411adc2362409757bd96d0a5a8cd4c90cb617488f342c2ba"
