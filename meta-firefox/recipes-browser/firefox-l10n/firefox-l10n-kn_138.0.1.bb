# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9314df68c8174037886da5de566c46a3"
SRC_URI[sha256sum] = "453d866f1d4840a74ab94af2eb52ccd77add2baac5f48afa555b79bbb03ef5e4"
