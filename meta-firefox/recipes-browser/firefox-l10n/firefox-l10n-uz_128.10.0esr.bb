# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ceed4711556bf0157da00703a5d4aa01"
SRC_URI[sha256sum] = "22b8fedcfdc748199c09680e03bf9993cb2da47efe2b6ba5790d4b2b13f59f91"
