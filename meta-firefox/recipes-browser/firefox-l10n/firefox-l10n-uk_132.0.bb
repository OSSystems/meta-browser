# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e56c7a790c00503ee864a7e652425ab0"
SRC_URI[sha256sum] = "9c544f08ce8d7c730611b6cace1ee22721f737e19f3f426d2d5437d4c427b161"
