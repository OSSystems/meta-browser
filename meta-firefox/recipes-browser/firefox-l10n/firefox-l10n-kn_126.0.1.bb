# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "939f345052ec9254c66dc7feecbda1fa"
SRC_URI[sha256sum] = "32b733a23e5d7b540fe40a2eb70a32f80386a0f63a6e3b2845ae95ae44b22024"
