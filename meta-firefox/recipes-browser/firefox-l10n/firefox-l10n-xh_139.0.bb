# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8f2ae415836de2d9aafb9ab2eaa36071"
SRC_URI[sha256sum] = "92b50db7f0c8f752fc5eab1fbf00216f54de892dfce3ddc4bf6b6435950a0ce8"
