# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "0291939791ea572dcd7c1b4db69fbf4fe8d02955632dbe98f563c39e2f26d22d"
