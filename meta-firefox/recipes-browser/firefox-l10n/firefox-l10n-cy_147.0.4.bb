# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a3bffcc60916eef241c31656e0a3027f"
SRC_URI[sha256sum] = "64a39a2254f90880cff736b491f8423ea14130368fa611326a489a7366311d89"
