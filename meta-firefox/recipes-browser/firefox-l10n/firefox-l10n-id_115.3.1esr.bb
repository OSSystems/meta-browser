# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d069aaa95d3d855b450fef33cf88562b"
SRC_URI[sha256sum] = "b6caec8528da8bba00b09abfae157167193e6f12e4afed13da815c1152fd7359"
