# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a1cfab06daf88b00f386caa9305a64f0"
SRC_URI[sha256sum] = "ce2c5b9d11450b092dbd5f20298a21246ddd2ddd58f0d5334e0a5698c63c7cb4"
