# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e7d5059f0a4652625bc571e61fbcbfb3fe03c2eada033a655716595dbf0177fc"
