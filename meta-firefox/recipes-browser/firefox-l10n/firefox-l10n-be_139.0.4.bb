# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "48329cf3de570a028f2b704d227f0ea8"
SRC_URI[sha256sum] = "fd22d37843b758307d7266f96cfd4cb2a163fe67e5c20ed04808c6f52b6c8774"
