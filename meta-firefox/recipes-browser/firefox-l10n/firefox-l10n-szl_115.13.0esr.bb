# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b5bc38ea25dea7df35cacc1b7e8ed08f"
SRC_URI[sha256sum] = "20bdba8dcceec5b8cb83f1e965f2a8af73066347a1c2426c0fa558e0ce508bfb"
