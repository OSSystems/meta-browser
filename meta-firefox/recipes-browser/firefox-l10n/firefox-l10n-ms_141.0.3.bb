# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f17cc77b2e61e648874f67d108726c32"
SRC_URI[sha256sum] = "26bce02e27f501bb561a4df3b7fa6edf69f825167d3af3b384bcebfdc062c638"
