# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3e263d0e4b0661db3cd4538287161da3"
SRC_URI[sha256sum] = "ae3bd5d30e398d9a15801d8e6d19958190c9093578df14383f4e9007c658992a"
