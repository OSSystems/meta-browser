# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "18d9cc41d720bba7ab6a81db0773c243"
SRC_URI[sha256sum] = "c7ba1974dedf370615ee48ab734faa3d695c48352692d5dca659ad9fa88d0550"
