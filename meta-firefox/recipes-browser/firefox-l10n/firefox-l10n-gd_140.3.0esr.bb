# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6eaba4b64dd1127ccd18a9f59b3ad38c"
SRC_URI[sha256sum] = "e59eeb40c511f9f8712a011de7a70de84ea6f136269937a595ade6aef9b3b223"
