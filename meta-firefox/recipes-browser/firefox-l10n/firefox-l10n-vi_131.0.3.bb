# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0fee451c86dad1281d3b8751321d8b01"
SRC_URI[sha256sum] = "5be314ebf5d12181fddd549fa10d3dcb6c2b29ab05d0907c781532530b49936a"
