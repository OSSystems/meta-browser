# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4c2c8a707967d369b418b2ea9a7bc3a3"
SRC_URI[sha256sum] = "ce75029e5c9c483e7cd438f5efbd9e0e2cf474a553c3c9df71768cbf4d35ebfd"
