# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3f9d0e11e08505e4517c0636fdfd4442"
SRC_URI[sha256sum] = "00bedf8c89725ccac3ff37d639c66aafbddbc92b52374135f578e49d6f20ab75"
