# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "02b65f7b346deb3e9fa2861fdfe84ef0"
SRC_URI[sha256sum] = "a49e41c571bd383b3f330a99141225a3fe75d8f43ab937a08f201ddc2f30c208"
