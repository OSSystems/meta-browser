# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "19456b05ed28f6c5a68283a1e9b1fb2c"
SRC_URI[sha256sum] = "6ff0d45ad85516b8de200f6e313ed74068cced2b37e153c135d1c2fcbc805b9c"
