# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3e35bfc0488229ea65e4eb9d806627bd"
SRC_URI[sha256sum] = "434756ac8466383adef1803a5ab252807698239a7d28683a2d7b050175d2f726"
