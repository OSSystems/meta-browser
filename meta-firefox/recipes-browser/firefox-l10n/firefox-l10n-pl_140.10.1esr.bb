# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "0fed3c8c473e76fe69502ae914b1555060527d0a0fe909189cbc3bc7f9f2dd29"
