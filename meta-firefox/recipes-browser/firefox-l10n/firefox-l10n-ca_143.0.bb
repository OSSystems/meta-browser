# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c7ce5850474db4e639ce97abf3151cb4"
SRC_URI[sha256sum] = "cf1907ad11908a3a86891fe4d9a1dd0e97a71b3788ffb4b7610e212a9e415781"
