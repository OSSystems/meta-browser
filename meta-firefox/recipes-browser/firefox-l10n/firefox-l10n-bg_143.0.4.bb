# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "64e92e434bbaf08d05cb6d3d6da51caa"
SRC_URI[sha256sum] = "eb2e5f348b66e2e6714a76a87dd16049f50fb46d07e015a65cc0120adaed0132"
