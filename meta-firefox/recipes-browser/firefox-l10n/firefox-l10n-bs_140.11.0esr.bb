# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "01c2673599b02acafb8da858260db7ea5d75904e02f7959881d1c767e21ced80"
