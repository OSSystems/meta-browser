# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "288f0d8caf1009fa99a3346143ac0d79"
SRC_URI[sha256sum] = "ec1a21c401b9a066c000cfe5d9be7a322b3714bfe5b1454b27206094cba90f11"
