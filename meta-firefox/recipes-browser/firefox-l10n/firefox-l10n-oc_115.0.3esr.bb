# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d9cff57f10a96933d44fdf7ed6feb485"
SRC_URI[sha256sum] = "803e49fdf872aaaae4bd315aef4fca9694e259a01cacbd95ec2559e7576a9152"
