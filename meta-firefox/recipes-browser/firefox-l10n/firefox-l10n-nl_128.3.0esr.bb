# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "26241816c6cd402cdb6acdb0a5945d7c"
SRC_URI[sha256sum] = "87c9a973ae3376afcb3c5609ba5d7aa33cbe2961c2b79cd9e1c5d060f645edbb"
