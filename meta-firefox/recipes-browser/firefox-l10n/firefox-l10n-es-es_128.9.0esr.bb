# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7f8c66865ddaf2d3255e57e6c433d4a0"
SRC_URI[sha256sum] = "bb81cb44f54e0dbdc3aaf41afe06d99b250c35077d5ed892f3eca905d93cf1a9"
