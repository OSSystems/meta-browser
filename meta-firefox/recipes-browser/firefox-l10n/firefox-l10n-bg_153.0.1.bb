# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "eb9e49a361e08dd834f982e76831c41ef99577a0c20556390e715fe530d23c5b"
