# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dee8e91ddd92b8274d4e67e7f76d2382"
SRC_URI[sha256sum] = "c5e46b4e9f293e5f6dad5e9573817000c11f6e7470f466f27b63ef99fda5fec5"
