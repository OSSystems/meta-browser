# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a7b19382a9e94b94251bbb158f8ed956"
SRC_URI[sha256sum] = "fd1ac2c31e16e26952a8d48eddf89aa32783c61b18b980f6f0a2206ddf1d0ddd"
