# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e9511f8323e7eb2f227156c83e709579"
SRC_URI[sha256sum] = "c7392abc895921273042aa4d93d4b3eb51163c9b1e146e9a9e2ff6be9ecdd9e7"
