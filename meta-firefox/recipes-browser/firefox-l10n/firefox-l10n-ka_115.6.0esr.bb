# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "769490cdc9d97d9c36748e14365a96ee"
SRC_URI[sha256sum] = "58e0046cb930793819aa5994838452e157f461fb2cc3fe6cde0e6c64532ca390"
