# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "770c4cc62743f0b0b244c4c494a39704b7d1030d1a91dee20f6a11f0594528ec"
