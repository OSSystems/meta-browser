# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1421204501cc8366988f7122d9af2180"
SRC_URI[sha256sum] = "b363b37f3ba93a13d883c5496c907ed6790e5cc06b10121baa464cb2dc4ce31f"
