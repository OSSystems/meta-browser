# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7e3ff0c13758768e789687622de63920"
SRC_URI[sha256sum] = "49e393f225dd96421d2bd139d39a3445f17508eedabe133db4514a13f1a36b97"
