# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "46b7cd9b3a9edae4310907152db77595"
SRC_URI[sha256sum] = "7197de8aa8e45b69c04fbbc8951e59805a198533c39144ec1fab3c7ccaf622f6"
