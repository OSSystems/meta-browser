# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3e68d908367db22ee8a6498374d4201b"
SRC_URI[sha256sum] = "bfb381da1058c809828db2c40541cfe3f2679ce25a3d19c74d7b55a197da664e"
