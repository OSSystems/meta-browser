# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "61a5f2356db07fea84f6bbaf2f7df2c4"
SRC_URI[sha256sum] = "4fd650de965f00a4231de1e62320b78706767f984da0e1948df130ca490b85bf"
