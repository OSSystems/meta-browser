# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d0249d5b48f5d298de3774436c981cd5"
SRC_URI[sha256sum] = "25b62054ce04ae6cee11734423fb19f2c87b95ff5214d40f8c05058ddf5879ac"
