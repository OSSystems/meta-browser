# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1e6c6012f18fbdef6374951931fe8352"
SRC_URI[sha256sum] = "b99afa0020d7ba8b00e2a8d0b8753641d1cebba04e97e3e97791dcefa8e50149"
