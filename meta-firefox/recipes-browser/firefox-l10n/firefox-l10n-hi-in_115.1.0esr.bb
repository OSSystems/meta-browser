# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "11ee78486e08cfe6ce116e35a912981c"
SRC_URI[sha256sum] = "55f14924712ca7ce599fd53ff12464d3c3d1b2a2a0195b6d47276596ea29a76a"
