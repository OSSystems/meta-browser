# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f8edf828691162dbb3820c4dfd87f4e8"
SRC_URI[sha256sum] = "b631450101e7c1e817e2af5fc77afe47e2290b332f9e8f8f5fae0abd47cbc415"
