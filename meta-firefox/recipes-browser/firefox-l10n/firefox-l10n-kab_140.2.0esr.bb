# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2c4bc6a6c285a533c540d529d292129a"
SRC_URI[sha256sum] = "d998008e193f691cdadfc888d195535aa22d5d659ffaa5af412c4e97bd1ae41b"
