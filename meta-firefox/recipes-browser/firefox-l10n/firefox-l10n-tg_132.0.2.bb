# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a8bb15d96b6d6c7cd478a5423e7660c7"
SRC_URI[sha256sum] = "810f693eff78a9e15b8e006c2be675a3ce0aa457746d7e691e27a1eb22706d31"
