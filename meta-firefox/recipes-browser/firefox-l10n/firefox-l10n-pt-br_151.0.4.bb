# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "76b72463b296c3eecc74f5c497701bf43cab39e5542849f51125912649df2389"
