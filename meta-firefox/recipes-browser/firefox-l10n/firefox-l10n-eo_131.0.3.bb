# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2a2832c7b9b95e8295636f43b1547d87"
SRC_URI[sha256sum] = "673ee41542786176865e187d51d47576665444392e6709a370fd2adf8665ccfc"
