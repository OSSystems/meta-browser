# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "27a4d5210834cec18c6fbf24c77cde17"
SRC_URI[sha256sum] = "be21cdae3f1b7c4d8ffcee1d6086230126dc2dc23798d8502888934af7fcf196"
