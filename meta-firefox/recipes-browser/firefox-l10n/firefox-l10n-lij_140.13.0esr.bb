# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "714814d06fa27596f85e405b1a03c1225bfb440533c90ce5194f414d696f030a"
