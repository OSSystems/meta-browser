# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ecaf5062506087549c2d4187b73ebf1d"
SRC_URI[sha256sum] = "3baacddb982702a83727ebc654fd7d41889e4eea1b1d38c0e67c1441f4e6ae74"
