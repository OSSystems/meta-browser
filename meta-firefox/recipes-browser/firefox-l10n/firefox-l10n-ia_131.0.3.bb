# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3c0fe7dfd64f88f1c3b7f805b90ba6f6"
SRC_URI[sha256sum] = "4e69064313a7bfc7e508e89ecb6638b76732036c4d631620d23a29c205d49a7f"
