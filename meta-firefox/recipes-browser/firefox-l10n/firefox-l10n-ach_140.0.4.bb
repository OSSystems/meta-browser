# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9aaf9b0d33ed7cfd8cb7cc1c5078b290"
SRC_URI[sha256sum] = "cc8dd7083466b7da427ee28e221ca7ddfc9cf3021f09a9486779e076130d63da"
