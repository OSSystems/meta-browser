# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dbff12d74c49efdb22a280db90469f3d"
SRC_URI[sha256sum] = "3abc30a33e170fb46cd27e4d1538587e13715d2a7bb424d00fe7cdbe866ff402"
