# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "95917ac9ee1bb5233f6f7faf3c6dfd7b"
SRC_URI[sha256sum] = "29b2d7a1e5fb55b9a8088e360ba484fb9b530007e1beb4d55db104873ff3667c"
