# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5b31df8a18a4ebc7af9b072f406085bb"
SRC_URI[sha256sum] = "bd10d5f5d7fad4d2696ec464c484e2ab7411ba187cbaccf15ac387b7205f5a3d"
