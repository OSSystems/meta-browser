# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fba4e1d9fe118ba140126cb7d76d2bd9"
SRC_URI[sha256sum] = "9305e3cd195331ddbabcd5b810e0531dda9f55a26ef69e543734ea209380fca2"
