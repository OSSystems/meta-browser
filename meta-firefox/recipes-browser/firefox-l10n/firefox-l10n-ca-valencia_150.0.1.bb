# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "be9b7035291b53fd82a03f29cf4c704c8eb84ebb1030bf91ca29fcb63b679957"
