# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ed114b9e1693ba305a2fbe03f34a38eb"
SRC_URI[sha256sum] = "219e182de9643da88db5455971e3abaa75cc252210af4d41c35b9cd3394b7ec9"
