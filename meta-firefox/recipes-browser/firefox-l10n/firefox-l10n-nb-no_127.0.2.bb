# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1714576c27997c8247d8ad62c97e2542"
SRC_URI[sha256sum] = "3e4fe9e58d7ee82a85a1f256a1f908eadd10d7ce2f6379710ac171ed0e64cff3"
