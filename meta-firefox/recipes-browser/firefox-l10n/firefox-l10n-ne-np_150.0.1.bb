# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "acbb79426c12667e306150d7fad8806f4c1f994df363269a7674820aafae9482"
