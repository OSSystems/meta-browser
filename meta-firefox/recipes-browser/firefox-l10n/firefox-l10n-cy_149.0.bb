# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ca47476ba18224819f314350a321d116"
SRC_URI[sha256sum] = "e1480741f7c7b140beb5e7a62b689cc76077846d1d3838f77898af86848f9e09"
