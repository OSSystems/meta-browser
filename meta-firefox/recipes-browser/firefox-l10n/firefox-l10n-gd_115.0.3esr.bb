# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a84ba9cd9ce589f7899e888876c81cbf"
SRC_URI[sha256sum] = "6ad07f53a44a9b0ae91bb50213f4b1bb991f0d9537666409916dff98ed4ca3bf"
