# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "26b8eee3f9ee9ff14c0e25b7d9f331ad"
SRC_URI[sha256sum] = "c3dcd7d8f248a6a9b1ce60c904d1c7a5fb4355c3e23be93df46215642edf1d8d"
