# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e8b450dedade7e14218f28f7299ae8ea"
SRC_URI[sha256sum] = "58d0bd10ab0f51c12a8daa12c793df821a2d8bf9adb643a02c12f655b4730d67"
