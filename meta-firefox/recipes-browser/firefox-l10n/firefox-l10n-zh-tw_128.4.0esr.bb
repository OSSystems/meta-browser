# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3cd048d05d70ac6daca8fa5239cc76d5"
SRC_URI[sha256sum] = "84c41ad8aa9410bb3e5d93b97dab0166935d2d81a8dc85cdc63b8a51c2bbc731"
