# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d6b5328546fee7e11ec47845410025a8"
SRC_URI[sha256sum] = "25c3ec79d6406a62ba34fee8c24f2a1f3db3bcf37a31a519a7c2a3453de8d901"
