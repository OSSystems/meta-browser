# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "39bd0f797c78aa597973baea0fa7a4f3"
SRC_URI[sha256sum] = "897404d87f5d6268cb7317b47abefea0f8d7ef2da190694ff1cd91a009589924"
