# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "cc50664751ea21833ffc26407e544eeb22037855f1e925b18c66e8fce7cc604f"
