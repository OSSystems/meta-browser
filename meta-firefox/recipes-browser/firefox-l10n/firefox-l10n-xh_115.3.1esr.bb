# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4e7d351007f603adeaed58e9eb516c7c"
SRC_URI[sha256sum] = "1c62125fdd2cdec48c5014df0c4f099e2efcc6f9018be8597f6025434698996e"
