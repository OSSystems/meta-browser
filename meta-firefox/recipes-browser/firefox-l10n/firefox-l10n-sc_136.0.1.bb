# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a15ff1da9d507f9fc8a2128c42120e7c"
SRC_URI[sha256sum] = "8126b507674ae5be5c3e272349165317ec31ed8c444cec2487bb2fc7516f73f1"
