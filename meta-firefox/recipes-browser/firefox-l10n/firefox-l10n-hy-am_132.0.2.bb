# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "841fce5f384104bb6782c72dd0376dfe"
SRC_URI[sha256sum] = "1cb43088254df1a7ae32cef160fa1c9fefc908fb2de17a57eefc60ae2cab65ca"
