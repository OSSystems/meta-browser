# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "73713dde47b62abbceb8ca5b36029eee"
SRC_URI[sha256sum] = "73a7f78d467078c355d1d4e7b53fe1d6479312ffe6057e2ba3a859d3f87d5a30"
