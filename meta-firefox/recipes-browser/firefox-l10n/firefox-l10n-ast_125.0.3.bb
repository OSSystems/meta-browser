# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "997c5dc3570fc301b287d4fbcfbe3f75"
SRC_URI[sha256sum] = "f72ce30224f238ea3a3252102409eec8464f860dd6b9a10dd0ac6b1e397aebc9"
