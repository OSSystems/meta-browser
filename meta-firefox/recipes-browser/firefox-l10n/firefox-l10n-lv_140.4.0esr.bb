# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ce07f7a23c249b585a833f63bd74cde"
SRC_URI[sha256sum] = "9f9bd079abbd15256b6ab5b035c3e852f230a5e822a1aa1117d414afda58d7a7"
