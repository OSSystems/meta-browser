# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "48cb6b0425c70d462bef6acbf4c45bd4"
SRC_URI[sha256sum] = "bc62495b7d1a634fd7a40ce4c23ff06cb8a2f96e973e4c4fbba8a4c805c73bd0"
