# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3c7a4747a1c684e5a336bbb8c2409db0"
SRC_URI[sha256sum] = "bc727f77ebd97676cb4c453ebd327475db52d1c9c01fe0b25a3442d31b918fd5"
