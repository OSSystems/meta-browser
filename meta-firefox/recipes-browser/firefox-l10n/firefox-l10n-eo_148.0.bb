# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "34be16f251f40abd941a691f7b6f4345"
SRC_URI[sha256sum] = "6b85e63bbf2dcb9969194d5ab1ca828017376f75d3f5e1e62ca791af057d0fc8"
