# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b205371f6e8e8d10d3ee8dcfc4906716"
SRC_URI[sha256sum] = "351284cb7e105a1bb5f4372e47a375834da8778afa16e4a89403c3cb297a2e7a"
