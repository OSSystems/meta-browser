# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e880b6e993c52a87f2ded76658d3f034"
SRC_URI[sha256sum] = "4a84783e6d1ddad3ff0a3ed85a5ea0735d1eed4eec6908903e10672845790356"
