# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e0cb3ded61b60d2ba21f9a6e38761c215bc498f28b84d20d6264a008051d305e"
