# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "861511b3e405cc0e9e2858db5171185b"
SRC_URI[sha256sum] = "355c08717d67d0e1f3ec47582f309481362ba97a70f5b52b490c163bdec54c39"
