# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "69718299a9de46a60435e0145f7a002f"
SRC_URI[sha256sum] = "b5962cf7caf5a893bd8c6ec622ca5000327fbfaebb1177fa9e3f3f7bf6092bfd"
