# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "84a05a4a0b664c0543f9e205a005d0fa"
SRC_URI[sha256sum] = "57f1aa84f82e5f726923cd79b159624e9ccda9fd7d9e6bb6b94f43a7706c6fb6"
