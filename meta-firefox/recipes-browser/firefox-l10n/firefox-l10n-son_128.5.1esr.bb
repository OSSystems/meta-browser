# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ca2b0cd4a50d0e05fcde640e07f7adff"
SRC_URI[sha256sum] = "fff2643fdf6eb7b2980ad2de8ec91379c5ca626a2e901911d8eea98bb7fb1dbb"
