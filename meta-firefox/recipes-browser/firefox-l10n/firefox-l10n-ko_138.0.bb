# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9a4c189e85eef881fc7d7f1eeadcb835"
SRC_URI[sha256sum] = "52508bb53a6a79f9602df0ebb21a2937d81213eec4e0b65c7fc9cbe120125cf1"
