# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7b92a1116973a89e5ce1639e974d535e"
SRC_URI[sha256sum] = "7c4e6100a739525edc4826bbe1727db78b7acc567dce19527b4af121f2cefe7c"
