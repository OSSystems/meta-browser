# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "582b7582b72d424cfc140715f297a344"
SRC_URI[sha256sum] = "980c74b8f91045e696c8da38307a8a92f2f6be1d55c2e55a3e35241be2c6ecf6"
