# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "71fa65bc00edcf96a9122583679ade1f"
SRC_URI[sha256sum] = "20cf115b85d124368d91c57db009531a264ed2bd87f46be9396303c6e683782a"
