# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0873294b42e585f37e68c7ad467f9417"
SRC_URI[sha256sum] = "0b4a0c2a1937bbae4cdff0069b4373d7504322f21cce1f351e75cff3ddc25177"
