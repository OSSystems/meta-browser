# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d5e9937791fd0b1e13911668e4577937"
SRC_URI[sha256sum] = "6bf4e959be0c8bec0acdfb5d2154fe4118066f726d93719ef4094977dbc428e8"
