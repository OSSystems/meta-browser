# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "08a8b51d254c56b633e6e8cdc8f6e477"
SRC_URI[sha256sum] = "4c3bc27b8b6ae58cd75346560f566dbba3eb1442d226e5e27776a4b04b55c0d9"
