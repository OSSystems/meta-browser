# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "28ef03f42302fab2375c749417dbb595"
SRC_URI[sha256sum] = "e4c8ebf8d97de71da7658f84fbb6652557cd8d349843dae2df0d19fbfc92c067"
