# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ea2fdabed89c3b6ea5d15f1b87944757"
SRC_URI[sha256sum] = "b015a71467881cb995fa9acb68ef6c46c1d142abb8624e21a55426c158bb1726"
