# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "60ff8c504b839729d2d8ec3bb4a2f607"
SRC_URI[sha256sum] = "7e9c10ae36a692c0285e23147cf9b177e697ee35c5bd74475d18ae945ab8fd91"
