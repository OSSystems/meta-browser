# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d8481f45d28d72847590a93a4c4589ee"
SRC_URI[sha256sum] = "7b486d7ad1a10f1ed306da3330a3f6ca67650294069cca17d9266f552851b30a"
