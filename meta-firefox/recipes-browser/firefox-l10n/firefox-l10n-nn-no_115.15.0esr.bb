# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dca5c753a54b736e4fae9bb3cbe32722"
SRC_URI[sha256sum] = "b9be0c4563ede26418f450761b486f316faeaf6c4ff30d8e3abb57373d10fbd3"
