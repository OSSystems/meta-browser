# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "752f8eb201c4d1bdbb6aea8b6138bbcf"
SRC_URI[sha256sum] = "096701d3c4846b812192d2967e98155e08443f72b01c285369dcf18f95151b18"
