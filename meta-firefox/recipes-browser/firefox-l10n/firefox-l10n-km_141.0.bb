# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "63c62f2434c0ee2d6cb11c6cb494885d"
SRC_URI[sha256sum] = "f1059302a52a5ceb6389f184da83e76d03d219e8cd8f4daef8f1d75125dfed8d"
