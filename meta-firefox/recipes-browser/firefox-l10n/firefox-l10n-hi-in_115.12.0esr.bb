# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d2264cc36217547ed303264ac2958d59"
SRC_URI[sha256sum] = "8051c7cee5e0081f2d156bb4c2ce158cf6bf4e3c82bf38a10cc27d3eafdb5788"
