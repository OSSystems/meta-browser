# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c1d95d903d053d166c90fc778a21dc1f"
SRC_URI[sha256sum] = "953d731fcbf6e4731cfe7000c446729c7199ce6d39e2b428729cbe48646d437a"
