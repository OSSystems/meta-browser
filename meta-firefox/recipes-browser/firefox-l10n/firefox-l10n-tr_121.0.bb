# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "374d134874358a1a1963341e4fe2aa58"
SRC_URI[sha256sum] = "ec707a0c0a67af624c77f89f6cf703d223cfb0bf650310e6709f9be4448f744e"
