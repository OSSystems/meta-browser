# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3aaa1b80e753993b6929fa421bab2473961c01dfe9b7f5058729356710cbc113"
