# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "58d40833c53a6b44c94303d4ae7a3fd5"
SRC_URI[sha256sum] = "283b01e1804bf89347889bd50d2649a2b8c8f5cb46c9229ed78a6d36cf08da37"
