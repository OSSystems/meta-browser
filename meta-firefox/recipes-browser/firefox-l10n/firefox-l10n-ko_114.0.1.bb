# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "34ca1f32becd9c1d90e2a6b2e17d4c42"
SRC_URI[sha256sum] = "7a44ee22cb7dccdda7a85b379e041f9910889248fa09bd8eca5a67118ff2bf57"
