# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "da552e4eb690c791d781cf05f2921732"
SRC_URI[sha256sum] = "f5403b2017eadf7626b41596309de2ed2b217c3eefaf86be31ea2e584818ae63"
