# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7680ebe43e41138d6a5e63cb36ad659f"
SRC_URI[sha256sum] = "f5160100f83a9b6f38d22bafa17c1c12f14123673db65c9100e501d9c0ae02ce"
