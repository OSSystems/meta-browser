# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9602200790249afb580c917785a8a2be"
SRC_URI[sha256sum] = "760681bad16c556085c41be7a0cbc656ec5532b1a6944e0e40b27ec17eb4776f"
