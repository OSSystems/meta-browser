# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "83e5873011587d5ce66374b8ab5c6d30"
SRC_URI[sha256sum] = "2ceeeb9cdb1e848e77ae98c65c5d845552e57a72edefcfc2c79a0d45b425485d"
