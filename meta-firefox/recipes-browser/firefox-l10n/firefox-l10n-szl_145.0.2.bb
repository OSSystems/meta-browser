# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "29b99e06cd8d5a1e6f1de240923d7874"
SRC_URI[sha256sum] = "3cfb63248e3fa7553112496b30437f31e653fdcfb85986c858f125b3545a5fd3"
