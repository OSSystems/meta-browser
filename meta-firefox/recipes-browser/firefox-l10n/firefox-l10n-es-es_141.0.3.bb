# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "000ea039e5fff76cb5e76fd8eea36909"
SRC_URI[sha256sum] = "c80a120758f524dc013bb0703f97eda95040e4129ed6cc02fc45557e38f01b88"
