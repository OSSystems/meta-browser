# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3e3bd3024b26df52fc045739ced59e9e"
SRC_URI[sha256sum] = "ad8ff23f8e4d2684b5eba7a859a8dbce8b3d7d2c636133709e42b0507e3deeb9"
