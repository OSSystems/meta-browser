# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "65c6f025c4fce5b569621260d7a9408e"
SRC_URI[sha256sum] = "d20067f8e724d6e7a605f36f8f4593af8281515a1068b575a5e2b288a117fcca"
