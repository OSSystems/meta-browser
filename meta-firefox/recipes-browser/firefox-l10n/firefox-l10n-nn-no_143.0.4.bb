# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ac90e911d52bddbfe83acd70f8e117e0"
SRC_URI[sha256sum] = "dd7540186411e9c7b0d286cba3eecd9497f2c9eedee65d171b2ad70698f79378"
