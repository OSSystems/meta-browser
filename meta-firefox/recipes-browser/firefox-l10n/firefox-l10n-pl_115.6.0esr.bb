# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0efec0b6028a68b96ea1b0ee70922bdb"
SRC_URI[sha256sum] = "1c9edf44043d69ac6ffc0d0fefae4665cbf782ba1aa5147a1a4fe518b17cf2c5"
