# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "54091144657e7c9f3b20953c30b9c9a4"
SRC_URI[sha256sum] = "ca1f1025d4527afc5de5f34320bd0cd55f6b64425efb711290aa6d078092a616"
