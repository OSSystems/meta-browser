# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "891cdcbbb858300f86b48a843191a722"
SRC_URI[sha256sum] = "7005bdc79f18cd6688a6906b045931fc7d7ebac83c4251453c351e26f73db109"
