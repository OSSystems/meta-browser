# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "329ee824e26ae32e2be169a227f3b258"
SRC_URI[sha256sum] = "4915bbab1f725692b8089c347cddba1c5a614a9a3ba1dbd3570b9adf2483eaa7"
