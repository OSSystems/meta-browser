# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c8847a18e13b0902f34c33d60511765c"
SRC_URI[sha256sum] = "f918456bb3e63edb2d67692fad9d3bd7132413591e2d015e7cfb00d3ee6f2925"
