# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1614b993d15a73a193c14ee09b5c924e"
SRC_URI[sha256sum] = "81e9fe74a27bb720ba4393daa4efdff0fc421599b59a58bec5144deb66f051ae"
