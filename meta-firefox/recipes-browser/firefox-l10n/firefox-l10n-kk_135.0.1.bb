# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "912de62fa4074e97373fbe7e26c83774"
SRC_URI[sha256sum] = "0ed1474492c35ca681a9ee49bf8f29223e78ce06ae36b4723117fbc9463fa73b"
