# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "73de331ccaba9b96deefac7752930058"
SRC_URI[sha256sum] = "56b62c77d3cc5a161c0128c209a8c9d166ed5c9cd6943d5feadf5d7c5cb4b25d"
