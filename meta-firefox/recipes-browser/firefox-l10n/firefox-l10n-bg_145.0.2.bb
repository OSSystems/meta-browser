# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b364b7613ea9de93a7a2b536284ba293"
SRC_URI[sha256sum] = "ce7776af294fe30cde63ce7a848ee0faa623698f77d32b4e12052e4d7fdc10e0"
