# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3d0781438c6ca7ba953353a5cf9dd95dc75a61d30bc308b9de1b56df1a787145"
