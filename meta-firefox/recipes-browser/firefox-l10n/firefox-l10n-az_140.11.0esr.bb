# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "88725ee6f1a3eaba38efc01c166e3845740e039212755df5ceb19de2326db4b6"
