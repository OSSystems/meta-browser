# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2f1fd0ec06adfa9a0b30ba2437413e12"
SRC_URI[sha256sum] = "231dfb98631eb53d16e70590453cc0a56b3207b35ed21e4c37160620e6ec6887"
