# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c1b5b5eccf07d08bb837372e1dd8ac99"
SRC_URI[sha256sum] = "c369c6462e5add5ccb9ab84e14408b770e90f79b3eba0ca5aae2d46e94c9239c"
