# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9fefc744d814126405bccc543440115b"
SRC_URI[sha256sum] = "3a06e2c667bccd9ccb8f3d98b6178cf50d8b40002925963c5136212c68406366"
