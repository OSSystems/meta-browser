# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e11c536f4b84d8786964e2533a005cb4"
SRC_URI[sha256sum] = "cfc5bfabb4928adaf57895dde07bb3b3c26cd486b096c4c93223169342597fc8"
