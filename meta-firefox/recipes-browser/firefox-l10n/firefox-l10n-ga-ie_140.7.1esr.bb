# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "70e4c28494ce8896796652f10cc92716"
SRC_URI[sha256sum] = "d2b3c4a1c5b80561ee5200aabd9f7063965218b2a3965e1da1748baeca386434"
