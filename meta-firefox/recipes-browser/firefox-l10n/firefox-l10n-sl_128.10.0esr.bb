# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a89a937a6ec61d428f244edb7f7f7085"
SRC_URI[sha256sum] = "9250ab31dcfa310a2191ee44611e381deb8ef2ac5dd312e4133ac2782299524d"
