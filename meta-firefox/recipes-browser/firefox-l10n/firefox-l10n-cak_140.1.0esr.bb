# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0272a42229a4b14e0435dec52f68752e"
SRC_URI[sha256sum] = "4ba03be159f9ed5d785364587bb668e7acd790b0f04bb4a036474330f78a3aa7"
