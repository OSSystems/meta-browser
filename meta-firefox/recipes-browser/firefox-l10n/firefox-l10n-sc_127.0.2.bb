# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f4566d1f72bda3eb5e780aed70a25f85"
SRC_URI[sha256sum] = "ada12ddf6eee991f7240f399575df7274e5189c8c56fc00666dbb7dc2d3a99a0"
