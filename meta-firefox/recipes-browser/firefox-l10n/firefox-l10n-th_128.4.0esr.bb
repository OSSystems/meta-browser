# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a41694d89fb5555befcac3cbc6d8f022"
SRC_URI[sha256sum] = "005b8e65a5c3011769ca60cc2bc70dd9f9eefc2cb48e1a5579b403cdabc5f034"
