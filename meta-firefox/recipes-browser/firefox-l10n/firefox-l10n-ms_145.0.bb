# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6ac65a3cca520e7436ce5e4d90e29b2b"
SRC_URI[sha256sum] = "a1536549bdef66e20d41f5c52f186330096569cb5068f7b73e92d39e2f370cdd"
