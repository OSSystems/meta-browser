# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "67a43d8fbbb2f6e3ff8880dad08cdd3e"
SRC_URI[sha256sum] = "1ee4ee6ca20b9e10184b9ff75bd37f4af1fcb45ebb05ba65059c69ca46b9719e"
