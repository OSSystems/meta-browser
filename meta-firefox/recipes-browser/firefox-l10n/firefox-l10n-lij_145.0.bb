# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b391e5e927ea9591f634130bcf918b04"
SRC_URI[sha256sum] = "427bd0244b16791cb2414fe31a9cce7f7521f601befd14f5b1c82e18c943cc81"
