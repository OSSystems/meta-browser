# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "78ea2f39bcc99f82e64f3c58585bb48a"
SRC_URI[sha256sum] = "86553ce99fcd135cbc309b51e13fb12b10c0579c55ac6de8b7d852278a885fd9"
