# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ce406d9cde0b608d11af7d2472242512"
SRC_URI[sha256sum] = "45969cee1fa8f5eab66029a9a72e2329a25cb9284aec385ceac38c8a171bc068"
