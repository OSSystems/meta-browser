# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dc3c55e6b6ebda8ed04a29d450ced7ef"
SRC_URI[sha256sum] = "3df3c3fbd674447d122c47fc53997c110dfff3c5064d39f896ec3a7be5d063f2"
