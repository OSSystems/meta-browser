# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c044cd4ab8f0578c074665ced1418196"
SRC_URI[sha256sum] = "0ea3ffde9ef7e2967f576f807c48ed42d2fb6126a4be7913ff5d3bb819bdb1c5"
