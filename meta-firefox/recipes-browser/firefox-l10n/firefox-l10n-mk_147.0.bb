# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5ea2b6f2f09e12b5d6238a2650d49a8a"
SRC_URI[sha256sum] = "dc1309cab5d725f7e11204db13742d9ec879b29139e56b2f27d4ed3f537e4ef8"
