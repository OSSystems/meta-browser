# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c412b9263de6f2619bca1aab28b1eed6"
SRC_URI[sha256sum] = "4de9dbd88dc86c02dd61733f21f6807056731ef26e4e415fde40eec41a4efa98"
