# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "03575ace56bb91ede66d373f489bd8bd"
SRC_URI[sha256sum] = "9fd2634626ac2eb0cd2a933fa2e601c8e327d733a1012e6e6b8b194323d7d3d3"
