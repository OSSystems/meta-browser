# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "705dd91dbc15acc9f70a6e243e9e8897"
SRC_URI[sha256sum] = "623c979f804083d209dc9bfb3e937d4625f57518d1be9a2c3245674492a698b9"
