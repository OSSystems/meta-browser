# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "64e94a2cc83e361daf5224a71004b50c"
SRC_URI[sha256sum] = "506895fc051e34aff6ff383350e77ff233e51e77ca3c98c9844372b7f65022fa"
