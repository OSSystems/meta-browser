# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6374553eb478e8c84949eafdc83570b2"
SRC_URI[sha256sum] = "5878f6c59cbb4b1b777162209f622c75025d4eb926c4bb9cbb9af4330f823790"
