# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "9e6ab4838f4143d238a10571fcfe7b033ee5e471359b8f62a68d055b6df0fbb5"
