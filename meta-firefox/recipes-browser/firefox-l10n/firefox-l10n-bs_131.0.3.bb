# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3ee68d2db688465ac470fcd08a7bf2af"
SRC_URI[sha256sum] = "e5a713024b21ce7dc147c0020cf90639a79dfd11bb7306d93e8a87deeb7c39d8"
