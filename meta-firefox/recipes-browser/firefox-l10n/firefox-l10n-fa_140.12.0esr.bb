# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "eea171ab0f1350c86e70b1375b1286dc6b64007571bef3512fa69aa4986fd5bb"
