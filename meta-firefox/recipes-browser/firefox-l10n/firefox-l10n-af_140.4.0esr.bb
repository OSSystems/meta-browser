# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e8b2f5817ac0a67ee9a2e9edfe40da05"
SRC_URI[sha256sum] = "d531fee4e0fe4be604b2166f650099bb9397215b8febfbcb848bb3ffd4097dd2"
