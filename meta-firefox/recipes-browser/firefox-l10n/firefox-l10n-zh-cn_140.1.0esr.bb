# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "594fdabeff5744048a3da9ace8e6861e"
SRC_URI[sha256sum] = "4729801e9809e2ca8620ed61c4ed1cb7a5f84f7e5358860a8f83d51c83f56214"
