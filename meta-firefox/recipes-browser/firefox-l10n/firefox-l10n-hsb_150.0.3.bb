# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "299e4efd166f5c89adcff1b11345a428de0f7cf70d4e5f8eaba4645ed98608d3"
