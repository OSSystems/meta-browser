# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "102bcb048c6ad49cdf229db67fdc5b95"
SRC_URI[sha256sum] = "ab23569b958f93f5b04e349218e79e9bc9b0a52eddf13cb7ddbc3fd3354901aa"
