# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3814514d6ebb2caa8cc43028a0d30a0a2fea4c6e950662228298d5b5bad66b16"
