# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "85ab64c4ca48263a67b3f56cb7782d68"
SRC_URI[sha256sum] = "17c4836825e7742f98ccaec23cb8620ab1c1dc92b172b190b3bcd28d064d9336"
