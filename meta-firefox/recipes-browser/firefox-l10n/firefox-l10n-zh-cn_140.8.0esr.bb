# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "46e3f6304d059c63687fcf41df12deed"
SRC_URI[sha256sum] = "9da41870b442a47298aeb08fec8632f56f5a486109c4801fd0fa639948889b00"
