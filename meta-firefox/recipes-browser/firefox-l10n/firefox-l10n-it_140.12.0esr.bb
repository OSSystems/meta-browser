# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "16badd7735885a773f848ef91820ad9f72860aee5004c1dc66663a7739afa49f"
