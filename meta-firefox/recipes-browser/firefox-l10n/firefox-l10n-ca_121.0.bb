# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bc7d4ccceeb064a07bb73760039be72e"
SRC_URI[sha256sum] = "7bdbaa3194155d6a347fc1825f2aa18d0f8a62aa5c9aa8394f52b10ba5889ba7"
