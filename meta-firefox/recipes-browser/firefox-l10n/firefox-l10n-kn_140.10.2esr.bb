# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "42721db4fb4b0749a753a9365f47335aa46f5ca83a76b0357686732acece0417"
