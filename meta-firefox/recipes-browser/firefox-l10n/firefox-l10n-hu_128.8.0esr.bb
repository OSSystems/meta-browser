# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e3b055d57faf841d4b479311f3c19445"
SRC_URI[sha256sum] = "ffca5ef15a225dc430012f94212f271448ecd2d6985b59462bddc67ceecbfc3c"
