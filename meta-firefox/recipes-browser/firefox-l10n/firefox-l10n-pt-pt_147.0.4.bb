# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b391fbb27323cdaedae718e5996364f7"
SRC_URI[sha256sum] = "626b02c1c90c728d866e51c3d927ee5dda8594e4961ac6c0534850de6e71b68e"
