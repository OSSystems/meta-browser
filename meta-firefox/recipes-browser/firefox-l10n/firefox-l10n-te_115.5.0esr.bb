# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "813a79256a0f00ce7f8cce44ecd62574"
SRC_URI[sha256sum] = "300df730d3c659d26a3be1e9ac01c79c2d1a40254156c789b0e1a3feee24b1b5"
