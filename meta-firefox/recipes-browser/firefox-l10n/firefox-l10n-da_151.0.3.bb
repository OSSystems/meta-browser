# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "eeb3456bedb8482401d73d925ba81281525b2cd32cea669e647bcc91a4e77e96"
