# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9d65dac4a795d490713495ee0c0adcf5"
SRC_URI[sha256sum] = "2e2d421d6144ff1883d1af533ce4d565f35f6e312e6faf0383f370450957a45c"
