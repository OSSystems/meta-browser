# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ca617f9e8dff70b51eb21c3f41a71228"
SRC_URI[sha256sum] = "75d37f0e57e0d26acbe6d0d57f21af30e2329a8c64e2b821dbbe94e9c2bfe6d8"
