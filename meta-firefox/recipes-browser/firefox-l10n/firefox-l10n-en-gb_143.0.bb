# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5328e4fc6f7a472a556d32b71fa8ab21"
SRC_URI[sha256sum] = "559def169379bbe977dbcefc3a14db3533980afbb8a56a8cb5d76fccfe7506f0"
