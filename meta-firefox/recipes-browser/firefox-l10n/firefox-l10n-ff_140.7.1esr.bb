# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "04ad602ad313253e1896139f1dbebdcf"
SRC_URI[sha256sum] = "8e19ac7e6fe2c216fd1f748b40c770cf20d4a0d8e6ddbbab9870b22058d00649"
