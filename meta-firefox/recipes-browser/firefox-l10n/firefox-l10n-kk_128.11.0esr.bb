# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8cb1b6c492d83ffea3543379c5a1d9c3"
SRC_URI[sha256sum] = "8e5db670e567e2f12f97b2b7061ad7f8799fb3cf80d3affd840c0d859974d92d"
