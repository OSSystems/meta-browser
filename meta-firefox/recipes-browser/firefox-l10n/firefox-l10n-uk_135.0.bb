# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "069ec69abc16423d813b404a4e6295c0"
SRC_URI[sha256sum] = "0493fcfb205cb4d00d8e4078597cbd2b41e188ee5809ae36f6d2d8f485459847"
