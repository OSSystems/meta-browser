# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0d8dc331f8fbcb6d52b6de12b417f456"
SRC_URI[sha256sum] = "1409621ea353cff9e6c4166c2f5286e2eeab515ba0f341d4c0971df4fa79c93e"
