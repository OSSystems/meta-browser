# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ba9c0c2bbacf94da5b8a5301213a405b"
SRC_URI[sha256sum] = "033f7dccdb58dabb882f42018a30008b38d6812b5936e21768dab47086ca62f3"
