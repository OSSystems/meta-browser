# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "829cfd78277660da6e1292e59983847032f6cf1ac0d1be409ec3a980ecc9a49e"
