# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b6a6eb8c53af2b664189f0f30ab3b4b6"
SRC_URI[sha256sum] = "5df4ffc460440e94e1d5b056416911fc4f193fd9dc1d9202ba0055fbde8d82c4"
