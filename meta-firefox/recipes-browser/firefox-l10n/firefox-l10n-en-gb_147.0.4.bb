# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "38be022b4437f8b8a851be6963585dfe"
SRC_URI[sha256sum] = "59bc3391e82031999f5a0d548cdb7e1a9daeb2fdc8e7a131b693cc0fe32a18a1"
