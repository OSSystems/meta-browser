# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e146cf0dd9d2519f9635eb16d6fe32a3"
SRC_URI[sha256sum] = "8f502821cae5048e49fbd0cc71a95e43f887838719dfc27dabd6939fbc0037d4"
