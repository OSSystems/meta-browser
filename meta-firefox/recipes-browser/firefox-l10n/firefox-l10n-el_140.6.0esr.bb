# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b28091e553c5c7bb76ca1b1405584918"
SRC_URI[sha256sum] = "e489c33d9df9f1184733a07daa7cea0ee1143dbdeb999336df2f811b4ffe3fe2"
