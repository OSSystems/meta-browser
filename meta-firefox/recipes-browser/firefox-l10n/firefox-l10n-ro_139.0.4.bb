# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "45da8454c1d7e92f285de20cc3d9037a"
SRC_URI[sha256sum] = "2df55825eff6a597fc0f1599f0f0f6e24faf9bc2d9cc0b33f6d70473f8ada92a"
