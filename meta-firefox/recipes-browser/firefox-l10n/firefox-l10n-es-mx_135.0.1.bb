# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bc438329d0bc258ee74bae99d1795ede"
SRC_URI[sha256sum] = "a7bb2f44f92383735a170d637d89033a607a2b70e6c01b40083be11c9af251d1"
