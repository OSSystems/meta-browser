# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "81ddf4f615ed6593ce27c23249f07ac5"
SRC_URI[sha256sum] = "d42fae708a88b88e15aeff09be5731e8fee15c77a00ebad491f644e776f6f1cc"
