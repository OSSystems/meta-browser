# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "692a3a9bfb5b72d414f6849274390d1a"
SRC_URI[sha256sum] = "0ed88700be4ec77e8a6ba8d5c31468f275a45e329b442d5e4b27074a10223e74"
