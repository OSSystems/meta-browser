# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "af80fd20467d83f8dcf5991ece7d3701"
SRC_URI[sha256sum] = "89049fc51e772f0902cdc85aa5c62f5cbe69313354c4b23e1a91cfcb3b7dae30"
