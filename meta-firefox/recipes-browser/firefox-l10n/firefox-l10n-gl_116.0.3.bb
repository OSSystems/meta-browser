# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e028187f27a2f8a6900bd01c842a810b"
SRC_URI[sha256sum] = "27e9cb2acd8ea31ef6cdf5f6994eca84d41b4ac3b229c1b02948e59ce026991f"
