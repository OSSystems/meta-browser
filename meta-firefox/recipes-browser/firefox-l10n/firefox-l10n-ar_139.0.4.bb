# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3519f2d08567746bc9077746f17355fd"
SRC_URI[sha256sum] = "8f60951cec0a30e1d4c352ca29da8a533619f3da0df13c40cea8319cfa36bef4"
