# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "03634fe2836b1cd77c01f95b8f5d12e4"
SRC_URI[sha256sum] = "820204abbf0b4e20da06b827437b3b3c3b5bf28f9d4054199ec00e86dc0de882"
