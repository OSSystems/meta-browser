# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e7b0bf1aa5ab786bacad65cababf20a1"
SRC_URI[sha256sum] = "14498d45f0d003e6a091f7266af1526eb8450788e33c73b0dcd80d4fd67acbfd"
