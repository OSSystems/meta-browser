# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e7b8eac0bb384d59e7b758a0c73cf61e"
SRC_URI[sha256sum] = "82d5231545e3145e848e4239229e81408708b033a40ab7a1334f134adb464ec4"
