# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7ac85578c8afc3a40377512d7e95c1fa"
SRC_URI[sha256sum] = "1693fcbec6a0e7b88eb5de310213e15e84c3fc5072a33428283d517d876cc3a9"
