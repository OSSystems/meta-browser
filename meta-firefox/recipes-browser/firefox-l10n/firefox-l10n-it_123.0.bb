# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b41f12a028b831f8bf18d9fcd126b7e1"
SRC_URI[sha256sum] = "a000cbc650ee84a862eb6de172c2e984e984ae7a457a1c5f5dd5ce63ced9805f"
