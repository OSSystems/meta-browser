# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2ee0c2f050af6a50f6d660340c4f1ab4"
SRC_URI[sha256sum] = "2003689e138ee9d6e33366ca586fa2a34b5ff1209ff3308e22b60634bfae33a2"
