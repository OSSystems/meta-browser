# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1e602745bf3c32b185df4014e247cb14"
SRC_URI[sha256sum] = "9fc423b5c7e8cc63fac2738f855b2602a377e7f115f8b6d0519d43ddeffe1c8b"
