# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7472bd79e1759a4e16e8b0ff201c6bce"
SRC_URI[sha256sum] = "e85b8557e54894b5c1c0b486898e1522b0253a09391eda81135926c1687929a5"
