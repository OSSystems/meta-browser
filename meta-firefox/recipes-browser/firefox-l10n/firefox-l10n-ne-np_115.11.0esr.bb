# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "17b03f4688f8b1d750a5382c7ebb6dc7"
SRC_URI[sha256sum] = "592f5874f7db993f877706c034e968062ec5121f24ec0b078744bd8a53eb4870"
