# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "82b2ed218386072ac857ff33922cb0d6"
SRC_URI[sha256sum] = "8b1cc2769c6f0489168c37578d2be16da0d913b5f4fc5804348cd5f1f8788374"
