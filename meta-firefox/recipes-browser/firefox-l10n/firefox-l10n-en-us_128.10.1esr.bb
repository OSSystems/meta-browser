# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6103f669929bc2ffd7f23dcbcd6789d4"
SRC_URI[sha256sum] = "9b13e5989e110d34c2dbd04396c416cdf42533cf17df1d545b6a4b6d37eea4fc"
