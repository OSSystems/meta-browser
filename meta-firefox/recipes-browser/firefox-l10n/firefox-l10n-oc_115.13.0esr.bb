# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5b4a65aab1c577c61315a1fbb8056d02"
SRC_URI[sha256sum] = "f07206695172b0a73191bee4da76f81a0da1f9b654ce30ce5cfc0c3a31aa1c60"
