# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "34f298ca4171bcba972d545894de7a4a8077058dbb9076c04886abc4741db383"
