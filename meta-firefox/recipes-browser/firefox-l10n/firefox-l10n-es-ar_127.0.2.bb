# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d7866b58c4ea3e62f91aae6ddca3081b"
SRC_URI[sha256sum] = "ddda6ddd5759e2f5cc71f0da48e8e433e5a4f267c43c9aba15db6e80f9786341"
