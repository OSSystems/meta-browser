# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4a3e37ef0d29f462390c6fc7297dacaf"
SRC_URI[sha256sum] = "e72f2e874fe935091bcabf6d63f2c5861d5e79a58c1e51b3385d42c37ba37bc4"
