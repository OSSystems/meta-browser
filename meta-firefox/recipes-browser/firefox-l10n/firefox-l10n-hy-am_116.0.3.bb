# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "217ae62c2d781a579f68391424b2c46d"
SRC_URI[sha256sum] = "593a2e9693da8a6a1531a5e322bd04f64c0314120dbba231b8c7f87e009b4952"
