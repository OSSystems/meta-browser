# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "315fc6dc872c27c8c547c5c49ef2d9b5fd3a9f55dbdf3a528de830a91e9d46c2"
