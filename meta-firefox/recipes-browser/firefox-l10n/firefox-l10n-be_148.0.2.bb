# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "287e9f35b28ca0cfa9ffaa0a49abbefc"
SRC_URI[sha256sum] = "7779caa4d65581ef92581c84a7f0e9c0e47b95feb4888a9745eba8cecb3bee81"
