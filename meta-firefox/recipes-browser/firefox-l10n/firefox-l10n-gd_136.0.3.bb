# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "636552f5caf0fb96d9033b0f372b6ece"
SRC_URI[sha256sum] = "26fee499b0c337f70954677e028d938ad5653663edb329b37939d0583448f8e4"
