# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db2ef8ad7030c0dbb7815493530d627e"
SRC_URI[sha256sum] = "1fe00efad30baba0a7cfa23f45364e65f9f8111691a943d730b824ce2db0d546"
