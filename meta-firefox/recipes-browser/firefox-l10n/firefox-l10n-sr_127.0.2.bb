# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "df0d29d75968ed2d7349c0ab2f0780ea"
SRC_URI[sha256sum] = "0c2b77a3f222c53c8b7c60ae97ce7cdac834c964e9c998d3fa675c7dde225174"
