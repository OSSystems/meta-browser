# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d78f6820cb21a164f4b898feaa6e72a6"
SRC_URI[sha256sum] = "b532b5c690e5326ff3383457cca77d0ddaec6f26dc97c9b811a3fc047d7b8a74"
