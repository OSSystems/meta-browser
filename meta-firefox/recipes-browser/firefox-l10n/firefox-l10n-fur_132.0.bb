# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "547b02db7a8c8711421b3ff5c867de84"
SRC_URI[sha256sum] = "ca27bcc00b3305dbb89c3f8c90ca27188c00bf75629a3e34d29275c25f59aa84"
