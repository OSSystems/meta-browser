# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8c52d0b4c2bca93dc85c36bc58d2cae9"
SRC_URI[sha256sum] = "48494144402b951ef356a03a55860186b83f104edf3aad8649ef4bbcb460289d"
