# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "31d508c5ee40405e3f397090b859e767"
SRC_URI[sha256sum] = "b7184fe1a18e3e229eb9795807e53e9b8b411a8b2c085e2c0ea1b42c11a8cbbe"
