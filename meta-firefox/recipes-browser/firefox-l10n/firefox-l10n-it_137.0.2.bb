# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8623b14e40b999a7480f8956df6848f9"
SRC_URI[sha256sum] = "9a0357aa0a29acfef1f5165d279ceb0aa770815dd42396d1f30c25b90710e368"
