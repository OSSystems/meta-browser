# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "97cf27ec54cd3dc5522f00275f96d080"
SRC_URI[sha256sum] = "bd3fe94f38cf4b954a0b912bee6ceabe76a484dcffd3a7e3aeba15c511aae62b"
