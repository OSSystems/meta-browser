# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9d35557c56d19d4588895bfa5aabaf5e"
SRC_URI[sha256sum] = "f9cbe172ce9941f2cd908d6c3e348471e9b04ae8a3012ebb0d034849b4f295c3"
