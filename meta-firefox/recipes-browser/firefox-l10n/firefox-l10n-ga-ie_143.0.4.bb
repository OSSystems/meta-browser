# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3f2b110ac4dbc13241d0d08c6fe625a6"
SRC_URI[sha256sum] = "c39f8c2ec37b48a90d8231329e2728e239e094d882f16c0bb2e0a8fdf862f7c1"
