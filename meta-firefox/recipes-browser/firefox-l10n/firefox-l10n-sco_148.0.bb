# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7482fed868ad2c4dd9c83bdc1302b4da"
SRC_URI[sha256sum] = "88c5be92e2a5021a2c102d1c2e3799f2c026aee86c766980ff485caeb6f7d88d"
