# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ecf20fc2dab118c3bb6381fe6c7c7bcc"
SRC_URI[sha256sum] = "2befc1bed96ac39efe7a2807de6c5319634f6f3fcac39e9335bc92ffc5b76fda"
