# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db6d8371d3e3e141a2bff41e5017813a"
SRC_URI[sha256sum] = "3ee4c56747a7bb5a6e86b1f55a18c9f4c36d5c0482fe88849b3be4b4fbd6b371"
