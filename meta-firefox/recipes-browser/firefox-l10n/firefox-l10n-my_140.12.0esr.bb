# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "9afa60a48ba0bcd2b33615cb4ed8de4541a25f16f12b67e9be85d97ca286989c"
