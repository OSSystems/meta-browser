# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "153ff97fc847a8a17260ab69d90ef69906c448727033cd64675915c23625f8f1"
