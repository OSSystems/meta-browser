# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f29157e4bb197bb1a1bef77a798acb2f"
SRC_URI[sha256sum] = "603f9b08cd6f970881e0d6e7d026c4a72588ecddd905a2c0138e49239efbb489"
