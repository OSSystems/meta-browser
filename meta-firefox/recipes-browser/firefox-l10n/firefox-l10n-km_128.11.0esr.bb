# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b5d2906ed5d5de77a4e2db51b95dd54d"
SRC_URI[sha256sum] = "a3a60ee4b6d109ee7eed5d3970113f479e506fd5e90150524004928c2d9db342"
