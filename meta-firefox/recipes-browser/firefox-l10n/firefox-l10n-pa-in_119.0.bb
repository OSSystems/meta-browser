# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "542142c78d60471ef666dd81ea1c4830"
SRC_URI[sha256sum] = "c5f107207a4f57413a325eb5e87f072d4377fe7fabe3a938f29d2c4effe5712a"
