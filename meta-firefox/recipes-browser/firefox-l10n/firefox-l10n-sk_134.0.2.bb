# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "60b2368c4bfa49faf987712627cd7155"
SRC_URI[sha256sum] = "aa6c2af25848bab99af46a6ee48ff9b0f2859fc9157f50f54b4a7f5829509ee6"
