# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "f2c6f7e08d6aef2be8f825aba101c375c1e9d0fd90da6fb18ab1121efa9a6f36"
