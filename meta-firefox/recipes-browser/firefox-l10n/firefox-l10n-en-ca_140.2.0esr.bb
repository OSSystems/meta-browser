# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7fb45858d72534b8ec52c0f22f2f1afe"
SRC_URI[sha256sum] = "fe297d1e470aff49520053b60f07f43f20c15e1a82c5db954f347a417c078a0a"
