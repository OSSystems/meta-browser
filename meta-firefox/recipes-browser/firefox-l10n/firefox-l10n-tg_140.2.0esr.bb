# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "176a507efa353ac2b144e6350215ba81"
SRC_URI[sha256sum] = "63657ef1d6afc64c2a15ef23343f38c653a2e64f0a579c0575a755e68b3db1db"
