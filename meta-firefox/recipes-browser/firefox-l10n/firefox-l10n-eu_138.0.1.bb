# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "27c9c7e2643c5f7b12ac23488db60c21"
SRC_URI[sha256sum] = "607ebffceaafa82b86dc2ceb7b1d88de38b06f37ed63f19ae8ec96acffb5bd2f"
