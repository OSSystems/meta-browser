# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ef04f6dc4deadf3d835182310422c26"
SRC_URI[sha256sum] = "a53777dddb86aa68416f04e37baf5e946a1a25bcc41696487cffbd36520f5c5e"
