# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5e03f296f05443509e3936e054c6fde0"
SRC_URI[sha256sum] = "61687c55188bff9e84e14ff19af2b211b540bd402dd0561355775f1c2c2b405d"
