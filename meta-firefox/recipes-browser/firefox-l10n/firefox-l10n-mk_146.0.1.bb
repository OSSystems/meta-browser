# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d71eb7e23a64a346713c7360dc5d0bc1"
SRC_URI[sha256sum] = "8b02492c54fd6e12baa3d76f80e21d9dc9de18dbe4e74fb81610d0b131c4418e"
