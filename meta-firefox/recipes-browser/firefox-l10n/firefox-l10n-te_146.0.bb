# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "19672229a01b5ea43d2f3f84aa987367"
SRC_URI[sha256sum] = "ca8e4d7abf80e357d7a96419a7b742aa27e120b6b0504355a50b007de1b5494b"
