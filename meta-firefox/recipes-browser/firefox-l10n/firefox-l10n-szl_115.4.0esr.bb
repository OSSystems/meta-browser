# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8dd18e7ee9c014a5b2a5b6c4c8ac3367"
SRC_URI[sha256sum] = "e7bdccc460bf5c36570cb67cf90ea0469176ee3367616eb88c538480fe3d0544"
