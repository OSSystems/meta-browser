# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "107318beef60d80879f0169e5289d46b"
SRC_URI[sha256sum] = "d70c9b53e5d8e68e17df3432eecc75bddbd09f3f852b570748fad68404bd587f"
