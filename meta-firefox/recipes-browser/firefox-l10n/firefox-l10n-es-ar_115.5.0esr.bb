# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0460d647b800c469ad95711360da2a2f"
SRC_URI[sha256sum] = "7dfb7376b787b7644d18a805fe79fd704ac5ba8b5175b8a8a199b8a1deac068e"
