# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "48a9f25264101111291f64d57d37b1c8"
SRC_URI[sha256sum] = "5a119945c3e78bc9efc66e0a0a206ed12878d0722bca80cf18194a8836498bff"
