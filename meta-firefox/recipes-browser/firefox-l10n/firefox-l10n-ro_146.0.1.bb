# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "19875833b0b5697a9730e6f3d6e55dfe"
SRC_URI[sha256sum] = "cda0b189e91851b474acf1a03d38674dab06a84122978f3be8b9cf9f72460773"
