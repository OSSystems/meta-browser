# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f7ced703b5ddcfc522c582232057e606"
SRC_URI[sha256sum] = "79d16fccf519031891c5a4b598fcff32d73a20f83b849cadd15b538d260b1b18"
