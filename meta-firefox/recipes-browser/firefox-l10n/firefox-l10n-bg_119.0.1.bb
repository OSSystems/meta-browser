# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ec57ef200b5899dbde288c21bb566406"
SRC_URI[sha256sum] = "10812c1edf1b4b85b7718cbd96f20fdf950c52b7d95a599dc83150d2b288b671"
