# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "97986128941a7938b81a09f8a97323ca97e15f3277096c3e0ccd1409cb74845d"
