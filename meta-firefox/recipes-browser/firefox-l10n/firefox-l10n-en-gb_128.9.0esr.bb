# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b63f88b1111d0b9fe5affa08361aced8"
SRC_URI[sha256sum] = "2507b47413b6f1396c88cdd1c358126ad59129837e004c95c5872673696bf67f"
