# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "49d5321cffaacb111e25e70019d85f75a5ba0087224a3e85cb57bc326d0ac37c"
