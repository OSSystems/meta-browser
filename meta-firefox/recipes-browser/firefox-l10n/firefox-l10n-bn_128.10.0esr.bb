# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "149e4f16bfbccc73794dfaec72deab01"
SRC_URI[sha256sum] = "3cfe7b249d956a83b2ad5e405722bc349ffc791979d636378c9810848ad1a51a"
