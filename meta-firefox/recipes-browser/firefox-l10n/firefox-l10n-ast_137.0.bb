# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7072730dad4e4bb622a8231e7812c12b"
SRC_URI[sha256sum] = "cea73ae89cf424c69ed536419fe067aad057c44649db80da51792aa0d9c88e43"
