# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "90b7b42df0df51b4212f44daf1144eb4"
SRC_URI[sha256sum] = "a5720fe7128b9e7ffa0602c95cc86853f5f1dfaa64b005522414c95f63f23c8f"
