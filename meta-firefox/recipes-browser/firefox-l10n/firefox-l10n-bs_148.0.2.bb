# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "19e1b8962369bff7572a54147120621b"
SRC_URI[sha256sum] = "27d44fc846c77a041bca91cfb011619fc5e6cf53069e7cb6c71f78e4f7c1eb0f"
