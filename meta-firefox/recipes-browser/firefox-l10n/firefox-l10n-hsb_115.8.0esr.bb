# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "750ece204b6f960aaac5a53e48e1f415"
SRC_URI[sha256sum] = "00cbefad3a6cd466f9940e77c24237daa5f4fe787723325560696b49c0136329"
