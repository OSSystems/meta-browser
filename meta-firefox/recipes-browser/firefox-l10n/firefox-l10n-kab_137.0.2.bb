# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dd99bb24dac4082851eaf767510606e5"
SRC_URI[sha256sum] = "e2701c24bf7a68342a94c800b7430e5d760ff0840aa6e42aa63ef0feaa108499"
