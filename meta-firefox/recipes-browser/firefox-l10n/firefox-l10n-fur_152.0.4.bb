# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "cb2a49c0ba175e2084693701493a306f310afbe0b5a1c7892261f6a40aec592a"
