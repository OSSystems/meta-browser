# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1484bb018a4b8b57221d250e41242943"
SRC_URI[sha256sum] = "2627cb96de810b1f2de07d6fc661d5cd49703d002b18a51b3d1d13b04f6837d8"
