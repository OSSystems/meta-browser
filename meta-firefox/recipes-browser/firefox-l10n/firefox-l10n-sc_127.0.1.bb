# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b27fc150003e840bcf88fb8e9d62e7b3"
SRC_URI[sha256sum] = "af942a50ea5e051e325c58a2e6a0562dd0ceb83998e09a99a1c05aafc57666a8"
