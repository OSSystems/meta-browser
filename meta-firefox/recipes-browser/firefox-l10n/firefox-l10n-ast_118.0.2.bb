# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3e220ccbe3b99df420b66a74493d44be"
SRC_URI[sha256sum] = "157c575fe5538b448fac8c0c8a37ea8381b4a5391643a72969bb5fe949cd833f"
