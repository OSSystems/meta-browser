# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4e11e94d319c19f09136cd53eda3be00"
SRC_URI[sha256sum] = "7e5cdd9bb99d38d1399eed3a4b8d09fe16a2760f64375b12d29868a87faeb0c1"
