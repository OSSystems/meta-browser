# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "38eccd56c47f0f8fab2b5ff4b34f9469"
SRC_URI[sha256sum] = "c8f64a024d757470d0afdadd84249442a820cefba95ec1874537e7fd4840c096"
