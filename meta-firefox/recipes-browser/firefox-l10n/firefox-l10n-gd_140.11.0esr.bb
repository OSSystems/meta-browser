# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d7a183588b63f9f467ea5abc2009caf1b6c981910b4629ab07b9cc711e1eb8d7"
