# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "090d25bfd277643f33c26e889131267b"
SRC_URI[sha256sum] = "61a356de7f5839144b9611e181ec95d9a8acc2d0657feb2d105fb39a63835728"
