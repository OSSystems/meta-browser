# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6cee7d2419e4879f0538de3d19e04377"
SRC_URI[sha256sum] = "3bc976f839dee5fe742ba0bbf39645fa2b5146e6524a35aca8e8892aa8e0e9fc"
