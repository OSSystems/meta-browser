# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "af2b9460fda29aea6769864970e56a91"
SRC_URI[sha256sum] = "a83d5e3468cfda34642b252d18edf7020f06855797b805b3c37b67ed44671eac"
