# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "615adbb094ffa131783d16c0a5fd586b"
SRC_URI[sha256sum] = "fa2dadcc65bbf4463270e1d44feed5f9f925cd3e90acf265e2585055f9aa3cd5"
