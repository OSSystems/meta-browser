# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "3f3c73402e72dd670298580aaa6f767c3198b29fd5c692df28ddf931921076cd"
