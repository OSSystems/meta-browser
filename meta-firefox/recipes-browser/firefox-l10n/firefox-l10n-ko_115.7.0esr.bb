# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ce80c62e47e924d3eb14650089fc6bc0"
SRC_URI[sha256sum] = "9aa72a37c462272b3c5b6ab530533b46322fae8cd6a67518429bbbc878c161c6"
