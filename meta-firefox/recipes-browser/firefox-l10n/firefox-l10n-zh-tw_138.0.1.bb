# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "50ea7f7b03ac8fdad095b388ec8c95ba"
SRC_URI[sha256sum] = "31183192340a9588f29a47f9d1377873d57676d8b57ae2b052f8f4988e728cda"
