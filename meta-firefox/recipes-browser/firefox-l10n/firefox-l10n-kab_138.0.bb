# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e72b60da6adc104a8a028908b8d4c32b"
SRC_URI[sha256sum] = "76820e2a0005fc7db55b271bab16ce9e622dd856860608dbf8bb48a72768cd31"
