# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f4a03a180552543af60563b4c01b9a26"
SRC_URI[sha256sum] = "19799216d64d39e0ca8497c08624177289990a168a2e9f231ba5669eb6b286a8"
