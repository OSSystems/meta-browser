# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "614bcf9d69ea8afaee43867e677a211638e1334969e51d3bb79f1e66ebdd713f"
