# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0f7f26b57a6e15bdf36af9e2e46efa8f"
SRC_URI[sha256sum] = "b4619e93f8d6334b47ba638de9f03c4de8a8415013e2c236a608ec68967d6a0f"
