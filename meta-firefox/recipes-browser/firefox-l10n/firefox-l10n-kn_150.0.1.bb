# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "81195f7ce701b06d17e703d8d08de1739115200ae8456e4235ba8c9bb66c0733"
