# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0ed2b6bc97e0e719b555d5999fd65a77"
SRC_URI[sha256sum] = "54c058dd390c210dabb02776f94ef01db7775321b14425c8ae6f127bcfa42353"
