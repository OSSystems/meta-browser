# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3d268de0dd74a294954faee487c87251"
SRC_URI[sha256sum] = "c8c37cbef9cd12814865f588d423956d079b35b852600f0d78b23ea589fea295"
