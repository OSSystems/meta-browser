# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5c71e42a051cfedd0c9740332e22ec88"
SRC_URI[sha256sum] = "4385884a45b64dc611f3fb3e710f023a0637c034ba2c4fc19c1e788c0a3e70f1"
