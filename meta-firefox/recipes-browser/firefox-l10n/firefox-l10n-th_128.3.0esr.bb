# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "38c7239b82c0510360cb9d12d8334fd4"
SRC_URI[sha256sum] = "f2ee7333923d94229b7d16ad1464f18dc3f66934f7b895634048c1d371dc97fc"
