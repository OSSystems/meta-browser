# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2ad2a2e604a6d93174faa4a57c98cf89"
SRC_URI[sha256sum] = "5f9ba09fd6aebb3a34100e286476897f7b7d518af179067a56c5d70b0b91abea"
