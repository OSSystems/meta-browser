# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7735ddfdd446dff9c97ea8403fe91f8b"
SRC_URI[sha256sum] = "de66df7327dda1663ec69188a8774352a40f6f466cba299eda2f4a94ecd4480b"
