# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ea8324df318cd61b43008ce2bc7067ec"
SRC_URI[sha256sum] = "691a9733eb0eff2b9de1f3b44d36176e1d9b25ebdf391402a1c74f63779271e6"
