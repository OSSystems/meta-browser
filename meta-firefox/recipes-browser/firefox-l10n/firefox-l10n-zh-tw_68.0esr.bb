# Copyright (C) 2009-2019, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "547f1ed6047699d8de069eb36925f81e"
SRC_URI[sha256sum] = "7120e23b71da220eb3a64114e8d1d4c17fa5de75aa6f6163f72865a7178530b2"
