# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "01e551727e78d7e8e7019ab838ebddfe"
SRC_URI[sha256sum] = "ee0e4385139a4cfb699825d2df26f55a1cf8d24de0c6bdabdcd1d5d3049b00ba"
