# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1d2dbcdd8f157a8a45c0f35faf76ece1"
SRC_URI[sha256sum] = "5d8e2ca8f67363a471388c48c5848634564d3c231fa4a8e376d0735d5ca6306d"
