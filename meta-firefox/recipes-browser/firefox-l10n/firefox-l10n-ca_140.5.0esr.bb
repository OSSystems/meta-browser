# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ff6b76cccde7d7abe1605d504ed158c9"
SRC_URI[sha256sum] = "3315f84fa31695757b035f9b3328f15f3767019f9b18b3e3dc8dbb929c6179a3"
