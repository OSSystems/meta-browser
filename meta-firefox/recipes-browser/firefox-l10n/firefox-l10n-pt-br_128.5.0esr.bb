# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5d6fc05668663857b56073cdda744392"
SRC_URI[sha256sum] = "681fa3087c5aa2921d99232d528415cfe5024c1b3c2373cad0e058defbe63b8a"
