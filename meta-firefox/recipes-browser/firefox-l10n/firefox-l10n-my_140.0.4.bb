# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "748e9b905b3d24605c08e9e7ae29e934"
SRC_URI[sha256sum] = "d10bed45d5b4208d100e0954e1e302fa2a5c116545d81b48a86f310c2d366ac5"
