# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "4bdae6a09916f70ecc680e01d190a32f5bee6e78cd907eaa9abbac9abfaf74ea"
