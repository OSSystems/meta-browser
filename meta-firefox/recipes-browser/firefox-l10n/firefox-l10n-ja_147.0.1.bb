# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "96ca71248a6970cb5c60bda3eec377ef"
SRC_URI[sha256sum] = "362551510c17efbda750139679048b730982884b529100dd55fd6007adc8d0ff"
