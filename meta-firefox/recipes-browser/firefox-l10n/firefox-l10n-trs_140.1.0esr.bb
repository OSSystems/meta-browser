# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "64eee6d51246190241fe6aadc35906e2"
SRC_URI[sha256sum] = "77d9c1b1f873da50e6b2cd9cc3182ebd1fa46daf4cacb6722968a28a60920446"
