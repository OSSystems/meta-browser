# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f43f5d9228ebdb114ab88aa6bb10c72c"
SRC_URI[sha256sum] = "e762ac0e51bbaf528c9ee93d31e5294cc00c531b26e2cf3487c7d804f00d8949"
