# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a4b4b76d4cab2bea3415da76fd8b19e4"
SRC_URI[sha256sum] = "9287dd89f5fc64b9979b1483e9155164c83bc3d60f9eb602dda71e8368eac065"
