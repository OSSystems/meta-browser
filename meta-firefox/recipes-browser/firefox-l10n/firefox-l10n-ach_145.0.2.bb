# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f6b0d57feb7846b16d6b7a5101cb0d7e"
SRC_URI[sha256sum] = "7b1dfd8d183748c3b7becde1d0290fcf40f82d0edca539992f75f22a9aa231fb"
