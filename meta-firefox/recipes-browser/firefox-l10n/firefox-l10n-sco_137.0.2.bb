# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ac86bd0c3c3820ae7272f08462face33"
SRC_URI[sha256sum] = "6fd334b3ba46a5a803c0a8b07bdec082b299ec443d9ff2f60050f70f2b381913"
