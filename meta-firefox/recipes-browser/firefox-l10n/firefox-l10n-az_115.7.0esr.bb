# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "168d0da6e2346f7708f5565dfd652d38"
SRC_URI[sha256sum] = "0f12b818e83861f4b32bb7888782ca0fe387ac4d3aade341f9e5b428c2125304"
