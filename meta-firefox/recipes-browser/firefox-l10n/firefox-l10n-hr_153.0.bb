# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d2b0b7a7ad29abaf991d41b10aa517c4f403fca26fe7440cf444b343dbeaa50f"
