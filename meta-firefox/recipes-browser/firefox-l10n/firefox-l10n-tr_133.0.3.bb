# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9c3a906a776db8edc86f8b0e71363315"
SRC_URI[sha256sum] = "43df0cabdbd9ee4151501cd90f8a678970cdc6bca55cc3aaed0568af821dd347"
