# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e54a485c198faccb059ac2197408fc57"
SRC_URI[sha256sum] = "b3c8cbee002dd41a29dfe4c835cc2cebdce19b939826e09ff60c525bedd3cdb4"
