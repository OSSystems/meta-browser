# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f62609c51c0b057e11f76a51c3236a0e"
SRC_URI[sha256sum] = "6c784acfbc43be88567e8f47a8347fe8f229b23bcba854544db252b56552c93b"
