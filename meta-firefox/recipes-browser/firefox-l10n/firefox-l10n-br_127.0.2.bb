# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "98074becd736e4fae4997c4302c6fee5"
SRC_URI[sha256sum] = "10693b616773126f9661f7c63c3f32a592deab0abfed7b81bcbfc5ef2c96ad33"
