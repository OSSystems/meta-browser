# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "386e979055dc25002a5ab8067a607777"
SRC_URI[sha256sum] = "4e831e715a6f8787bba00d383cd2012e4e2b450f329966631714a2c498423a34"
