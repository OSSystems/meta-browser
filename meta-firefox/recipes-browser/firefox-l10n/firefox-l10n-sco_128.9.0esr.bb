# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "25f30acc513ed8d40d2a8f98b624bc68"
SRC_URI[sha256sum] = "6f3790b88ae38e74d82063c7962fba2236f262f8ececd7607ef2cbcdd5611f34"
