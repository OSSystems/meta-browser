# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0cb9a9d6e1dc6e170b4b072dde34f5e5"
SRC_URI[sha256sum] = "bf7933a8c3c10cd11d99e8058b5a2e799ac26ed22c5be22c90d330af5df7b390"
