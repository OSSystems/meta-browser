# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9c0aef2cc5bd7352de7a69c4a9f17259"
SRC_URI[sha256sum] = "c0b8e3840fc35810b7b7ed8415f7be65296483db522dcc7809f1ce489d1808cf"
