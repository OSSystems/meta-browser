# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fbec64956a9e2cd93826d1dd2a6b569f"
SRC_URI[sha256sum] = "58d3b3ddcd753ca9f7b756a461b44e70d0261ab0aa40b940d0adfa6df3c92c11"
