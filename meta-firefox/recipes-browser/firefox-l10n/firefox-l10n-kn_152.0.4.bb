# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c258240c0b13de64791bcddf0a1c64ce41f19b0c07709d0a8e3fcc940e758d98"
