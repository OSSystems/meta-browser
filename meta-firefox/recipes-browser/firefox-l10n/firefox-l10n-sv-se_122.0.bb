# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ac89c5c7996ce54a339c3c15c1be5d58"
SRC_URI[sha256sum] = "6c18bb613bdf4ae7bdd14a3c9c86c05291361d6ab2f8bc4f34b0038913c4b2b2"
