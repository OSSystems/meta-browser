# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "10213bc7d02e97ce49dbb67a7389a519"
SRC_URI[sha256sum] = "f69be2e35deb824b5c76e2e83c76479a79bd81616768846530d72448886ad8b9"
