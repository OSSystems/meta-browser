# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a4f6fb22ea465b01e9f3bd936f459079"
SRC_URI[sha256sum] = "5498037f90b5fb2bd0c86e07d224f6bdb746a9121b82dc030f4fcf6b088ce0fd"
