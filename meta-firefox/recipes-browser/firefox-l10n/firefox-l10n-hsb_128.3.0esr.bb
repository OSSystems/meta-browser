# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d6629aeb3b6e127d114a118929ef2774"
SRC_URI[sha256sum] = "3ac0bde2391c510f8c04847c1ee3d4af02a5f0e3238ebef5dd1636b247078498"
