# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2bdb038760784aa48db7d15188da458b"
SRC_URI[sha256sum] = "ff90adf510de4b02b6b0306c36f5e153740c5ec828f6f56b9c633d39251c6daf"
