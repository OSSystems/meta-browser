# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "7a247a6f6e013dc51ee30806ada5bce77eb2e1d739399c08c8f227dca995139e"
