# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "92ae4480f9138eae8e84d90515fabab3"
SRC_URI[sha256sum] = "598759d7c5c919a4df1cc1b2392b95da05256fa6fda47cc7915f847534d9093b"
