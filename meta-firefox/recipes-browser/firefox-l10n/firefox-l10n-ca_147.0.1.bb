# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6cb74322c0dac91d37656acbe8a58ade"
SRC_URI[sha256sum] = "6ab849f1410b202b59daf75c49259b44fd3ef13cc3f034fec5f266df8fed96b6"
