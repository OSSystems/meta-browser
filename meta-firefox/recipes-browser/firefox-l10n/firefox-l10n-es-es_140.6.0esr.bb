# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "04ada462078f589a546df81ecf2c58af"
SRC_URI[sha256sum] = "419ae8916a76efc66eb39d24185a8edf052e8e5044c751302872cde21247d205"
