# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "30c7bc823165e8113c4f8fcd370e8229"
SRC_URI[sha256sum] = "fe5be1d7fb005a5a3df1dde6491e65d73ba7efb7bf69d2cbde76db5bc775c123"
