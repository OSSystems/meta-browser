# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a79647da65caa5275c2918994bf19d63"
SRC_URI[sha256sum] = "57e5c35e9eda0d2f3ba3a0c4a70478b18644ae59afb92afd709893ab6c468d8c"
