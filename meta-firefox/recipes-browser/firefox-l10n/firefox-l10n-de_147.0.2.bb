# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "65710f021065623923e06f52d2f8035e"
SRC_URI[sha256sum] = "bcdf800f309f3eefcfb83e308849fc6a7f91f56b9055a2fbfb81bf736a34d86c"
