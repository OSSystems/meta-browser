# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a07e0ea3f93ed2cedbbf6d52448a430e"
SRC_URI[sha256sum] = "64310fe27787f90ef151618c4d639038162514cfa637f6f21378764e8e61aa8f"
