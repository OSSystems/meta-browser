# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8d855f34fa2f431e13e5f7e747d00671"
SRC_URI[sha256sum] = "686231839b5911e80a456cb0b1c582a45b32fbfead4ba596fedc6b6f2aaf927c"
