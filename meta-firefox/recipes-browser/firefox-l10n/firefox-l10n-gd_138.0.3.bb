# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c67ea2fcb8e25f8badb2b5b86880408f"
SRC_URI[sha256sum] = "e6cc338846d2b9a0ceb68cc3bfe984448bbec433549c24bc1cb7adc64b6bc510"
