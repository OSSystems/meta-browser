# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "215b498d7c62a66ef3627db65732f130"
SRC_URI[sha256sum] = "c1e93f5300300d75c987b963328a633f6ed440a2ac52f8b1ee579bd098bd7882"
