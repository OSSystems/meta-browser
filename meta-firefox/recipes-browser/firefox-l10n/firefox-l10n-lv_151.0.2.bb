# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "17c947ef1d0988f72f2d9c4680cddbeafec0fd1f02e96cf14c370d92e96c2aab"
