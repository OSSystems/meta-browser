# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4a3565a3df30c5ec594ed0a29f8e93af"
SRC_URI[sha256sum] = "4e2b1e1d6d4a0e584ce2b672fc98edebf9d3c791c2f7b5d004f8d2ca540d89ec"
