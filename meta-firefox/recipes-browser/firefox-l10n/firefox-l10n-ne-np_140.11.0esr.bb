# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "692ffcd5fb901dc8efe4e743620828fcc077f4ee25a6341018511ca09e9d9ea9"
