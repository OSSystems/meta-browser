# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "4ada4cb95847c9391844c7fd3a681d2b5c9df5f11584596acd09439ac6cd3bae"
