# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6ff529a0f9850bf28c323be3b8794d4b"
SRC_URI[sha256sum] = "8473cdc2eb3d2639166434360a75eea84c552d29a4164c3c68705aac837b4f22"
