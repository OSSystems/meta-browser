# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "315843463da396044cdb6349c1e69010"
SRC_URI[sha256sum] = "e54893c5d6e592f396a4a403c66923965db10ca7c4ec04c0fbdb8c62f22d4424"
