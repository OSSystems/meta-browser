# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4c36265859d9e8cc7aeeb1882c94494f"
SRC_URI[sha256sum] = "cd238b5ba214c2f24c6c5900d7112bf8c8e725c31832666ce3bb32ab45f3ce89"
