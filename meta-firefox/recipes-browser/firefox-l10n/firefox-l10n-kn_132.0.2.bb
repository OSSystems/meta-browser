# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "40147a5c29640e4f4b252f9a7d0bd30e"
SRC_URI[sha256sum] = "39aea956760eaea33e47f10a2ea2fe036555f639d40a003cb671403c7302309e"
