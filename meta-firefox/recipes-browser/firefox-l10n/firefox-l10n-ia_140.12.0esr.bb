# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "429bf1f673331ade63739fb5a3ccc21d32b759513521db9f1d69462426ea4dfe"
