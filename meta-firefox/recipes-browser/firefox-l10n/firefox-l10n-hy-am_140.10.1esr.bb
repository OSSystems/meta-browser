# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "f8a5392b185b49683694ce005dc3e2240f6ec59993ba84207c36b4b1866e5329"
