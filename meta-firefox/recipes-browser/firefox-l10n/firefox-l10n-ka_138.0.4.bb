# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "333fb3e4f32ea5dcec412684fc2c3627"
SRC_URI[sha256sum] = "f4fb2272bc835557ffa36a3ca5bed67842a099c2d5868e586dc9c6a0c04f5b2a"
