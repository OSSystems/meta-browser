# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e1cdbd53e0f8651f8d86997f36a37c7e"
SRC_URI[sha256sum] = "f8c24599f02ecc315b5e41248bf3fd3d8be96edb986992fe16f9ca99cce79a0b"
