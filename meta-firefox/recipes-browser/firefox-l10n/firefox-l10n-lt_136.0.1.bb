# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "68713050f32fe8c540adb1b9e0e16226"
SRC_URI[sha256sum] = "d7b177b0b02439d08f17851f0dc71ab2ec6554f6032f28960652f149899b27e1"
