# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c704bf6a83681e903a29c7144ab947e1"
SRC_URI[sha256sum] = "74ea7500d80c24b497a785e66a804bd670b3e07094fbb018cc3755f5634b0a61"
