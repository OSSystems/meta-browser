# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "22f3595db196137da097cd65bf55705d"
SRC_URI[sha256sum] = "a46ef8ed8b4a070fdc1c2136050e374913e499ba00c8af293514b0a5f70e4ea4"
