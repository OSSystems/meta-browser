# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ab303b032113e291a2032572b2404154"
SRC_URI[sha256sum] = "a033a792b929ae1454b69b928a63901f2759aa41ea83720c140ac364d22704f3"
