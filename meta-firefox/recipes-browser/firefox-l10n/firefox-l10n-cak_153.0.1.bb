# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "8c000d06440869452b8b09bfbb255020ee22f7bf13ae2167ab4bcb213ec212af"
