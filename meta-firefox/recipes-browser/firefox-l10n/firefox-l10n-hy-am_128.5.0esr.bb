# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bf60fa41460161ecfc8ae19920b47ecb"
SRC_URI[sha256sum] = "0bd46c9ffe1dc54851eb4d7b02789697f1b8415507e0fcfade2ba24a741c9547"
