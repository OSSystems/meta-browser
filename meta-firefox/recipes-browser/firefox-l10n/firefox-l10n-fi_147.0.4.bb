# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6914403f69c98691d34e2ddaf7206823"
SRC_URI[sha256sum] = "9ddb92eac4c2c60637f207d70c22aef3d86a3d057f4f308eb3c736c22897199c"
