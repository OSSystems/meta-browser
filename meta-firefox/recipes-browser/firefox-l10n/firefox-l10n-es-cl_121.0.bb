# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7488bd17279942c576ecd18cc1a91c15"
SRC_URI[sha256sum] = "cf7886a107276b9adcbeeceb681b60295dcb013e23dab0178f947965e00623a1"
