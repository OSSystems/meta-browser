# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "962f3933dfdf632c1d40426dd0912944"
SRC_URI[sha256sum] = "ad80e401987b041291fb3fda0044d790cc6fadb1986259358abfc3e26328ae16"
