# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "98020cf974f23132907e57c49cbf2757"
SRC_URI[sha256sum] = "b4f1ca81333cff67e81a4351a56ae99a91af038c91d9d79b8620ef79d7f80291"
