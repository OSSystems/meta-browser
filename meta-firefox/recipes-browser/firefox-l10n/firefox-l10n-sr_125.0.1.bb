# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3fe77cbd8680be9108c612a566b040b7"
SRC_URI[sha256sum] = "1fc7a4bf934f2e71376b0415c34cd56f4b79c17cd42a7e51a10ceb8b3f10351d"
