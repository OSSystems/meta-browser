# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d7188a84a9fcbfe6c7db52a5dfc4cbde"
SRC_URI[sha256sum] = "20485a28aa04a4863c8235a673406b6395eb4d51181dbafe31f9ddea94042a50"
