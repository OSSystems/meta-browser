# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ee280dac6453f6e0ee8f6e978e57ab89"
SRC_URI[sha256sum] = "49439bfeb8cb1301fe6147a4c42c08a817e3cd3d7b59d4da8a7371df60ded9ad"
