# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "668abb0965d524cb804aae4a645ea755"
SRC_URI[sha256sum] = "d2dca55b0a35ff7603ebc4e4ae0894a316a225b12e97677eb3193d0a0440df70"
