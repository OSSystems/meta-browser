# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0b0fd70db080b340417d5e1403e71fad"
SRC_URI[sha256sum] = "e9b682fdb30e5568ebed2d575cf0385467c5d41516bbb3b9b7d9075ed9500242"
