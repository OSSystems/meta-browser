# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b59ec60315dbf81954dab917a64c568a"
SRC_URI[sha256sum] = "ce45190be028d42d3a5da7063d125e38e44d434370c62bb9b8484982a45b454f"
