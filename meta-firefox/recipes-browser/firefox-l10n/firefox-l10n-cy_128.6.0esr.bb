# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6c2ced11fb464e058825e823ee57a575"
SRC_URI[sha256sum] = "b3813c0d512e6f1dad0023fc8715b1c4448ed79a9d5fe8ec9ca94009fc06a31c"
