# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e24a63520615ee447f73b0e11e69c92c"
SRC_URI[sha256sum] = "3d339d0e9a46e1770bd5e5f87ecb04724614b798a64bb3bd3f52f31d89a8b839"
