# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5ee5b71d766136972c66e707bb844221"
SRC_URI[sha256sum] = "aa3ab06ecae49ebb56f9962a4916ba2799b735b59a10809a34b45fe7783fa2d6"
