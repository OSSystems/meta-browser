# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eeb515310caa44560b800abc113904b9"
SRC_URI[sha256sum] = "2c5a1134a4bf17854eb634b42535583972beb0af914552fbca694bc650d60c09"
