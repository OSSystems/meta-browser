# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4a2d44ea5b178791f20f299b13a1b947"
SRC_URI[sha256sum] = "83938c239bb8d78865c711fee77c64c8e073bfd0d1214e6f67fd00b6df83d833"
