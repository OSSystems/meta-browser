# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "521d56014cf0b560cd8e4e4f545c3567"
SRC_URI[sha256sum] = "99becfc85bb6fd78ec79f6f6dee327e045801b5db8385460fa1e8d2d35b8e316"
