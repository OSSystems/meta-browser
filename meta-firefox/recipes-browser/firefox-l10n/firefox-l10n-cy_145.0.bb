# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0fb76915b1b1862abedbc36da1a2dad3"
SRC_URI[sha256sum] = "06a43f017163374245bd95cba4ec560a5b70cee887809856d0b6198aa4cef26d"
