# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "801e6d9122c2b9b673ea253521f1b537"
SRC_URI[sha256sum] = "367c3da953e4b1617ae8f34cf4ac57d0e6b04337489a1c7d6a6d095b57113ba6"
