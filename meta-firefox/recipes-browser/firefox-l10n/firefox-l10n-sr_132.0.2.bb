# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "24adc990b77200160b54a495faf07093"
SRC_URI[sha256sum] = "8cab88d24a821a9e07db88ecfeb34870631bafe2080edb8b04ce8efec5f43f6f"
