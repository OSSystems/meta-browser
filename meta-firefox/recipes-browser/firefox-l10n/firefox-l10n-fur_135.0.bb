# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d960ce5bc5028cb4ff0dcf15db2c6539"
SRC_URI[sha256sum] = "7343bfeb307ca72408bbddc521ed593ddd431688b16a7188964661add3094bae"
