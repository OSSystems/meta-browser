# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "188c5b7a88fcede03c0cf052bc8a37be"
SRC_URI[sha256sum] = "9373b02594e66decf221f07da39ff7410506c1e99a8531050076d1410a1dc440"
