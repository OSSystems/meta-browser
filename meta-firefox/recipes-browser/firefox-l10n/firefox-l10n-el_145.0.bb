# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e2b7b246565775c7763a99dfcd7263a4"
SRC_URI[sha256sum] = "62490fdf84b87b90aa2a297eb11be787cd2911a1d408c79746904440cbae17ba"
