# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9a5396fa0f22ad59169017b55031f262"
SRC_URI[sha256sum] = "30e46689f123b890f2d9703f6b666292e3c83c4ecd35a3bbf7ec5c8ed6fbcd4c"
