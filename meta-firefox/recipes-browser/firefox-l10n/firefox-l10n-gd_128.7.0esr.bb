# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f1973c43f4c93755cd6182b6a040aaf2"
SRC_URI[sha256sum] = "7ecda45080062cb1e2483d55339c3db95733a3f83b0115c060629fb9e41eae16"
