# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8a573daa386a1e3e09305a017201a182"
SRC_URI[sha256sum] = "cc3b5b0c31bd35d41fc274d0745d08074a1b5f0ec80d2b51c2cf56ad779af5e6"
