# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "83b6c28655f171634a62d3786f7b4439"
SRC_URI[sha256sum] = "fd606e0540cd1df2a2207a93c10b5b41eee33e3476f1de21afd70d47c6d10528"
