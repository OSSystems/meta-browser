# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "1341f6a61359b42b592f86601af93a26e0c35ffab09c6ae850186ed87698cf5c"
