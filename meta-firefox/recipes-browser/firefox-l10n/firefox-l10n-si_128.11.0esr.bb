# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f7f51f415a242da7a6c7c061fe5d80ff"
SRC_URI[sha256sum] = "47262327ff4c230d591dfe050b40352f7ad55d578f22df0eb16d11a67293f663"
