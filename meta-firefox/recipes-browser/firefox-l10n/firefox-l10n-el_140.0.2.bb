# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0276e28036774690b889d7b800c7b588"
SRC_URI[sha256sum] = "14c39be1b0d5a35d0c58ac42a8ddacabeac58bb778954ff8e2e90b6ac067b293"
