# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cac5dd4a0ad605af14f591aa7e078a82"
SRC_URI[sha256sum] = "38d6fd1bbabe56a469eba2131ad80c9baba76c9c3fda1b988e63224e344d819c"
