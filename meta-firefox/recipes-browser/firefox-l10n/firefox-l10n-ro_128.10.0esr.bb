# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "640ac980880748cf474829ce22820af1"
SRC_URI[sha256sum] = "1bcacb609da6309125738d1461c982b849a0b61bca8c5b90ba49551ccfb0cf81"
