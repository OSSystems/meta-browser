# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "15f72884da6265a32ec29c8a39648171"
SRC_URI[sha256sum] = "a9df3dfe9b22b3ee74db8366cb80304b5cbe77d4ee96c146d268f992f5053157"
