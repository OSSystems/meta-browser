# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f2ef7f3f0d79c69bb7898686a1f9dc07"
SRC_URI[sha256sum] = "7f4a22a52a4f04a450ab772f268a29f900fadad191150845622a3a8b11aba0d4"
