# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "33796846083cae84f64a52249c581826"
SRC_URI[sha256sum] = "ad6c86d8b452b23857f5fde1409d3918c10055e86d357c2a7c133606340b3ac7"
