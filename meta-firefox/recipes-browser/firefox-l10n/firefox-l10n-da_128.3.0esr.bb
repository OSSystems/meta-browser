# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aa094c91d2768e85ab99fb20425e4ed6"
SRC_URI[sha256sum] = "535c6a6e31513d544d65f6d047ee0331c5daeb3296259ba435b7be1bcbe009ac"
