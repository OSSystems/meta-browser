# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eed135e120e7c526b793dd3598bf3580"
SRC_URI[sha256sum] = "c5535c9b9f87e010181c9396b45a9a8847810437d72294d786813ad6711e3f7e"
