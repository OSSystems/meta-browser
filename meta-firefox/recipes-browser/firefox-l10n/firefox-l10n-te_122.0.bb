# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "51afab8747b581b1e23c17f0a56f98f5"
SRC_URI[sha256sum] = "1c4b7adfa36e61e261bd7d5aa86210e7ba75ffbcbfb550ac9c75b3335c0cf985"
