# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "801c9588abcbda2610a3d5e8e339d0be"
SRC_URI[sha256sum] = "60f84a2d99c600773b1138353a8321daa4732091a78eaf5822e37f92aa96aaeb"
