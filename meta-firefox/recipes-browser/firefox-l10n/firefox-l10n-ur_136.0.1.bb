# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9a037c99a8c8a7b40f40649536687148"
SRC_URI[sha256sum] = "80957d34375820be17c59481071a738280fcd563785416c3c7b53ada98c4fc5f"
