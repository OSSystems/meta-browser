# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7695e558ce5e2069a6c012120fa84ac5"
SRC_URI[sha256sum] = "9c64d2e0dad46718956c4c9905a4beb312f39b9d3a41c1e43e3b74d66bfbb71d"
