# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "35351c4fa0a6d6d08ada33630db7ea51"
SRC_URI[sha256sum] = "f7a7a56f2ab348d8a3fe4b04140bb8a73694e7b8d82430627fc8bb98fb4e6f4d"
