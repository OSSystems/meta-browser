# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "757804bfac01c51198e8074b25dadd3e"
SRC_URI[sha256sum] = "6985c260626a00cf620864117023b42fd72e4a9429b5852170ce38b552320b05"
