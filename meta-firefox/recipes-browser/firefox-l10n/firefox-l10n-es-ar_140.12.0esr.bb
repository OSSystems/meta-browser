# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "fc1f5f8efd656c6931cdea3e006ce8bda6a6ea2671f8fe6094fc7ba1a87555d0"
