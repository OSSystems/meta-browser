# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fcefc73da69ec611fd49e1eb14bce22b"
SRC_URI[sha256sum] = "2842bf6204773df30f73fc621ff3d2670cc0398ab5b0a22b76b9d2fc059313fb"
