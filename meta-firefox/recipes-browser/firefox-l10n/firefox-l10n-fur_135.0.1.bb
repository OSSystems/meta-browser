# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8dac0ebae427bdcebb2967dcd3eca23e"
SRC_URI[sha256sum] = "c133e45c99801c40163a9d44d9b8a66b292aa6cb7f93a3f74306b87e2c51efb7"
