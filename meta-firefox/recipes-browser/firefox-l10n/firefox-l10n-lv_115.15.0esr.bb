# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3680ec7111f4c61c5f57ce25b1c6b698"
SRC_URI[sha256sum] = "73f8456e10b498e17b858f025be3aa8847f7d117f91004b7c2322c5c16580b2b"
