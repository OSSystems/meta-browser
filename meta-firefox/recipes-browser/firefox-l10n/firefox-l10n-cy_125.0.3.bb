# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3b93b08f04740327a6d8319cb5b7195f"
SRC_URI[sha256sum] = "438d52cd97d742d8cf474d2d2b7d355fab9782fd59613072c687f0e1fbb038cb"
