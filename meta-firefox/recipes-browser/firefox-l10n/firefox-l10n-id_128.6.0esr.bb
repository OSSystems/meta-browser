# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3fa0651d3a6872041b42553d00725f3a"
SRC_URI[sha256sum] = "ec7d2525ecce63c9bbc04413e180c474b647cae7ea2c20274e5277f6dc89f8de"
