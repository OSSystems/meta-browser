# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dae0bdd92d707c2c669ee9e5d7895f47"
SRC_URI[sha256sum] = "e2ebf661c4fb156e9872cabb13c5cc217cd909c0fdf73514a56b0654d4541786"
