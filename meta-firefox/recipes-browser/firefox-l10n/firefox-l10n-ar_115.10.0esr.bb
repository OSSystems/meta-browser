# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "631bbdc361c0819f80fe1e488a322c5e"
SRC_URI[sha256sum] = "9e22ce35059f69008a7694b805e78bb05db783c7cf0c850b09641168b5d8fdbd"
