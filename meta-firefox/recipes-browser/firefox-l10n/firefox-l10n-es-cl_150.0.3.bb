# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2cdaa313fd692e166263b36e3d6e1bb9b82d77de71ac77bc1e87d7bed1481097"
