# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "8452bb44df31b9d91a9882fe7f1aa07f359475a72fb2b9f6a40c756bfeb6c02f"
