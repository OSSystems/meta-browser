# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9493a61d794752c309c8c3b621346af9"
SRC_URI[sha256sum] = "edc71c58d62ee65d4cbcfd712cda3d2874f16f563182c5d1fad9f3a5c744bae2"
