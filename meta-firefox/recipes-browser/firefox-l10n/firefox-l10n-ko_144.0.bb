# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "25a3b79ccb353bfbe1e55ea35e3852ce"
SRC_URI[sha256sum] = "510683e3de91e649e1b7924d83a11a01d897da05021fdfd5482c0ebf5d117369"
