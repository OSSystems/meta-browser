# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e9f497956c5e2d312ee0e2c1b043ae50"
SRC_URI[sha256sum] = "42e0983a5e31a58ae82722d079c908c30bba1126ca670eabcd8a42bec4eff347"
