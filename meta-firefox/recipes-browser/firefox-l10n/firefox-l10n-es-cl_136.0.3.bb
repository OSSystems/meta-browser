# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1062e09830466d79924eafc60a4281f9"
SRC_URI[sha256sum] = "16420135f9bf931ff101682b93a03d6196a8726b51ce20a49bf08f12c2d556b9"
