# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "082cb414f2f86e2eed16fb6608cbb219"
SRC_URI[sha256sum] = "c6d4dbe44e4735e0e4175f3eb46f8c446636d876f2d97393ae9d7072760938ee"
