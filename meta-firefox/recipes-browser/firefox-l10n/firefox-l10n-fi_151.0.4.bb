# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "d2e0bfc5630e096efd40e49c2e39c3a368067ac92114485eabcd7f498ea76d43"
