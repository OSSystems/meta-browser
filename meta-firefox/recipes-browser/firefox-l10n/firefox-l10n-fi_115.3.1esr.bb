# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f9125274296cea6355dcfe039ded73b2"
SRC_URI[sha256sum] = "a83e1b29e9f53511d0927d3be83545e240cdcc9e905205db0fdd65cb56c33eb0"
