# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0086e8781dd74c4488d9085e49080e60"
SRC_URI[sha256sum] = "79a4dc427c79cca32241ba7ff7dce054f5638375ea2e6b40fa7061e5a0cf0232"
