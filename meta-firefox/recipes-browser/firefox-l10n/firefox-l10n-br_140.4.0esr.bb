# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c0011d6fb07ea0fd28554bf548688f5f"
SRC_URI[sha256sum] = "08c7dc864b6fd7449cd365294f883ba562dcda46cf01e03541fc581a18d07d18"
