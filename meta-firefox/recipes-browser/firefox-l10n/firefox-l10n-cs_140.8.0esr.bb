# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bdecf06a3c524552c874fc837fe8991b"
SRC_URI[sha256sum] = "c4849fa7595735ab4fc1a3e4d16944efcb51682239647c1905e7abf2150ae3f3"
