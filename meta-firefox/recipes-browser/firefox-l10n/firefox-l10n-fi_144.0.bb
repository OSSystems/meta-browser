# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ea7f7224250faf760498fcfa00d80f6e"
SRC_URI[sha256sum] = "785583bd8e6b03a81fc56043594b793abf9aea5e08b1047593b809b2ad1cd099"
