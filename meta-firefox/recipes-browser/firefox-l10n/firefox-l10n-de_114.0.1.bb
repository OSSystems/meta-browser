# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6447489c2121a62740ea7a9d8b80dabe"
SRC_URI[sha256sum] = "f23f54c8a74f3f54080d2b9dcf7080d661692f7942053c0f6766578971eb186e"
