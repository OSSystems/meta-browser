# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "400ba60b529ad9118ff77313657a2930"
SRC_URI[sha256sum] = "92bd8843649019853ea1003689778892c3339c2d3e9735301f17cfcf1a20310b"
