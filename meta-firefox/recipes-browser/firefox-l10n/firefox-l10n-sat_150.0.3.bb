# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "e7047830060122ca8b467534d49ee1f2968fc423b9ffae8645050a6ff154630a"
