# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "0e1fecf1b3ae0edaae614f13cf9e10d6318a9e58aec5bf6035662265fe5bc2c1"
