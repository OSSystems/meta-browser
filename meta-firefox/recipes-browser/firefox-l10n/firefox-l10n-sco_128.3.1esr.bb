# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "21990a60f44313a560d1a8e7dba46746"
SRC_URI[sha256sum] = "63f5769958919ff4e04956401f9c8b86c37ab1249ac885b8e980e3ef478e0600"
