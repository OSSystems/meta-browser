# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8e67b4f2c9420c28483722dd80fd5b1f"
SRC_URI[sha256sum] = "d7dc807b8103cc1aa6df02d172e2fbfc4e87098d5e5d1da3da820221e9ab3ad3"
