# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "43e23bf54a4d18fb46a12c86a38583cb"
SRC_URI[sha256sum] = "42a7247cd832eb901ec243be49ae215b0f1ded17954478c8330cf62235ad323a"
