# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8d1f452a8d13d50eb22a3f3e02a2bd68"
SRC_URI[sha256sum] = "b76cb79ea2609b95988dcb247f57f72ad178ae25a6b66868381f53ad07ec4d00"
