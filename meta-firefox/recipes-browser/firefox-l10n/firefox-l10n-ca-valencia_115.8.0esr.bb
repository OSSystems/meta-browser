# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "05656d5a1258d3bdba46db0a40583689"
SRC_URI[sha256sum] = "107887edfc8d8cc04e59416f752a21909c8869966f1ad22cc949609b47dd1500"
