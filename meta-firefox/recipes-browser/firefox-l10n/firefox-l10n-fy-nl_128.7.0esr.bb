# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b4ef4c55eeb2d119a950df131a8b1d40"
SRC_URI[sha256sum] = "7baaa7835f07416de1976de0d4003f8cec989f1a58cfa53cf3c3b63f2c3f3f9a"
