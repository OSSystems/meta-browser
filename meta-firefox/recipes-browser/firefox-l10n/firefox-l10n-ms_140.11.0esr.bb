# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "c83fff2a80e85745a44501ddce9edbf4408f26a1bec7771695ed12c199e778c8"
