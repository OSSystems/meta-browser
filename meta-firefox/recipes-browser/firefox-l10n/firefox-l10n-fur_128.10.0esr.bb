# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "26c94881686500d2cbf05b6f5bdaaf09"
SRC_URI[sha256sum] = "4ebc2cdf45d883d66e52959e211b5148a907dbd0b0253c165e04963d89bc63ec"
