# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c90b5c119e2cbc0b2431904d70d67967"
SRC_URI[sha256sum] = "2e4e84dc16ddd3622ed6561d54a2d01b0cbfd26995e83a5702c4e28b2ac627d0"
