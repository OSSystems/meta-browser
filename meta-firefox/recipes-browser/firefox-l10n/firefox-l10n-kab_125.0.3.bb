# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ca61fab0affefe22a45a42bc30c4444"
SRC_URI[sha256sum] = "805f8306b14291b7e5acf9521a892e513fb524f68b2536119948e5f21ebf11c1"
