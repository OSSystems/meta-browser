# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e4ca4d76bab8aa8bc92fc37dc66bc467"
SRC_URI[sha256sum] = "635957adcd51d46f57a591132e823a95ece3805457db57bd279990a4bceb3011"
