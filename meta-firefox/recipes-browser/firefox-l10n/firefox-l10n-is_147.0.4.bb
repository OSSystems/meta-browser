# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c25aa2caa8a7a01992de76b3853e32af"
SRC_URI[sha256sum] = "dade5fdbc414ef4c978b6d6ba4c8e3b895739ade86de7ce073661157e48b924a"
