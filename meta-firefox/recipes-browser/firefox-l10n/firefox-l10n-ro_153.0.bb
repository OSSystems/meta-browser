# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "1773705095c8b1cd1e8822fa895ff537cae097cae8a829db9de3ab3175e7ac9e"
