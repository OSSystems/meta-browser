# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1f347d8a9f95cbeb076f426b1a04a267"
SRC_URI[sha256sum] = "df253aca60e6bf073c48c074f47711d055ba865ea2622da07f1e7a1159ea5bde"
