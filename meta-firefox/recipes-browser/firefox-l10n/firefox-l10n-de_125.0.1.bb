# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "42edf2cf1139551e285287250270a080"
SRC_URI[sha256sum] = "a8fb86f692a3f3d29db87c5ca5619ea7df829318eb7eeab57436ecb2a59801e5"
