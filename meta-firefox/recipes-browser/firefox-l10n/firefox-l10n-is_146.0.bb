# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c7f9ea7e4b248d58bb4dcfb6af93a91a"
SRC_URI[sha256sum] = "ace7e6734dc1c8d337650d2410157ef6b864ac7fff60ad919ad9247393def57f"
