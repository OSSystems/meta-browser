# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "631f700564bd3cae86970a1015662bb4"
SRC_URI[sha256sum] = "80255a683cc65c03293ff05e1ab781676c851fcde41bc95802a22915b55cf57b"
