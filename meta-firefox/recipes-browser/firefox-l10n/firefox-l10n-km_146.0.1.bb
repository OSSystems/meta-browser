# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "439b452a9d534c7d2d722e6e0739ec4c"
SRC_URI[sha256sum] = "583c8b70bcdeb1f42aa5938e90da22319801d289387faae3fcaacc02bb25f88f"
