# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9af62e77c49c1fb72a6684d6c76238bb"
SRC_URI[sha256sum] = "300e6656add852c1d66d284bb9b82a2ae69b16cc409e84a14e05858de0849a40"
