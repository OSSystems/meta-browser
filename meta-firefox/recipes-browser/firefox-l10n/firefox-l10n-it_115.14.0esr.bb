# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b3aa918fdeadd101a374c45ecddc8f47"
SRC_URI[sha256sum] = "a6b83482dee8a3028013e4bfe8e2d5c7fb49e6369f97d169b3976318e5975f57"
