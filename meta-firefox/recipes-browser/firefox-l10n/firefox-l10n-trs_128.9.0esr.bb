# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "94f5fa90513a7a32b1f4f5b9bb17e5d1"
SRC_URI[sha256sum] = "5419c6122f63a35be7ba7e17e104407f92f789a4f69a2dae5de575ec869c83c4"
