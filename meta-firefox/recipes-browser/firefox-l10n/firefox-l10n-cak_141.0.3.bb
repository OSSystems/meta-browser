# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3a5c429b93e47de3ee9091a49ff290d2"
SRC_URI[sha256sum] = "5e5f053024546b813764f996596dfc451557ba1fb8c78f4532d9d1b640c55a7b"
