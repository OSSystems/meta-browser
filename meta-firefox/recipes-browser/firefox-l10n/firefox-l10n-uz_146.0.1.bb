# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "013e58d965af91cb6b67edf09394a281"
SRC_URI[sha256sum] = "3726d1d699d5f81fdfe94097ae0dd290e2fe00a0858cec2530073be23ce84af4"
