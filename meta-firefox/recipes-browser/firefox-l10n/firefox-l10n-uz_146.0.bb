# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9cd11f61bf7698e2af04751910d40e3e"
SRC_URI[sha256sum] = "835c351bc0c37125d1d88395851aa305ade1095f9e0b9b769e243045caeba1e2"
