# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a37a615880ce3152671a03a7cf5ceff7"
SRC_URI[sha256sum] = "6a372be59d4e4efc09230fd517aa61e086ed7432df885fc5829b10ccb56bf367"
