# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "700a5a2f95b448b67acfa02fcf78a537"
SRC_URI[sha256sum] = "f66ea42b52444762e77af7cb1144d0629313a1152220ddc3e54ca42581d8c8d0"
