# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e0fbcd76d522494a62032f46ac1e2897"
SRC_URI[sha256sum] = "8dc569f87e30b8bbc6efc27c46084bbd802f23126388dccf0b3fe49361c217b6"
