# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1144efc70e2a1d7ca8e02c1c4355afcb"
SRC_URI[sha256sum] = "8887c81b32b3622a58f0f968e519f52a3890fe93a3af1ed5214ac9f364b5fe26"
