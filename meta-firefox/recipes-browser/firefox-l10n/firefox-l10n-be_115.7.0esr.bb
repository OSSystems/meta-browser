# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "be419ae32be9e0e3c4b00f8d7200a8b6"
SRC_URI[sha256sum] = "5ac5cbe17ce1f735ffe0ac87a1f7d8fbdf0cb1ae6a5f5a1d8a3fe3b88c0dafb7"
