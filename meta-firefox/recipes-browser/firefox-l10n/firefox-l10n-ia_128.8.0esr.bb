# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ea88c3e1e28fb7f2adb2f49b06fcf5aa"
SRC_URI[sha256sum] = "fa1198744d0d4b5c970f92feb6e1a9bfa80421eb21b0a26f28f04381d53637c9"
