# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "27f7ac5b608f67a6d5f50acbc609b9ab"
SRC_URI[sha256sum] = "2d49947a0826a13c5e2ec5dce1b29f0205de0be80fa370f8418a50c58a1b9112"
