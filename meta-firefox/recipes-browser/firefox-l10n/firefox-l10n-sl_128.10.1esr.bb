# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "feb9c8e4c0946bbf3ac6cd735efa30f9"
SRC_URI[sha256sum] = "215489299b5b9e7b85884a8d8fa6a6c2be6a00127ae67e048434e6a9ce9c4ac3"
