# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5b070f73eb78929efb68733b59577ef9"
SRC_URI[sha256sum] = "ffd5af187d92d542d6976f9ece70d9e618dff682871662da223a4e5c0c894a74"
