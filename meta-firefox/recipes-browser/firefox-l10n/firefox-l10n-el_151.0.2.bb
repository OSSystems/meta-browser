# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "9c7eccbe7dbca16fa51252d97fb09e1dcf043c30658de2b12a99db71e14f18ce"
