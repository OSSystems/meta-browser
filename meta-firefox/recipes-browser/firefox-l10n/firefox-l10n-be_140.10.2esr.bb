# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "09ebbbbfe7a995a04cc8efc9e60ce2f4b9323056812c239274ffb27d79024098"
