# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7b8826445d9c2072af6abfc98ea13491"
SRC_URI[sha256sum] = "d127c03671ea3ca3bca5faa6f02452ff15747fd8e8be128ef413615ecc69ae0e"
