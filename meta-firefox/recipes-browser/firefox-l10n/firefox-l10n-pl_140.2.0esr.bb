# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "422f39e34888ab252d7aa8165dbc440b"
SRC_URI[sha256sum] = "ee0906b7ef6f1c6ad94c0bda98d648a04648994b2a73279926def81f73c8827b"
