# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fe697893d184e62d2df3a087f0057020"
SRC_URI[sha256sum] = "a39b52a90bb001bfce92973977c57a23f9143b43f595f05772f64f32b3df1e08"
