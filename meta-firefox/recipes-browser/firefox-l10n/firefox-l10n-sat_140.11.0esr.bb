# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "f7b9793150f829f503819cbaf019ad28a44b7941e89cefe08d6404ffb04fc1fd"
