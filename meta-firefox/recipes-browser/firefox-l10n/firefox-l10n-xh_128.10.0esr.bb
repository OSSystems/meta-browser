# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f65f68b386d1245ea60882d061597de0"
SRC_URI[sha256sum] = "5e2f85ae97ae21cf40a5279463459b1f65f50f49ca5d3d70886b6a69c68ec24c"
