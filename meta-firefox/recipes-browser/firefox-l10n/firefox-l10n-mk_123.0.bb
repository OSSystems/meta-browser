# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "67e1f5a774312ce8cd5e6ea2e5076881"
SRC_URI[sha256sum] = "3af06f45721a2fac06520276f99ed59deb9e892ac9a1a7e33a50538a84aecde5"
