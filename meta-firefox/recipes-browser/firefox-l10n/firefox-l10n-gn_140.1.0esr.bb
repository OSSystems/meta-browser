# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2fc6dad0f25650de2195224cc724c7e1"
SRC_URI[sha256sum] = "8efe13e54485e8d132c1e48d5d62c9030eacafc00f18985fb744ed19ea348501"
