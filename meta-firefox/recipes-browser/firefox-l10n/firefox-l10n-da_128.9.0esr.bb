# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4239bd02cad37059f46794bcba861c4d"
SRC_URI[sha256sum] = "10bbcc304ceb8ba964e3680924f82709d0a63d622af0802f9b951d9486979017"
