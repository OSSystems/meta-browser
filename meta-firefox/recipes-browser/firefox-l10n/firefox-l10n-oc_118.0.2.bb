# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6a4e22ddb69c6c97b168e2c54b48263d"
SRC_URI[sha256sum] = "2a589ba0b04d99d3e3e324615194b7ead5358a65392fd7b02aefef4d41cb98f1"
