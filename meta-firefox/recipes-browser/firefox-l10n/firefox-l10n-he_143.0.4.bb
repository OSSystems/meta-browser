# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f74e54eaa8520d9d9c88ec77b16f1abd"
SRC_URI[sha256sum] = "008eb7c4e317e138b1d594abc11c8dddba294e7f713d2749856bae2de6fdb667"
