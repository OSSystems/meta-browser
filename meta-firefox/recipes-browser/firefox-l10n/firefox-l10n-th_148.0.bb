# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9e3992ad96d252ad707ccc7cf2bb3689"
SRC_URI[sha256sum] = "c10771e483111c0970ee35951170475d68ab5705acaf5e8c4180fbfdecc27c0f"
