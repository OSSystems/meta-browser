# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "147ac49547e7a35cd6e5750a2d69ff0b"
SRC_URI[sha256sum] = "300060d15eb00a1f364736c350aff00785f7be939862dca6f1d7db415669cc36"
