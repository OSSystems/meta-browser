# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fbe43079a10526f62eda3568f29d61ca"
SRC_URI[sha256sum] = "8d30793843a1f316d890e57f44451d963675aba8c4b6a76be9f6b74036fe1add"
