# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f0a3b7c04e8337b02281eea17b0bf508"
SRC_URI[sha256sum] = "5f96eb98b0c84e1e920a8edc87d16879abef037f3b57beba7fe73641a42a9469"
