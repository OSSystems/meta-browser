# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1b33764f313f1636c27061f9db6581b1"
SRC_URI[sha256sum] = "b7f38bc988d081d70011b6fc1aacf1e1b8a44cf591d4276e31a66773362aa38c"
