# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "82f312a07b84c5e40baa0113c9327a1f"
SRC_URI[sha256sum] = "2bdded2613f5ab61bc8612dd4252ca2d4162030ebeedb728fec1b1f9716f4efd"
