# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bd5ac52fafffdd206a299ac828ccf694"
SRC_URI[sha256sum] = "799ad9ed4ef23cff40c67dbf15c0baa4c31d29894dba85420a205881143b49d4"
