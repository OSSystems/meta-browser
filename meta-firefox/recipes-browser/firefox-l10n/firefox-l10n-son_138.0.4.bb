# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ccc5bb68aea2bc5a3c9b12e20401853c"
SRC_URI[sha256sum] = "4c95ddc62bc82e4e7adadf1d0c8582c360b53ffb9143bafba7d4669cb3b82363"
