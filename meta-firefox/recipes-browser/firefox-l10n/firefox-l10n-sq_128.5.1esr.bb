# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e39a60ce440e4e12fb26a528824a8902"
SRC_URI[sha256sum] = "d2f72f1abf91897f55b0c4663c2841cd7b4f718e68f6f4d5ffd7336d4b754c65"
