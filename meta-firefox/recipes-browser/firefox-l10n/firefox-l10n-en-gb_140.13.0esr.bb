# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "ea2c383c6f9b235cdaf1ee399057f5f7e67a4f9623cc2ff8890f306a3a8405bd"
