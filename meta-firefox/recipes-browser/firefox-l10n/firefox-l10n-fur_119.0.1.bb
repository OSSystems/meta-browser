# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dda21333ee97aeccd8edeb0172275321"
SRC_URI[sha256sum] = "4133d7ad5ef1632c6e1c410227ba599221cba94cdf78e54466fed3e468f8a89b"
