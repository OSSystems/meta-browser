# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "66c5dc41f11794eec32d4cea691f745b"
SRC_URI[sha256sum] = "320e2cd31da1a41e4e51ab970178f8312945c39efacab71b36875291931b1ae1"
