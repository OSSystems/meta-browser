# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "13c6ef7af501dada327a387b2b2a2dbc"
SRC_URI[sha256sum] = "a269ce8ad765b22f1d4b3b533723dce601d1951596286bef5f02b9055c1b65ec"
