# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ec4f8d810398665c8078af86a16449a8"
SRC_URI[sha256sum] = "dab66f5dfe36d9f5352174c6c7f64ac8809974bfe0f7feb374e975d46a219804"
