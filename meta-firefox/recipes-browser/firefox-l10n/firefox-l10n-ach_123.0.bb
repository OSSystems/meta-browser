# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d76c70aad04a955a00ae268c5007270e"
SRC_URI[sha256sum] = "b0be6e70bcce5301b6e8e0c411f484084363629cccd3218f1ee93ebfc16c9d2e"
