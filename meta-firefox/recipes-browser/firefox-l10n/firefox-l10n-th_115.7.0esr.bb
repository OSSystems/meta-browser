# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0266c0a7437f45ff71a666f965fc2f84"
SRC_URI[sha256sum] = "1d55f944785cf0b0d2f7c25dbcc0b9dd7b626bf965a6d3780294dbccd714351f"
