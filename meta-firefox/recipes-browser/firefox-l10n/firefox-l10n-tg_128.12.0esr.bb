# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eacf8ff174ebde2ca0dcbda1474d53b7"
SRC_URI[sha256sum] = "2f903ed3f8075cfcb3e7e38a20c6a3ea4d64ce24918a2e78f41c6f8baef12087"
