# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "36721dabb10af1141fd91dd5fa850ea3"
SRC_URI[sha256sum] = "5f6d636abbd10d9253a54f42573b3f5f661a16364a99f20c8f206a0fb5359d27"
