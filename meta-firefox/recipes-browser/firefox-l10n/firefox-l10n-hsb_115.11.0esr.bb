# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ccaed3e76f7f62319ea30a6e1d179489"
SRC_URI[sha256sum] = "64bba01e3ee1998e6cca0154c1bc4351ddce266a7b4582a3e44f26d67296aea7"
