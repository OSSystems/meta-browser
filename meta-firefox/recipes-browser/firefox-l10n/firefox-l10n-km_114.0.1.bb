# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bbfae7435f25a9ec19ca66f8a7234074"
SRC_URI[sha256sum] = "c1cc0cbfb2a99dd42d959be9d89eb98adf14ae5d23c2c20f5362bd10b9559100"
