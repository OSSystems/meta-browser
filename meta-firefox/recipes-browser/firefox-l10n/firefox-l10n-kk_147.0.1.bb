# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6885d33ec9b171d1896f108eb90fa94f"
SRC_URI[sha256sum] = "c112bb57662687c526af1ce8205835d35f0f531a3ba17e0e57ad8bf8669eb367"
