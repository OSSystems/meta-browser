# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f20563e1048c0557cb9c58ab7f539247"
SRC_URI[sha256sum] = "32b6c87e8f595ec9fba9aadf6b9e89b38feb0dbbf712016c33390d6d4de5b1d2"
