# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dd47c18c4dc1fba9266b1a9e6bcfa805"
SRC_URI[sha256sum] = "de8e33169bc4f9422e0a3616bdace72b6656d3e60850228b45e1517299105d08"
