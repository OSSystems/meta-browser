# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5b17b137c40fca9eb2cdc467dad781b4"
SRC_URI[sha256sum] = "3165e41c627994e32ed4399a1af331137f9f3111ac7791143b01b6fb7f231ef0"
