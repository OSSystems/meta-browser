# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b46b2c625a9fabd1f87c7463296e046d"
SRC_URI[sha256sum] = "c68dfdff0fd1df6dde7cf103615cb904b62bededa1f3d0bf8d2a2f55b40871f5"
