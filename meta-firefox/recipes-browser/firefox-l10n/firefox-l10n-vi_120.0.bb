# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0ffab5197216d5584faa0626f64524f1"
SRC_URI[sha256sum] = "3021cb2b30820f45b650b4a314e81e7ca130bea8526ffc7c094914dd3463cdbd"
