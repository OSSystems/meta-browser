# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6e046472eb25ef2b04a4e6e57a711888"
SRC_URI[sha256sum] = "10bc8519a4b884cb8489cf85875f6841f942b06ef3d62cfd47138fbcac449f03"
