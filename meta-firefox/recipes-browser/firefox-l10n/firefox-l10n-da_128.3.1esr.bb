# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c0c89cde9ced98a5f1f4464ae6f8b254"
SRC_URI[sha256sum] = "3273bebd78b951f5ffc7baf3b4db81ac49df3cb10c0b744ce3219c77a2767302"
