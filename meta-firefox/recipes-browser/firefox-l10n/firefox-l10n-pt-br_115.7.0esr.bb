# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9647445ea41f7575ac2d9415a909faeb"
SRC_URI[sha256sum] = "f17ff35f68a03fcc57ba04ec78d01f5cc5c562bbf2535300d2d6794e29ed7fd5"
