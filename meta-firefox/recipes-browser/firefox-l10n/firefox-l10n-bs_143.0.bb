# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "337fa9c20503f8d0f2b9abb965a6c3f3"
SRC_URI[sha256sum] = "50213764ff849c79d4bd4a54df47ba43aeecd537db901e644deaa35aac007d07"
