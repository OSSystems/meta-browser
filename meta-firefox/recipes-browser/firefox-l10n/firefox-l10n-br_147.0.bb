# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b147b269099a2cea7be28aaffd58e4c4"
SRC_URI[sha256sum] = "6ad70efacf31726f39ceca940037d31350fba281563829930dfe2fe946989bcd"
