# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d2c27f780e129a0774bceca0c9f8f81b"
SRC_URI[sha256sum] = "adfa2bd150f0d24c655ff71a34215495be8e10132bd6c999bd2144166ac7b77b"
