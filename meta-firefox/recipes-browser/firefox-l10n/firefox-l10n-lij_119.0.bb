# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1bf7acbb92a8e226f59e2eb8f98b3763"
SRC_URI[sha256sum] = "e473b2091babb4afce1a6f02ca88602f4c4d62710c90ffeea9fe11936c16fd2a"
