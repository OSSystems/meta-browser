# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cad24bc652f8a3bba416c033189d56ca"
SRC_URI[sha256sum] = "c6ce16b49273b87b0e6083cddc99b5226f12c4d395f19e0d94936202600bcde3"
