# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7aaa2a19c154164132be64712c47c9bc"
SRC_URI[sha256sum] = "7218b12b0f643cf93a74e1b2c0af8e3233e5b4bd76ca48def8231d526f05d2dc"
