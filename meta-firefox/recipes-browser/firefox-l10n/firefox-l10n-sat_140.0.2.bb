# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "728afa1e74dfb79654efc8e217e4b629"
SRC_URI[sha256sum] = "680d928ec9fb23f9a4542dd1c63a74c869030aa1c81bd4b3dba87151a42ac25f"
