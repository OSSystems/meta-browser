# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6a2f0e2e476de2540554fcddf221dc77"
SRC_URI[sha256sum] = "bac69392c154b83c80df761d9af8ffc6fb01e61115c3258489b6ac2f3c78b11e"
