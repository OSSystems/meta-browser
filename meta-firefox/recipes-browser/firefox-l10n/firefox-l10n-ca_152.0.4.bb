# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "5ee9071cc848ca71cbdd85e4c1b6e3a3f4ce9610d65504d99cb192f0c1f6088c"
