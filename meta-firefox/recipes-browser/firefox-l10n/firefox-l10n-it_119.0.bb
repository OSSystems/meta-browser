# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8c5fd4c43b42640d076be8bd3fdd3ae2"
SRC_URI[sha256sum] = "22e84045eb4b2c5d8052364701729dd9d8aef4c40d110cc0518e75c5112ae013"
