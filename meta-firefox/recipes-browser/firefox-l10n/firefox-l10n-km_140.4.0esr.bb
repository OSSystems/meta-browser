# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f9caa0bfde53c11a1bb4791cf597b06a"
SRC_URI[sha256sum] = "eef9f07c1bca3cb15bc0bedeed10f275737866e7a6440457b81a709077c46868"
