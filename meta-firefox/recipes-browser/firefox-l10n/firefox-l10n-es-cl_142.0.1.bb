# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "58d5b898f279797c66b4d0042a921445"
SRC_URI[sha256sum] = "8871314028de7fe8c90fd92b2cc0cd1fcedd9cd5f5bb56f07661003652f53bcc"
