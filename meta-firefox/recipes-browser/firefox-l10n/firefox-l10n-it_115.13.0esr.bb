# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1029ccf0d0d558538ff7d0b20bd142ba"
SRC_URI[sha256sum] = "554b50e5024af18a0604ef8e9e93dd1432cad161e7f145244b1b1a4cdfaef5ee"
