# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4eb84918dba5f3bf477bb7fd52bbe10a"
SRC_URI[sha256sum] = "586a13239cfa0b3a02574e208871b1c74262e9d5a5cc76ab1326d0feee48a6e4"
