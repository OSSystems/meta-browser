# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "97134974356359290e9a93c3379479f8d62e6bd30fd8d9beb618b6840613667e"
