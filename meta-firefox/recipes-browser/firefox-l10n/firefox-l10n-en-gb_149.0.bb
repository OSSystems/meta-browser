# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "13ac51ff5bcdf0e6bbde196d2bcb4d97"
SRC_URI[sha256sum] = "5c5d51f140cb5b388877f4dff49c3de93622032c1f0d96eca552bea88e85f815"
