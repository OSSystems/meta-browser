# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "edb47bae0adee03eb44a92240d08b1c8"
SRC_URI[sha256sum] = "fb4e0dbed523c776d6a29517fc1039f362aafcc1670bf835cfc3d2051cca6a7b"
