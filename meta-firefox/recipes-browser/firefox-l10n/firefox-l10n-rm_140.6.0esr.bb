# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aaa5cd943343d9c2146b66ab9f6d92b9"
SRC_URI[sha256sum] = "71d2ab406cbe80bb2edfa14aa5aa142c747103ccce86368174015012514ea888"
