# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2ccf7beffa20faccf06bd33faadff196"
SRC_URI[sha256sum] = "33d084c7e93a4c55fb07ed957e00100a98bf2b88cef12e0874aa04a372cd26e2"
