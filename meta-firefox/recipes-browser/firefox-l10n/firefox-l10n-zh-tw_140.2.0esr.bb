# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eacc3f8e6183607b0708af15f0c22587"
SRC_URI[sha256sum] = "65b480523bd1014dd3656d16592bb911b7233cc77f9b869ef59fafbaaeab13a3"
