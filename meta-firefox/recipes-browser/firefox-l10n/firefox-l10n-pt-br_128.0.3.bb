# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4f91b70a0c6f088871027a6643fb47fa"
SRC_URI[sha256sum] = "f8c535fdf82d7cd69051bc4f67bfb596eecec3cf77fe4bca9abdcdca33ed1256"
