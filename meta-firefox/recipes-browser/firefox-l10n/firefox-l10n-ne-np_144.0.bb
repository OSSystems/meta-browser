# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "46764c126017bad1a10d00338040949a"
SRC_URI[sha256sum] = "9a3582067914cda3694ba9281c2bf1007afb7dcee4027c7c221ec0ab4c7c3045"
