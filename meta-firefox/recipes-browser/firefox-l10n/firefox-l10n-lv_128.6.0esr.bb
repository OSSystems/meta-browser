# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "13d8372217ea686d667c4430b4058771"
SRC_URI[sha256sum] = "4f237a6851d2cadb71fc4ca1d5a035722069ec6b7e32d3552ce4e98a6f53be1c"
