# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dd84d1fac1dd0e140784843c83af42ee"
SRC_URI[sha256sum] = "7f5d5ff1407384e37137ea65df28264ddbf9cc9e6408ce4a78ba16ea98f3c0e6"
