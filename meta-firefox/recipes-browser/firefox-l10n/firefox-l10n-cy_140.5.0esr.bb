# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4ef27e058902dd41f61db157ae562ad1"
SRC_URI[sha256sum] = "06e40585b5b7f4ecc4d0f12d604875c589958f3ea52c9507a40a8c39b6fc6ef3"
