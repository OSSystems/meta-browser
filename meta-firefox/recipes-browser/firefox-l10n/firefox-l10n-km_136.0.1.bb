# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aa9617bd339da2db57d42c51a72a3c76"
SRC_URI[sha256sum] = "a8b63cec13b4e4ba2a352e705da1a15ca9c7a176893c06f700adf4b9cbaac2ad"
