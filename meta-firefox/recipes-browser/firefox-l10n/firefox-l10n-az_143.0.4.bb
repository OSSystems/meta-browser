# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e462e33f5457a8f957a0eeb0370d7903"
SRC_URI[sha256sum] = "d5a9d20936a209316a185443811e5cbdac926fd3e671ab38fffe621f71599ba1"
