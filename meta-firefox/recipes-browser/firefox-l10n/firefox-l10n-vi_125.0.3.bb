# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6fd8ea594419121833dc023a920b03da"
SRC_URI[sha256sum] = "89c17afdb80e81208de378053f84bd78908d328e375bd37593560e78dfa92a6a"
