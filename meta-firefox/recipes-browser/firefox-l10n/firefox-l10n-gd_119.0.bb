# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4107918bc6c285abea8d33b8a263cc53"
SRC_URI[sha256sum] = "cd2a27667499453a561360b9e7f6c00630911db27c4366c372c20fa4e5080cc2"
