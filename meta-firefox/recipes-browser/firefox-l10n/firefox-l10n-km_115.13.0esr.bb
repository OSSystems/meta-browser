# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c3a7103d485957d5b85a3707fd39b717"
SRC_URI[sha256sum] = "e0aa0728be4eda660b0adad24ad12fff15db9f4f328354ee48b311c7e172ddf5"
