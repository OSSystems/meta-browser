# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f364989ef6ac6056594830575a339c99"
SRC_URI[sha256sum] = "70344e6c0b24dbb4a31591902c350ac48e3a9e3a88cb927f4bb9ea5e94976bad"
