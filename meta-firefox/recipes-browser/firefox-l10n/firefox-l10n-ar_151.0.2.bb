# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "2c43c81fe3c019e0b38809cacf5a8426a9b83840b18fc282e07eacc990c0a8e1"
