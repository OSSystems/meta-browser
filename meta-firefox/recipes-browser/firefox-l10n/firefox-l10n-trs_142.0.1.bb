# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0175061b99ec7ba33ca8f776ccaa5d24"
SRC_URI[sha256sum] = "2edc261b8b48acee069b9c386531c651c32bbe0819e5108a658ea59b39bae003"
