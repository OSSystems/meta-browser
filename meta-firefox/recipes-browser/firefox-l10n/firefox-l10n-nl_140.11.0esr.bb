# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[sha256sum] = "63493b8c4cc505450d9a046622293ad9a34b26273972e07c46a990c74dd184dc"
