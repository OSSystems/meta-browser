# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c85ea0ae385bf8b484ac21efe5cd52a4"
SRC_URI[sha256sum] = "620e5773b8ee73bb11cd0d87f74c8327cdaf2ee1b69998cef926fbc9e71d3647"
