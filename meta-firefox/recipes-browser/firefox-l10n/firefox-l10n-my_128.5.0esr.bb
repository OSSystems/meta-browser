# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "10c6864851fa2c3b7a72e5458fd7bc4a"
SRC_URI[sha256sum] = "3eb340c053eb43275c448fbe7845db0439414e5dab51ad1a08f9b63bdcb81302"
