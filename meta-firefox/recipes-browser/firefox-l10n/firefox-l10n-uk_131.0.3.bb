# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e231a7f67a4b9c29a35b3ce1e3f27655"
SRC_URI[sha256sum] = "fe7cf85adceea45ef2fe5961cf8023e13a473749c68053f07452dd6fb0c0d579"
