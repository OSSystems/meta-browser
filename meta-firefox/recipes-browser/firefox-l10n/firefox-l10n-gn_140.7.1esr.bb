# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a47eca878a16a8d14de98a5a49834c6f"
SRC_URI[sha256sum] = "6412784b316c3c792cb4f68812ba9ca52f09cfa5c96dd00f26e6a823886fadfc"
