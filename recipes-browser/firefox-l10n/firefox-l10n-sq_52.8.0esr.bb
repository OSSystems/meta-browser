# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cceca6438ef354c3667f8afbc113b853"
SRC_URI[sha256sum] = "f9d6bb89af80e355ac77b59bd0d7d9088fb0e400fc59402ddf83bf6337fc7f1e"
