# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3790677f9ca2d6c14610317e307641c0"
SRC_URI[sha256sum] = "b0f419ee2bfb6cb0da3ebcf5f43f7d2b4435161b12ffc1d922946353b64ad543"
