# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5932d82abf864a376ed5d892179465a2"
SRC_URI[sha256sum] = "b2eff18982c8464b34455dd375b888d76f3b13b488c9ad1cd0c6e5075616bb6b"
