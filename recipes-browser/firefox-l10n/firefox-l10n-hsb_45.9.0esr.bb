# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e351fdeed0c4c8353903f9e116f6b3b7"
SRC_URI[sha256sum] = "89c0a24a4276e55a72bd339effa93ebdca2d0aa41281ddeda0bfc1a1f81da0ba"
