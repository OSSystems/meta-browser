# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6323793af1ec9c8c9a138d71dba0bb72"
SRC_URI[sha256sum] = "3f77022c3669c5d2c8a728c2027bd515263361cc7722c546662a56e9c63ed788"
