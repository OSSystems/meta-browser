# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9cf0f4564c65dbe766622ad0e2bded77"
SRC_URI[sha256sum] = "0d6dcfeec6ce9e4dba40d9dc0aa0d8e0f5d47949693efedc426d59c051da20da"
