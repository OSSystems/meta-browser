# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d98bdb96e56338484d092a6360b4b614"
SRC_URI[sha256sum] = "6e630bf5a66379abce2f9067fd8d9fa8633f714ece5e2ccc26a5164865a69137"
