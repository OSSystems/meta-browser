# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d6567490730fedde5b98a14a8cd1fbee"
SRC_URI[sha256sum] = "27ad1b840b755c8a5b58405d653a93e7c927a31f1a2581942eff08331c7c1fd8"
