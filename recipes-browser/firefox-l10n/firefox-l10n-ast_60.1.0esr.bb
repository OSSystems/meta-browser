# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8b16766560055e9f7b7ea11508e89941"
SRC_URI[sha256sum] = "b573efa4c86ad03c2750c17cdd1733fff0ef648578331ee669abf060cefecbad"
