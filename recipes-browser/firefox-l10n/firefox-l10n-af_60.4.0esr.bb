# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2760d2d6e1900923364b214004107ca6"
SRC_URI[sha256sum] = "533f29c135b81f87b4d0e16a1c1024bb88fb765530006346632dfcabae775efd"
