# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c70fcef07a16aee12bfe18ecd4d5ec58"
SRC_URI[sha256sum] = "0a9fb3717235352a72ba21707dc5bf15337e16a7cf16ebe72a9695a238d26648"
