# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c97dce8beb08d6e5a9117452cefd1f3a"
SRC_URI[sha256sum] = "693a74d9a97667fbd741f5db3ff3ee2648eefddb41fe53b0fb7a91300022d4c1"
