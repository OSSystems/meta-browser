# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "70ec166e133a8540926e755cc47adffc"
SRC_URI[sha256sum] = "fd95160dad8787ed8803bc8e98f2ef7c3e57df5e03a05013acb038753f82baa6"
