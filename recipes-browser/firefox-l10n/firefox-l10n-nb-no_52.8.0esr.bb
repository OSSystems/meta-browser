# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8af3e13838d6401c0c44e8b30bdc0eaa"
SRC_URI[sha256sum] = "0a222ca1fda65aa5c291d08bdc50807d674d05bb52ce77683c063bd768391b05"
