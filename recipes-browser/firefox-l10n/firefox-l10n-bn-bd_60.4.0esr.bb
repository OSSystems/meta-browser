# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "71711dd83a511482412159ff8fb13ccd"
SRC_URI[sha256sum] = "b9a405fb1188b9f9d0e412653ccfb3bf7ac0442a97fecdecf03a62e8cf45f5f6"
