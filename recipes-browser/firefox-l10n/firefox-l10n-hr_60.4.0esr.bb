# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b8fc2defc31bc967263381fc315ecd63"
SRC_URI[sha256sum] = "21b05b3332c8c417b21133291b9189c929339bd33ac85c0e133c1762e6899296"
