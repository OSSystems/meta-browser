# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "08d1c4be24bc5b6a5e407e726d221a49"
SRC_URI[sha256sum] = "1c6a6c1c5024a81df3f858ab8038c4228630d9a4eca073cabbe35fb884503ec7"
