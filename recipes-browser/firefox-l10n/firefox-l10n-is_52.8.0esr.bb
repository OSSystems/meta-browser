# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f78fb172989a4c38fe2602e099188be0"
SRC_URI[sha256sum] = "c4c3296f24996c35c9e18db7bbbcd4025c0a3a774d7af570b8edb6096fd5e1d1"
