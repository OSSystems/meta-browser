# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8212e9dcc89b65297b14a56ef2423c67"
SRC_URI[sha256sum] = "d8ab0f6ec310078fa7dac47a38cc8ede907080c75485a890df593063bfc698c0"
