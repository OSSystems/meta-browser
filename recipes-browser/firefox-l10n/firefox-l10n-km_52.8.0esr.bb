# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a7aeec32329703d954a3d81d17d64f3c"
SRC_URI[sha256sum] = "d6311f10d091e66902947db4a71fa4951876beed37b4c03e02cbffb63049eff8"
