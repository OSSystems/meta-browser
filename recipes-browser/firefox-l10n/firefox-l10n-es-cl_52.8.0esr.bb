# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b4536cc02c8928bd3c68f0447475b69f"
SRC_URI[sha256sum] = "fe09b523998ec03878a6198b0ecd93145340ee9fad37b0a891e252754af12fab"
