# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "397709d5f434fd61bc6987033321005c"
SRC_URI[sha256sum] = "eb437d8fb09550dab8660076185d8c229f5d3e7cde03698896dce7bc983d7671"
