# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c59ac694ce3c69f159946560d6695da4"
SRC_URI[sha256sum] = "9b67115c23cebe3e3ce57c3a19dd7a5afaaf98e18e06357c4eace53b4808f302"
