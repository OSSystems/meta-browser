# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "87ae315d7e2471bcf80cc34850c39607"
SRC_URI[sha256sum] = "107e399c050de243083d4d05a184de9ceb645fba067bd6c97ac6ba692f3cbc9a"
