# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ea131961747dd56023152e7fde399ee9"
SRC_URI[sha256sum] = "3fe481a37d2998050653e8144a627ed5aab6a6d096933783c705684ab64253be"
