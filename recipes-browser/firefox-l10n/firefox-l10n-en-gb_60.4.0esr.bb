# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ac9d7e5e13cb0a90e424d55d050e94cc"
SRC_URI[sha256sum] = "63ed16629f8abacc5246760e87878604390f5501bfaf81770cd9d772cf74963a"
