# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b1b21b8a51944f653204bb63726c781c"
SRC_URI[sha256sum] = "5488aaf2648dfe4b01bde08bba07e6ecd960ff39c85b0f63340cfde111dcb32d"
