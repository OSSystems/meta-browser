# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7739be7a455981ba5778d6e0d2487378"
SRC_URI[sha256sum] = "e427833cf0985c680732d5ff6c98e34d0c86caa4ed8363f822bfadc291d24f3f"
