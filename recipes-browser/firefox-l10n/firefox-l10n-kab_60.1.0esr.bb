# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7df7d8ff85be8b96e02b8278bb0c7c75"
SRC_URI[sha256sum] = "56f19ec2f09e6371cb499e2ccfdb0593cba6ddc4bf4aa38b76a5ad4f72c1ab06"
