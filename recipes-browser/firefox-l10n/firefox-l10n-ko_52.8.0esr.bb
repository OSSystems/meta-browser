# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7df487c0fe286aca3a69dd04db1c9f0f"
SRC_URI[sha256sum] = "ca78841e987df549a641e078e355c3ca025cdcf7c65124b610f0844ac07a6015"
