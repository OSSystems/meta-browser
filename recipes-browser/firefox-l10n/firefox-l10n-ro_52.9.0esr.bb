# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8ab784c95c9b7b1083a5be62b2a834d4"
SRC_URI[sha256sum] = "7d7311b5c059d86f5db629d7bb2fdd88232c138f911076f9533d144c139fd2cf"
