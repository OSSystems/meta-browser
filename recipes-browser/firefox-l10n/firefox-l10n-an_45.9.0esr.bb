# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a20b3c15c84335f03081d402d31f6130"
SRC_URI[sha256sum] = "58b73bbe48de91c31d9db40b5b9ed8b0a3894fd82653cff38449b88ec9cfd21d"
