# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ae8e3bfe55ac968baa440c6c8dd70895"
SRC_URI[sha256sum] = "17cff077070827b9eec55fc95fd26ceae58477b73b56b6943232ff87a235809c"
