# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "51cc5a855160c0976738cb3f8742e058"
SRC_URI[sha256sum] = "1c77961f575e7987507f5ebc7c91b8d104a0dccc893db6bdfc1ad4e03d92f760"
