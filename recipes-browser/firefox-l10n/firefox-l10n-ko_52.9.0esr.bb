# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c8978c56d6e055bc54a9abcef054844"
SRC_URI[sha256sum] = "465c5cf939297ea1a4b2725ac6b647f084a34000990f0c6bc2e755313c57691a"
