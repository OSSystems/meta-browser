# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3dac3de55a6b72cc051e13cfa971e67e"
SRC_URI[sha256sum] = "444a522fdcac5ce9d4901de58fa6e6fa9c5b8a772755c6d1eec120e22aa5c964"
