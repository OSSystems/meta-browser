# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1961d24dd3cbffc368bb2804f79f0d94"
SRC_URI[sha256sum] = "006dd61c7bb4582355fc5d50363152348a51b47ced2b81e0cc34a27c2a28f746"
