# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1371ef651bc81d558d358b681306c755"
SRC_URI[sha256sum] = "8141c6320d0e52a82f5a6574be227f193fa3491a3db4eddb0a6a39ac83f56793"
