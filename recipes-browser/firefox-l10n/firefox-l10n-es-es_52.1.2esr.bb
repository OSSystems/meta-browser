# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cea74e83e6d25a0ed4bcb443c131272a"
SRC_URI[sha256sum] = "f2bcc16a8162260776e51b8a9940efcc10eceb327f05336a932d5f323368890e"
