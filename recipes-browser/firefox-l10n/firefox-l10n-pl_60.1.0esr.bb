# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8366c8b5cf17b3e0be168af99e09a862"
SRC_URI[sha256sum] = "922e3ef88c349620ca5569fd1fc88ec7eb3d89aa17a01453044f8addf98493c7"
