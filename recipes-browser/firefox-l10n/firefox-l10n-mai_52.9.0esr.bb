# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a85393cd070be51e476e36f7718d3f58"
SRC_URI[sha256sum] = "5904ecb6bee710f6a25eb9eb4a70ce3b32cc921545f4d3aae089573a8ced89c7"
