# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "37c171324b0847998fea231edfdbfbeb"
SRC_URI[sha256sum] = "4ed55b788c30e1e2113ff6ccc02777149f1d036781dd87a810d1d759fbe09438"
