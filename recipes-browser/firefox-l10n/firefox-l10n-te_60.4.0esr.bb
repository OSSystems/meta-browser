# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cececa6b7d8cae4457006ef1d26170cd"
SRC_URI[sha256sum] = "1df0426f98e4096818c2c37dcf7c77d3f5c0f5f0ffe2a1f69820e4ee5ef9dad5"
