# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "94edb09570754c735f15f95be296a2fc"
SRC_URI[sha256sum] = "ac443368d345d2401f1e994f1f1698d5eea19af07b3fb7cf7d50b1d9662c13e1"
