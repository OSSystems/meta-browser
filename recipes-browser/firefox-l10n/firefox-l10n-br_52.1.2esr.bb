# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b098c2e26cec5c261e43c66f4973f6b7"
SRC_URI[sha256sum] = "f9bd1ddab71c6ebc25475cee597ef43e2292c5adac1f44d2c8a5be99460c9156"
