# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bd85477679f07f10627716343727b9cf"
SRC_URI[sha256sum] = "fbb71bf898b556476ddef5396c93daab30fb613229323c4ccedec789361e5db3"
