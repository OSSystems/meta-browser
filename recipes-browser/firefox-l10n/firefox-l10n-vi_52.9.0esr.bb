# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "27ff79da74e2d9404deb15cc245ac302"
SRC_URI[sha256sum] = "844dfecaf0156967b6c8ca031e1782f2afbfc7c057d15f3ed47ae3962f0dfca7"
