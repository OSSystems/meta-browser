# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2ae542d6abecd75cfdbed773b5e9e9d5"
SRC_URI[sha256sum] = "3f09406658fa066aceb85053897fba5c4798bc7e035ee803443bbacb2cc40293"
