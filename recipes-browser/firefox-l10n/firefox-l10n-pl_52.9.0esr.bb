# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1906658eff72947a2ca5f75d10b54f3c"
SRC_URI[sha256sum] = "a3431256dc89be10524babf7243ef48b366348166f8c6f3b33e7ab3dad8f6fa9"
