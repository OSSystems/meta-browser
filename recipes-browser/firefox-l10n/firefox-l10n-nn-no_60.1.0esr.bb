# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "92aee9e9add316b3b64f405e4dd7c9e6"
SRC_URI[sha256sum] = "09ab53e8ebcc306fe8fbe93c30fb2109be09f0428fb402145a970e9b5159b787"
