# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f18d2dd49b9df1f17c3dc23a5a1fb2f5"
SRC_URI[sha256sum] = "badc78dfdc174feb0b3c360ff6f087aeac2c00ab177768f5fc3d9db37eb03265"
