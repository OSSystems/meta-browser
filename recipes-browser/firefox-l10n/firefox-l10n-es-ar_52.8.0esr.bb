# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "73d932dda350e9615d72d3725dd4719f"
SRC_URI[sha256sum] = "e9830ef15fe651c794e8c912fdbe6deb9b611cca49f02c31b847a56e5def71e0"
