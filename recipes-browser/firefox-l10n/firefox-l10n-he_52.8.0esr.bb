# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "abd1eba6695524887ef4e2975f01a0a0"
SRC_URI[sha256sum] = "86917c56b4e7563db92a36d9facb9e41777d5751ea3357688946bd157f1c629e"
