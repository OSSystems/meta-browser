# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5fdceac7050f8aa20f9f54a3df8a0c2e"
SRC_URI[sha256sum] = "63ee1cab2c7eae881843b20297c5abab15185d95b2ed1061b7c21c0e81080212"
