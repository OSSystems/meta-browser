# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8731fcec9a4b53ecbe3123886dc1694f"
SRC_URI[sha256sum] = "c00ec788d868a77fe1b6fa1532ededef75b1339c803b7b6ba75e5029c0d8a4e9"
