# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9b98777d5cb0ff8fcd47f8c1d8df3462"
SRC_URI[sha256sum] = "9938e29a27ce91c3a9349a04848acc39107283b47c4c01a4517b3cbcfbb31bf7"
