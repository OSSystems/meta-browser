# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7f02a670d4f7ec958e0895431fbf782f"
SRC_URI[sha256sum] = "de5a59fc86a8f3bec1889b642eea1bfc0ed71306f6536e43028e75f004842040"
