# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "48be3eb7dd0059ef32eba3603ddec351"
SRC_URI[sha256sum] = "b30101831b319b655e75fa54a6805c9ccfa62918906b1fb1c5057fb3317c1a61"
