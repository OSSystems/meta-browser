# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f5c0280eba3678e1e134bf3dd4ca0e41"
SRC_URI[sha256sum] = "089f2bdeeedef607aa6fd3b83a1be73d24a1ecf59d4127689690ef0511b88975"
