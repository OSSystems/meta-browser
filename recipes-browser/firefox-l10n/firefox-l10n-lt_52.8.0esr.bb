# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c3d9958e41c254f0376ae317e4e83ac1"
SRC_URI[sha256sum] = "116b6981342e442f448c98289fd6439068128d2a0362076d9522095dea6f7320"
