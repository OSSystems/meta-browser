# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5b37130045f1c0d17ee9f73934f9a3ee"
SRC_URI[sha256sum] = "a174968efac5d26097b9c301df671fbfc441debb6120bdcc137e1159d324219e"
