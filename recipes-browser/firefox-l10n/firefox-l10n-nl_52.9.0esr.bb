# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7eba7eb6899bb554c8f5a675d7bd59bf"
SRC_URI[sha256sum] = "e87999ef3c49563295fe7229127c5c32b2a1deaed77d142923a1c02f1eacdceb"
