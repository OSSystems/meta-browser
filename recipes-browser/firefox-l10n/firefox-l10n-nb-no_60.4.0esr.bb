# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bf3062f0af415ff1bda7310ba3cca03d"
SRC_URI[sha256sum] = "e0b532164d0c205ad7f0ecb1c385056d594cd6739881eca9d3a41ad01b12d265"
