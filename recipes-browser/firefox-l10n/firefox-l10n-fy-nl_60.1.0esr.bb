# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cc42470692ce37871f3118add7245a5a"
SRC_URI[sha256sum] = "90b2d857414f4931745cabf1faa2893510d0e409b8c425389ffff19863cb69fa"
