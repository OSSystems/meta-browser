# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1f27a910f5a91097316f749501ca00cb"
SRC_URI[sha256sum] = "4ba54f6692543397f7694169dba0568331ef60cb09b9a5b08e8170a7bf6a75fe"
