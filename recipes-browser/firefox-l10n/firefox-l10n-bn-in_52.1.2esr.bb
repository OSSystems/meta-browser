# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cbedf940b57fab9d97fc0caa90b09b14"
SRC_URI[sha256sum] = "68203cf59545ba7ad3d9a3790d0f1479c4d73eb8b201d9d46ecfbb15ee4ecbf4"
