# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "73a955ab03400645047a76956bf295b6"
SRC_URI[sha256sum] = "73c6707f04764aa79b55c95d817751cfeac5ed01d08140234e6cdc78e277e4af"
