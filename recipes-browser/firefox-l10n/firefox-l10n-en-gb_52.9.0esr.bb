# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "441684c41d070f13477e35d118e8fee2"
SRC_URI[sha256sum] = "2d0c00c47132e19c470c23758df33d0fa5583efab1a3b5648b18148dded4e7f7"
