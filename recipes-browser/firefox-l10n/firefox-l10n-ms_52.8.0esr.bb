# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cf20ee295c7dec07efd16c823cc59909"
SRC_URI[sha256sum] = "5c8df679a379c443a5ac3416e0d3b21fd2ed5ef955addc7d0b09acd26085b285"
