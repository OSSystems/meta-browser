# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e44cb250e3203cc49809d2e09119124d"
SRC_URI[sha256sum] = "f9406eaafb6fd26a0ccf8d820bb5458baff1632d4872f9d3cd5b8ca5561bb71f"
