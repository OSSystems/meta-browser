# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7df30d3bce21792031138340c86349a3"
SRC_URI[sha256sum] = "aa2c2bf060aaf2d276899d8ce24e917adfc3dcdc1be7a17550ee783670d45ad0"
