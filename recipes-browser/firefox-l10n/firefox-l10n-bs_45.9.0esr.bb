# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db25a013fb3fa94b182b02ae52c96102"
SRC_URI[sha256sum] = "cbe471c092fdc291a025a5013715084d646713574ae40ef2fd79deeb4ce1968c"
