# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "66020ce09cead02033b54be32b10d88d"
SRC_URI[sha256sum] = "aac7e55a8f0394600861ce51bbdec6917ef6edf2de67846c308caaa64a7a0f53"
