# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ffba2c6b0fc859e06562ffc82cc61db0"
SRC_URI[sha256sum] = "72ff53312c26d78be381dae65c74a724d341989cf584a42bf23c8d4984999680"
