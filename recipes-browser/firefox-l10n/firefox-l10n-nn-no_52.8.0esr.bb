# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2e4856430f930719bc6e4774e781bd64"
SRC_URI[sha256sum] = "a98bf22c3ecc3225ebfbb310c84324e545ce85627461c1bff22008aa29f504d6"
