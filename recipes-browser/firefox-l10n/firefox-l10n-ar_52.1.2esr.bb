# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c7700690a203ddc81b758704e0f23d8"
SRC_URI[sha256sum] = "f66232c4280a297dc158fe739f59a9d3863e8d7b137bd0ed7d242474048839f3"
