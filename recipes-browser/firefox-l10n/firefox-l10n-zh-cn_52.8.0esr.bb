# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d9c49066bac757bb6f6484f7020e35a9"
SRC_URI[sha256sum] = "a1bdc0ad4365fedf3cd9cb87a58dafcc08333a79e0383cdf97a20e91e5a4f1b4"
