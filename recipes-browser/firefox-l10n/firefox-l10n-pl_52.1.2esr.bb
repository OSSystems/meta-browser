# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cc80739f9304c627c66ce99fb8e65fc2"
SRC_URI[sha256sum] = "6400ddb4d6a23864422f6f9666d6e3db35c926b0cd6591d6da6c411b407320eb"
