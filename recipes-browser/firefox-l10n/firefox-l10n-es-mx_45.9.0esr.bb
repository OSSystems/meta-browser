# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4d03e0039af8d315249bc0fa3f62cfb3"
SRC_URI[sha256sum] = "91811e06609d93ac1ca013ebf2e7678705a5f7bf4be8e1bdc4941c0601329158"
