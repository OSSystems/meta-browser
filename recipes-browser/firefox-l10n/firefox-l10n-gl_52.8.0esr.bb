# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9037e0f06d7b702f8664bcd935131eed"
SRC_URI[sha256sum] = "6ba049f809536745ba87e2ef459781f1c8ff99edbe08330edea157f4cf7056aa"
