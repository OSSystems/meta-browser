# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c21aff7c9736ce1c919382572178c2dc"
SRC_URI[sha256sum] = "94c98fe541f550881f718bd741b555bd934f97b9e0f106219ca84beb80e8e235"
