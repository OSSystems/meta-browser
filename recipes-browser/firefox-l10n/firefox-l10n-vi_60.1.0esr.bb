# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "93c1eef5f5ec3977a70f2974278465c7"
SRC_URI[sha256sum] = "c2503cfc42092643837ffd3c58c637157bdda76c63a3f5d209e5e251eef0feba"
