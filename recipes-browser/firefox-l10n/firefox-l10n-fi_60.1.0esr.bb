# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cf79159c829a69f112cf23c5f333109c"
SRC_URI[sha256sum] = "3a4624873bc81c5c021e120ff9ecaa24b60dd6173070dd9016e692deabc1b7a0"
