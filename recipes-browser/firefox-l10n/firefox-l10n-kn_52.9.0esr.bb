# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "189ca30cb18f3531435da0fa66c74aa9"
SRC_URI[sha256sum] = "ebffd88e898ad8aedefeb15d85628ecc02014ba17578fa01347e536c16eba46a"
