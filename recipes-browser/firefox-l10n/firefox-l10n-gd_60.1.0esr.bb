# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1bc92346c49e6ee839bd381736d68821"
SRC_URI[sha256sum] = "8cac6a092e724249fc691964d297a208a02a7b22f561099296328acc515f38cb"
