# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f2c5b81bd0f000155a626707d7256279"
SRC_URI[sha256sum] = "14291f4955b8d24f01586c4e2b46ef00cf2b684f83fdb2f62ee4a5eea8fac8a3"
