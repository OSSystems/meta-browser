# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c9cb732f9e78ef770b85406ea5d48177"
SRC_URI[sha256sum] = "3baf8d0aa2769c76e548ff41dbd11dea6796ef0a25558c9aa3c9447ad7ba3fd6"
