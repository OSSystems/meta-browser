# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bbe97c2d38a9660d73a36c2fc7f38817"
SRC_URI[sha256sum] = "553bdf6a60bded015ceeef002db99028c9334a4fc2825f9f147ac922f923b1e2"
