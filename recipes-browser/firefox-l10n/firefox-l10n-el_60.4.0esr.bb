# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "00156483815db39e9f1fcd3da3f8bbde"
SRC_URI[sha256sum] = "e4063533df98d216b95513782536c5df4ce61e3c1c04a16d5454767fb091395c"
