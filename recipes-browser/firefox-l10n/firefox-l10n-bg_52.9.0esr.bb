# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1bf20bd13afe59a4ee43f47e0fc8d2ce"
SRC_URI[sha256sum] = "dabfefa33d774e99047e30fd1ca2bd6049ed98d8ed7f1e70d92573b9c5ec8dd5"
