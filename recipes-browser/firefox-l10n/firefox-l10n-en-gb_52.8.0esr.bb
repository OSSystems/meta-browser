# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "367a69eaed4f2ee638f87951c8f85f5a"
SRC_URI[sha256sum] = "e5b5a6ff2e3d9f483b9afb425f5a89a25a3333db06260a2623faf2d7847a014b"
