# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e5e32f76b512875a26aeb160abe92e0f"
SRC_URI[sha256sum] = "2298fd3b2ff6260fe27a41f46efe98b5c4e17b33f8f21f5a6d74caea31ca8fce"
