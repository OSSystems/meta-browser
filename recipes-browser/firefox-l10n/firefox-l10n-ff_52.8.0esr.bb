# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "32aa15f25e46b53bf8ae040454abe3be"
SRC_URI[sha256sum] = "4bc09e0c823a44eff73d3a6e8500254f3e4296099428545c8fe8018a89013ecc"
