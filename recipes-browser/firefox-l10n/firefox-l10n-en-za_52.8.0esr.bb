# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f341a5188020a645e3999358afc9164a"
SRC_URI[sha256sum] = "0d6e4fcca8b7160a4c262229d06e61b116e3bfa8f164097d32e37ae53bb0a06f"
