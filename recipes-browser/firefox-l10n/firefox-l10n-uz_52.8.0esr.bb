# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "86fa0bab642976ed51c93ba4e31fe44d"
SRC_URI[sha256sum] = "f729000a17f6770423895af7d123fb0cde0f5fbe854d692a474a26a4991f6f2e"
