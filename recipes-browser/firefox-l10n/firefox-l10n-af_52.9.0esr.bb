# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "24537d244c8582821145cae3fe94d071"
SRC_URI[sha256sum] = "e271fa624527ff760878cd420942c704077fecbf723de22d3dd9287a60e076af"
