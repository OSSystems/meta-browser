# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "30e77cffa87240c55f51bc38f4a6791b"
SRC_URI[sha256sum] = "ee885bac2037837b25d6ee687bd0c2475ba7f124f400c49cf32318691fd8a94b"
