# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2bc5253d18e50e35f31addf42eb12357"
SRC_URI[sha256sum] = "a86a2e5af7483520191be81878c3db2a984cbf64e84ff76f0bd203d5a041942d"
