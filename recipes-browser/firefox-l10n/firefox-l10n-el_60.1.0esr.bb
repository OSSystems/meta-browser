# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "86daebb604ed4f51105660faae5f4d64"
SRC_URI[sha256sum] = "911f062ff50c4a5e4f4a7a7683fd6cd5b269e1522a09ae3af3afe76e4717862a"
