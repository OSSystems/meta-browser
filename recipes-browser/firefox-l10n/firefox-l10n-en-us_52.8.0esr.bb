# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f7e15c8ff932c648473d1d6adef966fa"
SRC_URI[sha256sum] = "e5487e67c1789fa15d3a37f5316f9204a9c871868720205c81d9b5c6bb2a4f9e"
