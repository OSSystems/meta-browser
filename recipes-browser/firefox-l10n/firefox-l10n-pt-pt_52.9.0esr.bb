# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7522d3fd1aecf2c56fe3f170bc73fa1f"
SRC_URI[sha256sum] = "7fe472ee9817615a200326c14556281b75a1190b5918725251f6b5b48793979e"
