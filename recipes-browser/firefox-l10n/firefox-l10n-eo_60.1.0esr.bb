# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b8b4a5c9b328296397925fca21a19974"
SRC_URI[sha256sum] = "1a061117b9bd79025fb68af98133cab976865a937d27a490a57232515e3aca84"
