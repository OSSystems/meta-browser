# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "48e14f0dae637ec1733ae56b1010fac6"
SRC_URI[sha256sum] = "86863fe00c62100d711e5cb5e300d9644615d40fa57135115e084d12e971675d"
