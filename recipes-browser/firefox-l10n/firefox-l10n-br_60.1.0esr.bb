# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7fd236291abf4e74b963cdfd6cbc513d"
SRC_URI[sha256sum] = "8ba1ce2937b77409c4021a97587b1766de8df07123eb76f33c01085a97d25014"
