# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d0ac9d48957ca9f208b44dc630c23b3b"
SRC_URI[sha256sum] = "43fdaebedb1c10d9706340cc4636e732cdd0288eee9a328a322e6b486666fa89"
