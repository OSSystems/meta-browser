# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a6cfa6219f860558810dfce24bca3893"
SRC_URI[sha256sum] = "f59ed6f6466815a47ba0e62bee6f589c851f1d6248df0ad0b439e31929e61338"
