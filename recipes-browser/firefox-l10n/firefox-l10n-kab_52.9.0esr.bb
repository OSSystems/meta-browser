# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f3519cf57762baa141f6e85853b54613"
SRC_URI[sha256sum] = "13a4f598164775e3a5fcffcca073460c5760294c54bf8d3b86c4d3e6354bac42"
