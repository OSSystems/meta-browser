# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "252be8e499a70f51c6a9a255478845ad"
SRC_URI[sha256sum] = "00bdbade3619e757805e043cf210bc20bc9ef67e7c5a7d2d5d87a921b782ad4e"
