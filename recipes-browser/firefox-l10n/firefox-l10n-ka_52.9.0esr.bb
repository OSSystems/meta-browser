# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a1d4bab666e4349d5820342e7518c890"
SRC_URI[sha256sum] = "c1aa4b8781925a68975a0e4a7ea419a8c2c8312fc5d81f2b35f5aabfa0a379a5"
