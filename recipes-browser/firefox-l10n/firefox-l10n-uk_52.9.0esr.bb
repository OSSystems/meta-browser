# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dcd0867090dba0ddeb6ff9deaab8770d"
SRC_URI[sha256sum] = "43a2b0033269aa6bce8699ef9cff2407fda2cc0ad56b924d0fb110cccbe5125a"
