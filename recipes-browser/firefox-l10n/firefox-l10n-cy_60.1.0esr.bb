# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8c6ca269e468bdb039449e4e99d3da59"
SRC_URI[sha256sum] = "a122b18fce6809d68f6ccfe94c4f6d8d84a709036fe5d4ff50f679eed87c4577"
