# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fe6a6e6e97f0b5ece6c71c27d259aef7"
SRC_URI[sha256sum] = "d902653a500d41d157148c7812a16118b65d321a5d5c9edacfd4a3e6276f3142"
