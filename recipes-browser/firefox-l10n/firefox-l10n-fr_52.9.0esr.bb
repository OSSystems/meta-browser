# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0463d99200b5f8679da7f6f2da59276c"
SRC_URI[sha256sum] = "d57f183a96c7d57502a884458839518b20b183afcf88662c5a3fac4198afa320"
