# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3297eec50b9bea8d0051d404a61a2a6f"
SRC_URI[sha256sum] = "c8f57aec50a10b6475ef4d06d7c2de794918c1ee17596a80445cf90c1e450082"
