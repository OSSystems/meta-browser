# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a2337eebb3dd7cda6045b786bed1f431"
SRC_URI[sha256sum] = "11e44f831003ed4cfb929cbbe7c7a9a80830b9d3e0da29cb2f40e8f042fd6ffb"
