# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "24367093efbd0fab73cb4cb4b2cf85a7"
SRC_URI[sha256sum] = "5347069b88b0020bf2bebcbf7fbc6e397088ac74e046458e4aaba9c837c211aa"
