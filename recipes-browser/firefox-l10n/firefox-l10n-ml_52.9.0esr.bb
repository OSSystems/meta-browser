# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5a55e20139991165cb23cb2e0c13c896"
SRC_URI[sha256sum] = "5da1ac0f791df172435fe6e9dc0f8fed5a54bec5bcc219380718b6dec0739a56"
