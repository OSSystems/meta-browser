# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1280d46d552929eab297274e801afac6"
SRC_URI[sha256sum] = "348b9a59d5c621e807c002be4f57f616ed51da2d6e750611bb18da9081a61b42"
