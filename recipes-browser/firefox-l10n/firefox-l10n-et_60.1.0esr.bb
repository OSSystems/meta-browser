# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "03a47af11ab99be2d099872692a3aefc"
SRC_URI[sha256sum] = "95db9f64700f99f0d8a28ea709dbda62a4d9d5ef9c0acb5f224447c779118151"
