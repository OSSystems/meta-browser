# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "76a1a8857ae0063308067cc81956967c"
SRC_URI[sha256sum] = "645562039d5017658db4bfe0ba09334a239a78ff8fc6a6b39307ee3e1e5affdc"
