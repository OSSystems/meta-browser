# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "62d1338005d30fd48788f7847e51baf5"
SRC_URI[sha256sum] = "735f3c8e1338943b4a44a6726a15ea79353ba4abd65cd490794708f5b196c5b6"
