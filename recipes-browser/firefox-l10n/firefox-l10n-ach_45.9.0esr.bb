# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "68e228241c536c9f96d0a71bcce76716"
SRC_URI[sha256sum] = "386b918b126d859727ad556f3b2d1843c286e39b78ba0aed9ff83ead9e46855b"
