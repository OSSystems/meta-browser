# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1f4978924f0c70c2fb76c58d6f5fc75d"
SRC_URI[sha256sum] = "2e794d017814967a4a142d53c8d6004d8f15f85d42b1d9d31bef989f1ee147f3"
