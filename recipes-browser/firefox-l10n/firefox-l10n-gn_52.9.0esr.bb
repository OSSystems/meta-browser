# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f1608420a733c504f0679816fd8deb7f"
SRC_URI[sha256sum] = "bb5829ca7512341d4d5c395ecfda75e1d8a1f66725032f09533c60bfa7c32efe"
