# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "80d7f631308f45f48b8fdd9e05c975d3"
SRC_URI[sha256sum] = "b029a2c9828c8f7fa4161bc7d0280ceed8ae23a1fd1f85e8052dfaa288b60bfd"
