# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c041df6265d86b995e3d2d4ef6c190a5"
SRC_URI[sha256sum] = "b0b7ffdc54d1067f4405f33a568941d738dcc0ad9a045b66fc50ca4e05a25f2d"
