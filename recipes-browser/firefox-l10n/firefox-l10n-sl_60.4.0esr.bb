# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8c3c134994f70031e48dd91d71ab6e37"
SRC_URI[sha256sum] = "9e892bf500c93a414ce4b9ec92f41241cd7b8fae45379aa5e0bdccb2c931370b"
