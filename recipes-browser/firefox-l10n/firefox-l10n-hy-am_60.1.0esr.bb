# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "28ebc0755448666c20efc21f2760a6f5"
SRC_URI[sha256sum] = "cea3206f2fd2a5019fe93217ad28bd16ffd119db1ed566e834426a7277090de9"
