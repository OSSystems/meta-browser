# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "314c36a50a8894ffaf02321b66598ecc"
SRC_URI[sha256sum] = "eb1945549347a5aaca3512e21cad000160c1893adb5c1056c10fbf5981dc9056"
