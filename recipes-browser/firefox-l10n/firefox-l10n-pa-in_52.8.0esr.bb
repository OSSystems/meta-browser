# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "16bcab569c4b7624bbcef1300b05dba5"
SRC_URI[sha256sum] = "10dffc15f93c9347a6ce6c2ca53877057fc758a8c3a3e7777ab5858839072f9c"
