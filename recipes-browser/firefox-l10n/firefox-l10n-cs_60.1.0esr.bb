# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "080b098bbc52e0dcc51b5b9a715a15b8"
SRC_URI[sha256sum] = "f4fa1c7bb1e276c7220f0c33a5968c660f00fb5aa2c412c033034355fcba9934"
