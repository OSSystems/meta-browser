# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5057d330181d6840b28f0f7c977588d1"
SRC_URI[sha256sum] = "dca41d4e38dbb5bae255108f7ee853579346ecfe50b0572a2c7c7a04b969913b"
