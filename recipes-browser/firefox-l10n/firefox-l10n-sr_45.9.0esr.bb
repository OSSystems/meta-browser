# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "840828582d069ec0f1fa24a63b6e22fd"
SRC_URI[sha256sum] = "32a7750a3662bc5b667ad48b38a662ee491389c129ea36b94bb25759ce05e8ca"
