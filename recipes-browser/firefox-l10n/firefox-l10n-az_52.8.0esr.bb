# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e9155cc593f0350ccf466f150d522959"
SRC_URI[sha256sum] = "e33318ccee8f9d51af79939a8ff0bb8aede9c82113ff28bf67bf53b9db6acce3"
