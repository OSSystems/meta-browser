# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6b004409e2c0e838a030960531ecb519"
SRC_URI[sha256sum] = "4838a040484a5e06e641c05f04f83c3f69b8e6c214e38589e154d53d61e96004"
