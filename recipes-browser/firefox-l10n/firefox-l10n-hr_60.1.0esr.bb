# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bde44ea6d6a6de12a8dde295c2fcbb63"
SRC_URI[sha256sum] = "c144c9859ad2e11b444093d7c1634c391e4e9f69c20e979bceccf5c90ef0d505"
