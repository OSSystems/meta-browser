# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ea009222cedfaf32c733df8e2ee532eb"
SRC_URI[sha256sum] = "c2fce043ab825b8deaf9af167c5d668be2377548d2d5c339fcda4416c9cee35b"
