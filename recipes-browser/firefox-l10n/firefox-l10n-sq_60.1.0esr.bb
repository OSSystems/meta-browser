# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ea46eefbf3c234d0b90cdba8dd2aa0d2"
SRC_URI[sha256sum] = "ebd86328ce004157fb66fbeacc887d446f82df6b56da874a266d5bd83431dca6"
