# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "60335c73158a22ee49cead8043ef22e7"
SRC_URI[sha256sum] = "07b3a27e36f2cec1e44f892c4bfe59acf7b61299c5a903195706c696e1ca6fc4"
