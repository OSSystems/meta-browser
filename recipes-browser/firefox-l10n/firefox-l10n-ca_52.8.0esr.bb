# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "020d61e92943d5befa12726256bda775"
SRC_URI[sha256sum] = "8c8f8c8ffc64e435b29f9ed8751c6006fe9a665e754e1a656d78a06b9f989b0b"
