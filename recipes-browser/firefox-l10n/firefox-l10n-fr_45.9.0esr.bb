# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "995221a4b2f84bf5a95d225d1f699410"
SRC_URI[sha256sum] = "36db31861fbadabb47d57642baaeeb1094e3cdfb649991f8c4ac1397f557984c"
