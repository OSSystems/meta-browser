# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d07b18688e921272a2a2e14d77514e00"
SRC_URI[sha256sum] = "2818096eea89b3fbd8a77a23e587d8770ec0f5175f1bf7838c2db8bb7456ae1c"
