# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "40323fee0e5fe562523479b8ced336d9"
SRC_URI[sha256sum] = "4bc7a88ffa5a025f1eeb2533ede56e1b76259df57cba6bfb30acc82b48ed5a7b"
