# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "799941355e9e0199f9980f4c037cb2ef"
SRC_URI[sha256sum] = "299c6aa5305e5accf6451331b0df513648e7e075cb7df23f7c7317699f829bee"
