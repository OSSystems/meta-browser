# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "84f96b61be420d73a05cc39b1dee901a"
SRC_URI[sha256sum] = "1a58e3ac6b8cbe8e747d16bc1d0e14f5f0091f168c3823794d049d6d32ccfacf"
