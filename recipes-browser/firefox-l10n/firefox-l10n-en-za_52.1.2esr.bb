# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "29a058835054a2ab39e0c08943ea3982"
SRC_URI[sha256sum] = "a6ee081b4e77e9fb9bce5658984f475e31de1316b53eda250cdd52fc53830a66"
