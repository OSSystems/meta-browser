# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db4f818d31e08b8a88374460e4f0377b"
SRC_URI[sha256sum] = "9da67e7a18168ccf4b3b805945c2dffd75f7d1574b05bb384049bfc3e29c37f3"
