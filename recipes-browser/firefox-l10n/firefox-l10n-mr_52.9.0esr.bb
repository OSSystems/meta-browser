# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cab1b5b68c0ae90de8976ccf1d9ef1f5"
SRC_URI[sha256sum] = "dd9da1a0f0a33c2fcc6a9a149c97314478d62471c33aec00f0324836b894748a"
