# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3eaa0f260884b0215af790a37ba15264"
SRC_URI[sha256sum] = "b1c074e5f191bf464911fbfcf7b77bb6b7207a70f058afe9660ff2b877b95c71"
