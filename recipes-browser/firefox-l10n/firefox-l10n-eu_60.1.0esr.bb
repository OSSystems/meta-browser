# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "53df4b0c69c9e37e877b62a71d24c78a"
SRC_URI[sha256sum] = "3800f915928f8355ffac255f5b9ee84e798f5963ae4ff99edf59b8fba5475838"
