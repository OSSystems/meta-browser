# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "88ea37c6f4ffe6523a35ddab6c08ced2"
SRC_URI[sha256sum] = "1f315900c784eade433d5ffe6d5255151532212b0a0d40493d6e383359586d69"
