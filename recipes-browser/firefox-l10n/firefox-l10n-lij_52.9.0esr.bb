# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eff2f52e0cb0d61056bb6c5ee435e58d"
SRC_URI[sha256sum] = "8c38efcfb7b55a05c8435a175b08f3f040b9ba670e658b3c010c71aa758242f4"
