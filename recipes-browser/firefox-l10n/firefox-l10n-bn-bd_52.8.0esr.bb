# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f54c4aef09722dd4e1af91d2a99f8729"
SRC_URI[sha256sum] = "8b0beccda82b82ae4ae3c6ec8aaa8f5650848a069d7dbd6a9ae9332e9131bc26"
