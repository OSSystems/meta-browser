# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6a642e097e02884ed6c2745e44a01170"
SRC_URI[sha256sum] = "a2ec87a777f6008b6ea3ed7062b72ef3b331c6ca9c15a1f20177a414daab5526"
