# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ea0ac8470708784a3aa1a9147f88e832"
SRC_URI[sha256sum] = "a59a78a08c5116b103304952f4abcaa347bb9992d49ac0e6251d32258b24fcf3"
