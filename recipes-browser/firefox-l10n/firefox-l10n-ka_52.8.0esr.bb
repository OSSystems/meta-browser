# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a0e8714547278dc82ef0541003dc9859"
SRC_URI[sha256sum] = "8b0d1d355dde3d69d5f926a7a40b9f2a35c9de6c62b09c05f034f553908cdfbe"
