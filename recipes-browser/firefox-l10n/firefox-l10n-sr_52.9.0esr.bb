# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2291d9d91cfafecdbafbd29428bd303d"
SRC_URI[sha256sum] = "ba95f83cd63abf7518e98ec71eed90a47f4fe43e1ce1215ef047663935543d43"
