# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0d9999b79f41da586db56a1d082eb07b"
SRC_URI[sha256sum] = "ea3be1ce23f549b99de19494bb6c1ea0804ef177941fac01e1a62c77919ef1cc"
