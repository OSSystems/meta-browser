# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0f487ec6165feac8fddd3f3e223ee3d8"
SRC_URI[sha256sum] = "54fb6ac376972b7355fa21054be2921bb6d78770a77b1d6564c5bfe58acf8cca"
