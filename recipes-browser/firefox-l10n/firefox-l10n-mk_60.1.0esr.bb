# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cd17ed4fb66a558e29fff0e308d63c5e"
SRC_URI[sha256sum] = "b377a9a7bb7b1a8e121cfee605d6038655a9688417c6665e4259df74039d89e5"
