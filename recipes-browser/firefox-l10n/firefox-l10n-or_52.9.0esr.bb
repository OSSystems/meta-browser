# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4738a0df7351c773646a71ec212b815b"
SRC_URI[sha256sum] = "e6d616793b35f5a3ec08eaf21a58fde941f4e704478ad728e754d3b9db6a9df6"
