# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "077640024fe505997d75581d8456d2aa"
SRC_URI[sha256sum] = "9f7226ad8764daf416147b859a54416cb020f324c3f956c78c806e7259ec56f5"
