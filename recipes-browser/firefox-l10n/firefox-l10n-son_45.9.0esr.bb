# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cb26a9685ec7e86953a14e4920c6e774"
SRC_URI[sha256sum] = "3a90a2337400db9368def1953f8ab2013f12f867d6b767f2c1a372c9f3f8e02f"
