# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4076f0954b95d3c16000b8c882a3f9f9"
SRC_URI[sha256sum] = "0a9109c3d40b9dcfadc39399acf805182e8713fcc8f600e472b084289c30277f"
