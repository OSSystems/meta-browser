# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f8588495989ecca0f1e80a5689617c7a"
SRC_URI[sha256sum] = "0236a1135483a6dc90c4b059f73a6c549b5f1d466c8dd7c934f7d18c76fa1c2e"
