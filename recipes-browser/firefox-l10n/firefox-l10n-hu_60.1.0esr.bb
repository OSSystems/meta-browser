# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "260305cfecc25571c26149e4fc148002"
SRC_URI[sha256sum] = "c46a58b003016b1b5b313299030d2182a7bc30c36d0a164a035753f1c4ce5bda"
