# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "475a66b5bce7be4978c85570f4a9b534"
SRC_URI[sha256sum] = "452c73e8962c3ed2858a95e69caf8afaa432e6c3a0f6b3c04b1d758e8b0aadf3"
