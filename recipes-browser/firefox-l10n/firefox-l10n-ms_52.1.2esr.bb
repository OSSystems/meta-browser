# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b7de4a93ab296331a1f7269a3e9b4ca8"
SRC_URI[sha256sum] = "1f22477d03c7d949c27a18b69a9f3b80f24346b04a54b44d74f7c7fc77540afa"
