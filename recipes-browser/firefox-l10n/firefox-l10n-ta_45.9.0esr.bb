# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b8a4deea418a71955d1372d49f3ca245"
SRC_URI[sha256sum] = "eec3b7b25bcfdb141c02d462ac93ce44ab112848ea23f0e4e7f975ab77cfc67d"
