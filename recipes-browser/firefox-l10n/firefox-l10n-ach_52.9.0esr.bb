# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "63e954da9967baa335281e5bbed5a28f"
SRC_URI[sha256sum] = "f0430c3a56a450f4bf5c21caf847a279cb19e8a5373939a13f537f8b7bab7367"
