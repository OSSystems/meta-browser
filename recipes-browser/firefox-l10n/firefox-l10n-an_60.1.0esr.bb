# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eb9111f31f1af8f8e18aaf08f911152c"
SRC_URI[sha256sum] = "2bda3e03f74015d7d7e8af3b437c8c11bbc6f6d6ad915871c8f9fbeae3dd6863"
