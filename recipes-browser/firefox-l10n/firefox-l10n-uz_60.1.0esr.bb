# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "69016e2b5469753dfc2c01c164822eae"
SRC_URI[sha256sum] = "c662124bdbbe1984015ea7f1e460cf19152e5faa996959b0bbf78eb2ac69f8ba"
