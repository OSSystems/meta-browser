# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "50822bb77510839b0ff883f22b74a47e"
SRC_URI[sha256sum] = "03c7d40c2df94c8d1a1e838b22aa974d86ee50c5f61d735da8802b1a5ae04d85"
