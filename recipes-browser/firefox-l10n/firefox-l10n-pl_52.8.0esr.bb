# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e7cd9560509ad1267e9dc6b3a591efbb"
SRC_URI[sha256sum] = "ebc90628adaf91bff4a2dbfa3bedb0bdb363cab180dea7b341d048f6a494c739"
