# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ede573e58688d657e1e908a60a52bd96"
SRC_URI[sha256sum] = "b4a37f8336ca24670c83d9efb92ffb4ed263c1a5d3a9bf4219f887eb80ea5d90"
