# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d7f556dbc13b7f5ec25b6354f04a3483"
SRC_URI[sha256sum] = "19fd25e53641298c2d726cda6ed60a1bf978813331405b04adecb101213c545b"
