# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "43989ad82f7f124f18abda42d1b758c1"
SRC_URI[sha256sum] = "39fb0edef74f72e6fbe5bbacb75c65200f3b4da2e34f48a0dc11d21bc665f4b1"
