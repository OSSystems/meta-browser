# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6b25d89a55ec93dacc33491cd1e5a08a"
SRC_URI[sha256sum] = "34147575109ddb584dcb64d79d0e52f3fb923816269e9322c967a78b93c7825c"
