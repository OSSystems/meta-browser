# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a6531a28893d546fa04c64d30c6fcd09"
SRC_URI[sha256sum] = "d3692c2cdc86a60b5ab872d3ae70805c7623636831adba34759c99fe4760451a"
