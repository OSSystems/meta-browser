# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "65c4ae5acb4afa8002139bbb9ec6f8aa"
SRC_URI[sha256sum] = "5ea9289e509f62ac2315db1d332741a31d935cc02b9ce3af36898b082f293d9f"
