# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8ef08ce22d6b3ec01e73c5081be2f880"
SRC_URI[sha256sum] = "5ae3a134fc1c14bc8547532d1848ba483f1e0d4faa7119d6615c35f0656caa7d"
