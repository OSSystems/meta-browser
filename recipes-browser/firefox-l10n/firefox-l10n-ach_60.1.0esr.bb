# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "12500da05035fef6432e604a76e47a24"
SRC_URI[sha256sum] = "867c8917c20bd264ec7388438468c861b0684980640ee9f2d35e90ffc78bc48c"
