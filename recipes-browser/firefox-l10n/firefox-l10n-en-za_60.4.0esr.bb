# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "adec098c6029045ed0973316eaec91d5"
SRC_URI[sha256sum] = "0c1b753e59455191a79d5f11c2dfbec7778dbf39242eb49a668c5eb297fba33a"
