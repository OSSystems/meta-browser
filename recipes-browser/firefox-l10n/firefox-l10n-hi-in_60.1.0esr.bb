# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3bcc6c9abd8642599f311c411d562d8c"
SRC_URI[sha256sum] = "0c7189bbf9989583754c63705d724b6968e5f56c598705943c30febb4a4f798f"
