# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0a5e25b6c6578257b6d0510cea1cda61"
SRC_URI[sha256sum] = "c96116a11b70fe005284aacc6b9c5758902667c5e412a658665390ac505b7857"
