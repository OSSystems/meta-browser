# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "757f11e0dd0fe7d5c30dff58bf87196a"
SRC_URI[sha256sum] = "15b2d810761ea44828d5166588143b631a8341414a35742c2985142260464faa"
