# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eb3eee2d004c224342f0a746dbbb1b05"
SRC_URI[sha256sum] = "d4cba3b4eeffe4d538a2d7c641dfe022cb0b12b32eed40824e0a63216f610207"
