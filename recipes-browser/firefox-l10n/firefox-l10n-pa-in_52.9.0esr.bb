# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c9fee9a6deabff72393d266b00f5cf21"
SRC_URI[sha256sum] = "15705ba576cc09df020e02b5fa1e98039e6438daffaf44ef169dbc3da352eba7"
