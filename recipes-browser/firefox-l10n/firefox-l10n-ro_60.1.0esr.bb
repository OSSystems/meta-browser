# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "36c3b7e9ee60e618ee357359eaa7a96f"
SRC_URI[sha256sum] = "a780f52650fc9f88543bc27e51ab8aa2ffb5462415076ffcb36ee60d5e9d74f0"
