# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f70751cfb361b27d4596736ed3cb68a1"
SRC_URI[sha256sum] = "d73047b8c868acdd502498fa0731d672f4e8e50e55fab6661ad1e8b68e03d522"
