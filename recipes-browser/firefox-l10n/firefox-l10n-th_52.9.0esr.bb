# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0cbbb9bbf4b4d5dece17775063a8e4aa"
SRC_URI[sha256sum] = "24daaab49e4b71be426ef7276d556edb22fb8c53bb20f684fae1985fedbe2ba4"
