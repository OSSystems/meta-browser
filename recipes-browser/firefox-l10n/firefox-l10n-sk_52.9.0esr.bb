# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e378ceea8efbc7f62db242f959452ca3"
SRC_URI[sha256sum] = "ba88eec4cd462d636662529ed5757c359d9a684b3659dfcfc899b5863c07a552"
