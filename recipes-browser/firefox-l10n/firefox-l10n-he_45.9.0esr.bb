# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "34eba4b6f718a554b6b4d08c4c12b289"
SRC_URI[sha256sum] = "e4eddf7610cdedfaed953b9fa1464d0ac7c3709b40eb8cb442be9656bd03b5de"
