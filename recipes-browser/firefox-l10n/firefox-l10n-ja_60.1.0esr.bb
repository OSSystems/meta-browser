# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a61b3ad9cdc059698436b14d04dd9e27"
SRC_URI[sha256sum] = "57fa2f696578a662b9487b542612ea9397df55d0ca4c42f05d438fbbbffb10f0"
