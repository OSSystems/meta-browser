# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "763328b90106516f97e4796e6650ed8e"
SRC_URI[sha256sum] = "fe9d9df8b4437d3bb9b160dfef6e908bb88ae99546a6a05691ea68417dd96816"
