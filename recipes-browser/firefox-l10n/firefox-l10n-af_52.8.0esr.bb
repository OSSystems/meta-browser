# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9be70386209a4da65a607028b37f1530"
SRC_URI[sha256sum] = "d7645158223413e16473bb56a44c7c04ab8ef7b3ff7da6cf02f4ece06ac9d454"
