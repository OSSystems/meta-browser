# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a88bc24b042a53ccbe51f90a8b10256f"
SRC_URI[sha256sum] = "3ae884cb20575234921b7a6c1b1839e6de6e59c1cd9b18276fcb9a2afade1564"
