# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "002a3866e55957568bcf68ec125a45bc"
SRC_URI[sha256sum] = "32525901fffdf3f61d6e3654276e61245174435b53382d87d5d8d2448e52341d"
