# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eccc6ef0341151c59bed0003de1ee5fe"
SRC_URI[sha256sum] = "f70b4b250a9ca85640fba8467293a0b52f2882d53694edd80abc96b13df13d69"
