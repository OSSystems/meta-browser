# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "698e639ff494cb044358ae0a1444f71d"
SRC_URI[sha256sum] = "a837d5724e77fc8a7983caa7cd913dcb52588c807f21d27f502d426430059acf"
