# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "892c22a450dae99d991981b44c96b9c0"
SRC_URI[sha256sum] = "d49e7d27523f94d4ef577bf892492ad5ce4ad832e2e33fba4333f86c927e9583"
