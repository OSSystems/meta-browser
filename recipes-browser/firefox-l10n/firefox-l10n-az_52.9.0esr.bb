# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d68f8e404f4a0aab56d49740940cc2c8"
SRC_URI[sha256sum] = "9eb05526f4e3fe539d3c756d617cd50780116bbd87a3eda5817f156c30bfa286"
