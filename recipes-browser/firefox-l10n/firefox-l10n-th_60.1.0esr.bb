# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b1caadb0cd6bf7c28ce25d4e7c5aa5d6"
SRC_URI[sha256sum] = "21dec21431a0675c3e60bf0650a5f3aa7791c9d519c5e89ee5ce5ac574e84675"
