# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "77c032272b4448cdd0032f76c9c99e87"
SRC_URI[sha256sum] = "c611343e3305c61c0bb3fbe2b9a54efea092e714930bbe3f40c0bdb1630a9d5a"
