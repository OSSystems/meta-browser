# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b036ab90063110acecd5fea38c0e020a"
SRC_URI[sha256sum] = "2f3dcc166342d083a5bc072ad4425e38782696e7c6e1bf96d254b3208b263676"
