# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "48eeac4dda2e689d9a42e89aefd04a07"
SRC_URI[sha256sum] = "7372e838f62ceb8201e528341a177c496cd9b713e66e746d7131ea14d49d3b87"
