# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fbab2e90b10c5f36884462a0d1c58eb5"
SRC_URI[sha256sum] = "3750f9cff8cb57112ed31984c13e4955dd632ff84751da65631e111cfb76811d"
