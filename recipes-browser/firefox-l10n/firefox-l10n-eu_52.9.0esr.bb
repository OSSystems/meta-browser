# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d541b6836d96e4ea3e05c57eb26d8670"
SRC_URI[sha256sum] = "63aac2681aae850d61b69c0411013ce2ae2c56bc428f174934668a3affd5f3fa"
