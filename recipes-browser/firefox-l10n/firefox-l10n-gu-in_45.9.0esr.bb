# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9b6d0886ff74afe366fe3cb7b50a4f85"
SRC_URI[sha256sum] = "d474ef1f0cb670dcf76ea643ae97ed0d4a185c3fd590907722bf6e0bbed8cf23"
