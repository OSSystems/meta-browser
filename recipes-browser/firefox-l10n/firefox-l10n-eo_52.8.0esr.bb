# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bffa57fa5b55ad77449ecec02a7fe061"
SRC_URI[sha256sum] = "24ea6ff03bed39895d0c3f6cc4432fba6d58bd42814efd2dacfc12021090a2d7"
