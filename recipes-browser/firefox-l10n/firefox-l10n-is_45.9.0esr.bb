# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "26073f60047c585035be26c9e830b613"
SRC_URI[sha256sum] = "d8cb5caef1e22a8fa3a928cc60f576e41a52e720424182bb895f1274a36ad13d"
