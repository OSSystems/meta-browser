# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8f667d46758640dc67c822741f32f24b"
SRC_URI[sha256sum] = "dbad8461140a9bcc5677b64af330adc48da4a5c2a140e10b1fced2f8229b526f"
