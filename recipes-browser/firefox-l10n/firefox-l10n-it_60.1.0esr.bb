# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "19264fbb58aabad8deb219dc6f41b32a"
SRC_URI[sha256sum] = "a118b8799c1916c3b6bf211ba926842e5e8d92943429d8079d382a29bf39643a"
