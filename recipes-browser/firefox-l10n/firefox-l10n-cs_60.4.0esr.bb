# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c872d51eb9182790a01fe09b996c6f84"
SRC_URI[sha256sum] = "61a1b2ac458acb878b117c1d6c69a84754d1b6aa0c0cabfb4949dab8c4d72e12"
