# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "182ed13383782e6002be4ac733a6abe3"
SRC_URI[sha256sum] = "d8570f7716ad0b1e9fd59dc731f972b0518dd2dcaa1e41014ee6ce1de24795c1"
