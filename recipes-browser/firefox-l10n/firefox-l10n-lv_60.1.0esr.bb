# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b8b351618ff921cb480269ae71816702"
SRC_URI[sha256sum] = "5edbfe26bfe997991aac3e5b949bd36de286502b8fe1fbfffaade6e4366aebe5"
