# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c894a1e2027a108638a477515af7e071"
SRC_URI[sha256sum] = "9671b66431047b3c4425893557018cf01a3d07b081f74201d05832312a08ad01"
