# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db23a16cb7bdd40d974467db4026872c"
SRC_URI[sha256sum] = "2deb102c37e8d5dc006ad1eb551f17fd0363d3930009cd42f2057a9432872663"
