# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1600f46ecd12479beac8f794df57587f"
SRC_URI[sha256sum] = "c07c624b39f030e2b670c7b95df82ce3118af2a46c9a4ce2bd4d24c3405a1104"
