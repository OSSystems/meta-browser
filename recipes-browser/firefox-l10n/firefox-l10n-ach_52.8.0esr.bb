# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f2ee22a27e7a57db3f2c86e2553cbb99"
SRC_URI[sha256sum] = "0c069738a285dfbc4d5754086cdd108ae36ca89e5ac08cecbcc42e972a5d275d"
