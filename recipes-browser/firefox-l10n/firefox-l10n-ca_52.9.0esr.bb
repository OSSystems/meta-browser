# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f9147aa515aceea86251bb35fb1c8b82"
SRC_URI[sha256sum] = "66a1d3ba08d4324706763eaebbe4b4d60b02fb6710187681100c342d7d4b5ad8"
