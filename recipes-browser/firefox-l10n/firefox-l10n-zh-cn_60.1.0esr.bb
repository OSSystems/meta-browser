# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "44f163435d28e7bea0785bad77efa441"
SRC_URI[sha256sum] = "efc811e67abb016227c73a56163d7db0877f0b3ab09c3c02382baad19a87981f"
