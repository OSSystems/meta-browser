# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1c176ec0c99b2dc27e6779d24b8ea5cf"
SRC_URI[sha256sum] = "94fa4491de8d2bf7b881c14ba1f3ce05e9731cfaf7a7809c00d3deb9937121e5"
