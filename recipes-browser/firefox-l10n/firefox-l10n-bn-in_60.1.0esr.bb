# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5c49ae6631eeea03ecffdfab763b1d23"
SRC_URI[sha256sum] = "544db0c07e39c402c09c69e485697305234cdcdb3a8cda100c411f063ab845d6"
