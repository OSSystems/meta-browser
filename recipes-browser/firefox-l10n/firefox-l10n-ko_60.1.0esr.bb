# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "66705aa99571516e72f08142fdf98748"
SRC_URI[sha256sum] = "861c9a887de3e2ef71eaa96c4b1d63018a854cacd94ce7cb9d7ef77fdea3557a"
