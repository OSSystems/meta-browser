# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b75c99ef2099b821730782b7d09d99c1"
SRC_URI[sha256sum] = "9907eef05e38743e66758248a7bf52edf2d4e9d22c82b437ba7deb920e5da9c0"
