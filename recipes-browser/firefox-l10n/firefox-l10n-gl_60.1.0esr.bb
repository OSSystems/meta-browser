# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1f3e1c418ea2cfbf64ea3aa718fb6d6b"
SRC_URI[sha256sum] = "eca1eb8aaa5ce2a1545117213776ccb3033efa63719490937d635e00f4e8d118"
