# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "013fef8645eb51f8dac8e53fd310cc9d"
SRC_URI[sha256sum] = "1b3225c9346bc73dbc0458ef2f92739f5a604161653f21437d49729241f904de"
