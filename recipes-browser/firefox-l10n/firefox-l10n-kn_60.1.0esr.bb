# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "398f648323aa4b4d36b18791c5926bcd"
SRC_URI[sha256sum] = "3721d0e7cb25f2b7b094b51a661f5dc673878b5b16cfac199b295cf77043f953"
