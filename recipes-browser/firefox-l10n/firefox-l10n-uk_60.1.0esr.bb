# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5787331c0da2ae9277cc909ab2747249"
SRC_URI[sha256sum] = "db131538fe253ba19739288f96f290dafbee8280f13d85476e00b9735c4d1745"
