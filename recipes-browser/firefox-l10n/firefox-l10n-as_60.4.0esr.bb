# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9dd6c833a1137def85c8b172526daecb"
SRC_URI[sha256sum] = "8686a58ecba3b3fc16335ce3178f7958c0d3a2af36a9365ce73ec946af87bfbd"
