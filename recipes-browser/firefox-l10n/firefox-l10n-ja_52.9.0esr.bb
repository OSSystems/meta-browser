# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9fa27550af0746e926867d1889608099"
SRC_URI[sha256sum] = "aaed4fa95b9f1766f4a2e2537b15554b7a8821d105f27254c4bbb23cef22cb47"
