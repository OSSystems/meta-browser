# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a3d3584ab9b8f9347eb08a0ab34ccc66"
SRC_URI[sha256sum] = "c95156a1857a6169851f56961b1b4eed0b5b5315ebb653a2f2d8196f8f3bfdd1"
