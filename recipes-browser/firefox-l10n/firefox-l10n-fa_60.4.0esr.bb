# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e19c6815a8d9da72bbe49563199e259f"
SRC_URI[sha256sum] = "8869a4c54df2806563e97f60144c78137ab539295870d22ae616b8e6b4508a31"
