# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d58977fcdaea11fad31264750624b76f"
SRC_URI[sha256sum] = "1658b2782ff9ba538f9215d1214be2d201293739fba29cade86205506465aab4"
