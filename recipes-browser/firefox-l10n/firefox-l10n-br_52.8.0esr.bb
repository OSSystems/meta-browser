# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ce49033a33bf613357689600d1ab49d7"
SRC_URI[sha256sum] = "cc3ce8d3c3c54d5418e5c911ba7e94dea503c62b969f7effd26790ab100aadc2"
