# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1f3ad7979ecf68063a6aaa8f061795bd"
SRC_URI[sha256sum] = "aa5b1ab335018aa7e45ef7274fa37807a4a7999224aa6632a19f18e50a6558d4"
