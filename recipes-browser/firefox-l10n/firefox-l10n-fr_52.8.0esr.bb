# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a483eee3f877f8738900903b39661dcb"
SRC_URI[sha256sum] = "0797c241bfc4b15becab480c8eb7ed68797f9f745a116511a55a92aea68c0577"
