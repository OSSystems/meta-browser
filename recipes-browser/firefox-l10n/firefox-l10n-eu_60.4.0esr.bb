# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4b04cfd83d8364158a2a5768c2a87c1c"
SRC_URI[sha256sum] = "4adb45e03a94dd409a84ee466127871c338e4c842e46218f48474e7c676be125"
