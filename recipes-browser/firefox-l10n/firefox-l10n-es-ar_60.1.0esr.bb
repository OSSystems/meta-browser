# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ede585cd1392ac2fba827b9c093b41ba"
SRC_URI[sha256sum] = "327de0739ee552e9f64c9029babe9962dedc1d794073639fb1383c61945b3b8c"
