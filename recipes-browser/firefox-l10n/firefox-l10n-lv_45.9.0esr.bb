# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "71f6bedbd28d51c59c0ffafc209d1b5a"
SRC_URI[sha256sum] = "aecd9305ea6d4a0a13743279afac4b5dda9e339325f92bc15a772f98d961c288"
