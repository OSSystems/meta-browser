# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0d9604ab8022f05802ffd18f8f615508"
SRC_URI[sha256sum] = "52b69dc62f1b0915aabea613a32dc438e9ecdb04cf5bf0a86486ccabb59ae951"
