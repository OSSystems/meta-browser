# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7acea974a3789ef025037fdb12d56882"
SRC_URI[sha256sum] = "35b2ac640ec58bda58073d45d3a0cff6d278e251fa11a98596151943961ec0ce"
