# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d68614d516011927723a3c7972fb59e6"
SRC_URI[sha256sum] = "e03149721297f487b6b8d395add7594f72d6c506ec1be0eb229cf36dcf256824"
