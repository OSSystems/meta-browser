# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "675fbaa3a39ed7c2a878a30c932cc502"
SRC_URI[sha256sum] = "b50c30e90580b0c8bc6871dae8639a01019618caf713c1b8bae32485f0e8b167"
