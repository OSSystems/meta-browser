# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eeaa5951e67657aac71934bdd7bc7f95"
SRC_URI[sha256sum] = "af38739494d7348e7e5f53b1c14548110f8f5d1869e4de2f2c559fc458a69218"
