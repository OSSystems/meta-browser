# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cb6e365b27ee63cf3bf19f6deba3bc31"
SRC_URI[sha256sum] = "4cb58c6ede9b14304e74c190aca55d9350509699596711a7cdc7ef93fc558a70"
