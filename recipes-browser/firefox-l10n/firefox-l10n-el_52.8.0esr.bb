# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "542b6aa240b4f7710cd823cb47aa4384"
SRC_URI[sha256sum] = "94ee8b852a012f3a0a9997fd263ff9f88405d6bbe427ffa33fc37bff567df0bf"
