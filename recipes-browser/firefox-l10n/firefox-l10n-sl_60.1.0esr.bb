# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3b3d85e5cdef9275ae900d2d6c1ca16a"
SRC_URI[sha256sum] = "519c321370b2e917be768f14288cee260c299472d3c443f618c3352df5dd470b"
