# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2fe1d047b74a6954dc7e5d1705d4c2e5"
SRC_URI[sha256sum] = "1ce5170def238a5eb32f0f55c99f010f255902212c416b055520748f7a873de6"
