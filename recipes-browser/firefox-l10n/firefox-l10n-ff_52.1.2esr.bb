# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1061e8545df83255b191c48ca865d4e1"
SRC_URI[sha256sum] = "1edeb87796ab9a92e4522832ec962c20e1aa0857a407118c597b3ebca51f231b"
