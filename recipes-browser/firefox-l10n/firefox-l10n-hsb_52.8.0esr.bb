# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f408a10f199ee3ec9d573829a42a6235"
SRC_URI[sha256sum] = "4bf3aa58d2c8d0659da6027d85fc5c516921cc87d70fedf092621c2ff27f8d4a"
