# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "59cc28632c3d78d271c4a94c29285841"
SRC_URI[sha256sum] = "ff4c4893b0313e3ea7720c7b4dc485229f0228f6a86f943789bb4f0b371ed788"
