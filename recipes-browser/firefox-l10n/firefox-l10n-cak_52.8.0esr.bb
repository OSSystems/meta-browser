# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7b32680222059b4510d62a6bd81fc246"
SRC_URI[sha256sum] = "2fd0fdfc2785365f78277c9fe4fc9a3c3a8494448f94c302379cc71af0afd9f3"
