# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a4edb25a600b8cba5377852315aeb2f9"
SRC_URI[sha256sum] = "dd56b6c4de66e4b6f6f6db56e5b2fa157add2d71faf3b41c7dbd2465a649a98d"
