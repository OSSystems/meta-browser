# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "efd5bd963fe178c5e43d232810ce5685"
SRC_URI[sha256sum] = "e2ae0ea323ed926b232c52cd78923b06dc50cb5acabac108b91d2a7acd95d863"
