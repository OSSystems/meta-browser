# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2526621d755134b66dbadbee7037846a"
SRC_URI[sha256sum] = "c3bcece23d752bc3bb6bf36f135354f6abaa244bdd82a37ebdef2024b97efd65"
