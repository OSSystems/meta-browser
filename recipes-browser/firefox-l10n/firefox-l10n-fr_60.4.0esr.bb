# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "73ce4e302516e0cb241a23f83d9db9a7"
SRC_URI[sha256sum] = "f7f52f50f36835be12707c4e44e3000b12a9ba7533d110930289499fee1a995f"
