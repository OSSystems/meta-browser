# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "10e3f918f61d4de72ba5ee4dda66837e"
SRC_URI[sha256sum] = "596cd31176824b06aa3819b71fe3884fef381c4278a3d924390f2590e6f46994"
