# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "062fc02ffc17b86a735436ab77b583f7"
SRC_URI[sha256sum] = "bb14fbbd04c85f4ad09c98afe27a8eccfc86b965e269c6599cbb76507e1018d7"
