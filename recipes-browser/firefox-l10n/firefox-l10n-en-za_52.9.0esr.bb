# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "123a1495aa79bbd692a99700380ace0f"
SRC_URI[sha256sum] = "f76a6b8ccaaffbbeade411976d71176dd598c30a0fc576caef7b8e2140e7e8ea"
