# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8c088e8490396e181bc860e2aedaafee"
SRC_URI[sha256sum] = "68b40fdde936827c384736b089ec4f7f3c69670cf18c446092681b3e7359be14"
