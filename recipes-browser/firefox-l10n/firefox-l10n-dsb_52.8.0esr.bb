# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ec63e7b30325bfd05b01bd7b6060578d"
SRC_URI[sha256sum] = "71b9e71ca4545ea55f13245b90600d0114d3ae72d16ad2db25db3f034592ec7f"
