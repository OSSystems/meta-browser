# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "793b93bdf9f9162d1faa9aa2d2a8bf96"
SRC_URI[sha256sum] = "ff261bc0ef624014c4d5fd91d45ad7445fdb82517353fbf1a2f5ba749fa3a572"
