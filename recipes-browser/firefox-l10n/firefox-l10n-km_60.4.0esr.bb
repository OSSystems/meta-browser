# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "877c4d8b09228504fde0992a9101d90a"
SRC_URI[sha256sum] = "8205b3a0e405750e6bbef1a4bcd0375374d0651761d28718b8257d9e5065e080"
