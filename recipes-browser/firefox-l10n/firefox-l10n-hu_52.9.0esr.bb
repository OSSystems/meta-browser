# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6f1ca22369ddf4d00fc4be399f3d6b85"
SRC_URI[sha256sum] = "2d1a34a83c15f87c05c5be22dd48fd447e1d0772843e4ae3fbd64f17a6660acc"
