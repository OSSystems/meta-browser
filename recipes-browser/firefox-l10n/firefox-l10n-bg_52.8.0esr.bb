# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "18dbcda2693e94187e5cfeb775a3fc80"
SRC_URI[sha256sum] = "bc8f076c26966fb7267d4d83dd8aa42cec8afee83e4fb9f9179bae6900c3724b"
