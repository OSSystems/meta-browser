# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2af12d6803d04866ae8f8c7b1478a69a"
SRC_URI[sha256sum] = "efc5fc41c22d96e1e3827d997e418277cf1e3de453aec02734ba513639543eb0"
