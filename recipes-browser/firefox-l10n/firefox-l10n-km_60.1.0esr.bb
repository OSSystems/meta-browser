# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "caae8acfe6556e5840ed62d96022f079"
SRC_URI[sha256sum] = "56815cacf17ed91600da39673454726fbf617b6dc68bbe7e07134bcb5053252c"
