# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bf73941fea8885692dd033046887a868"
SRC_URI[sha256sum] = "0946d1b3960095b92d91c3bebafc05b4bbc2eab6024ca8c0a1aa8eed105228c0"
