# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1c115e3429f7d18861a6589e29548ac0"
SRC_URI[sha256sum] = "8c02f34b99bad15972ec2e0b1c418d83a8f698a1f15a095a570f20dd7d2631c9"
