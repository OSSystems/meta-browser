# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "10d06c399b0aff9060df27ece3979a5a"
SRC_URI[sha256sum] = "c203c62ee2b35e1070735ba40966984ec571b5ca1174318b76b383904f721879"
