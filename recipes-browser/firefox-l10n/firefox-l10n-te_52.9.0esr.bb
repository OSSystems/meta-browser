# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7745f0c85fc6c61a264651cc02c08df3"
SRC_URI[sha256sum] = "a9be8bbaffbf17dc64ef42de29de38b61b3acf493141de9f462161afc7fbe8ba"
