# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fe9d53390d92420544f9ed4c084470fc"
SRC_URI[sha256sum] = "5b4a5350d9f44cc9535987c50da886b52922402d1d607008239aa289f23f9a34"
