# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7ddb6a1595c4991de7f1930d468f27fb"
SRC_URI[sha256sum] = "2bb3a7347135675dd29bb72658c523428eb6af15380d52457a7f1aac1d381b7c"
