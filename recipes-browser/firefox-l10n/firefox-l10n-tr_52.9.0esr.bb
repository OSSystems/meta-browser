# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a173616100472acbe35c8af7e71a05b9"
SRC_URI[sha256sum] = "52cc765c308a4f1bc9d99396784da84fd4405c6e571b4911f36f34bc5aa94735"
