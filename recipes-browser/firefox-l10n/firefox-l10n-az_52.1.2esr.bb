# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f6bb01047cd25ddcdb68b785813842ff"
SRC_URI[sha256sum] = "cb569e4fed68bf63a326b9227ece6a280f9e19456e80e7b3c5aa3f87fb195bc2"
