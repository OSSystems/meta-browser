# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6c7139e25363f449405e43be7e662198"
SRC_URI[sha256sum] = "dd72dd03d4d17d7cf31a1a226b4a0c3409dd009394404b3cb8f54f9b2f942334"
