# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9f92c926b0f4a1d44bdd2742f9561104"
SRC_URI[sha256sum] = "7300854b0367c3569bccba4552f94ab948dbba28e4b407a1919cc509dc6e9224"
