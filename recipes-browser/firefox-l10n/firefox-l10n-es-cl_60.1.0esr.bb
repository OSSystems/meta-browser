# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6b7fd250f7b0a1eb1a243eeebc48858f"
SRC_URI[sha256sum] = "32db21eb540dd077d20033a80d21a8b0a0256ad53cefa38963d48e64bd251645"
