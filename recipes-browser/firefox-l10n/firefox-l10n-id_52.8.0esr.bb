# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "71886cc24e35936d7f4fa7fab35e6340"
SRC_URI[sha256sum] = "dad28e6b93f574d2995455eac8dccaa537eb3d8a3366807932161a12eafd97fb"
