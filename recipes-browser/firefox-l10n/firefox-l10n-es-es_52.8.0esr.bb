# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "188c706ec4dfc15010ce4335c390b432"
SRC_URI[sha256sum] = "c45f4ca91ccee666079790ce377f474c7992d410c88c16ce4551867711467a30"
