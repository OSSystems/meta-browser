# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0817d9112fbea8a47165dedf2d761069"
SRC_URI[sha256sum] = "8ea19529b0536099bee5ad65799bb422a6e9460fe9670c951e8609eef54133d6"
