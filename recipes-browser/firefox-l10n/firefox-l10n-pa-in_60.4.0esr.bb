# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "551b216f4669b8e8cab5d3540fde1825"
SRC_URI[sha256sum] = "6829648639d2501a9836f09f23e087a7d6011868eea65728a818a35182f67643"
