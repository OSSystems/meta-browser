# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "48bb5307e9710de28222299861f8712e"
SRC_URI[sha256sum] = "5cca394cd42b087b7d14e85ba2a7115e97eba7e08e8d4bd7a9482d25f8d07857"
