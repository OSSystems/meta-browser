# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1a1f80e18f9a87584ddd030f279a88df"
SRC_URI[sha256sum] = "b51d5c1117c0ef1583e997a64ef3fcb530c7caaf052aea0b0cf0aaec46d5f3a8"
