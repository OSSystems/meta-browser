# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "710974cdbca3acc2ba671bb262aea514"
SRC_URI[sha256sum] = "76905cf4d180915ab1dd8ce07acc618ee0a8f32e25245aa193a0285c39181ae6"
