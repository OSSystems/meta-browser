# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2c0195766ea6262da8470ca94ef7b27f"
SRC_URI[sha256sum] = "a801f7a93e76217af229b6604ef6a00c3e39c815fd8ee2dc3b9e07e80660c16f"
