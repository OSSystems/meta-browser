# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6644ecf12780532061ea304f7178bf58"
SRC_URI[sha256sum] = "099371d26e2d6cdd6dc7d75ed6581a5d6cba794a61b09ea530a713ef228a679f"
