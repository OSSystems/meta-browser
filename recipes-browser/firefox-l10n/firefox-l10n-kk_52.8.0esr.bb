# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eb436891fe9c1755213d9d8308493801"
SRC_URI[sha256sum] = "e78680221cc5d0e726a1ac8362df672a70aa4d0f3e0c08c47c9f3fac7eab0211"
