# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e01abf5d87fa0d985de9ecbe4e777a7f"
SRC_URI[sha256sum] = "06907c301e1cbcba62d31661b64f1744f7df8827722b21252277749642de4857"
