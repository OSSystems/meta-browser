# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "54f201f50d520a4c63c46d786aaf648e"
SRC_URI[sha256sum] = "069546e9323807c299ff5a50bcf397268fdcb475d0c5f4530d62449cffec6b3a"
