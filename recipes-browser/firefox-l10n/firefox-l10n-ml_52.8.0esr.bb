# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "025be7b547b39603f86113bca6e2682e"
SRC_URI[sha256sum] = "2023a29c5725ea458ebade2874e49c48e4fd83931f110a4d172ef238f0a4635f"
