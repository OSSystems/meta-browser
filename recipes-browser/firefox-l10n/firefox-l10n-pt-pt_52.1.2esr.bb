# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "71d44ddfdf5c35b579bf5d31e974aabc"
SRC_URI[sha256sum] = "113750e6daf0f0ba2e764ed6140d28579189f1e99e867d613752a2368b3b388a"
