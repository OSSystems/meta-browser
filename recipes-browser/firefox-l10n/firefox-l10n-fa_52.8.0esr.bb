# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5eaceac5d5c84388b5a18d90361d23f4"
SRC_URI[sha256sum] = "734508a2d7997969c0cfa2f46751830e0e29b5522548994b385f7010449a05c9"
