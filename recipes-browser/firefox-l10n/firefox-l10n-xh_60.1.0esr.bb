# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c2c98b26ce1bb51b2e36584c28cd086e"
SRC_URI[sha256sum] = "f45cced5035fcaadc04c119a332e8358d17fafea8feae8cd159ff314117e3028"
