# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c166be6c81150157950f14d5a073d4c2"
SRC_URI[sha256sum] = "55586600fa4bcb6223998639116e47a0ecadde8278fc8db54bfe7f1deecd839b"
