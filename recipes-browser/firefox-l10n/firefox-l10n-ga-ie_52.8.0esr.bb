# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d1fd8eec18a4e81fdc38faaa373b59a7"
SRC_URI[sha256sum] = "311c222f54accb81014384cfda644c9d718a09baf4935056016307324cadf83a"
