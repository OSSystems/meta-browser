# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db5351add68151b4d8de72edeb2bcffe"
SRC_URI[sha256sum] = "5054a5f1071c926290dbffd5820ff19214e22ad6a63662bc93a5c1af885d14e7"
