# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8f5eedf3f98ca5e0c139a3e374c5ae94"
SRC_URI[sha256sum] = "74ea5a3e367d775ebd31eeba01650d8d380ac2dc863aa26eafe17e431b0b40be"
