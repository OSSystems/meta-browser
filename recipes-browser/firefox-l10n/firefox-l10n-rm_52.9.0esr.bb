# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a8fae1b6958c7599263d19da94ebde0d"
SRC_URI[sha256sum] = "12206fb5285cd7d2b1125a6c372b05591e7beec37bbd05c3e0fafd900af70cfe"
