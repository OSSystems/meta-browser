# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "657ea6767731347e7c9b7d7bf6c40945"
SRC_URI[sha256sum] = "79321aef66f784670f44078baf2d001284325e6cb3b6e00a1787efbe4fbc12e3"
