# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c041cc26052c0180fdd8aae601e3962"
SRC_URI[sha256sum] = "dde0dd74b3f9bf549ba27017941c1b8341c733cf0b89c63dbcc2dbc231f6fb35"
