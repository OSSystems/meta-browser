# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f3f4648eff819d6b505092b97564ee3b"
SRC_URI[sha256sum] = "071310d0e7c2b0fdfbdc8f2646660383ec590f933d2f72a6464414976d873b21"
