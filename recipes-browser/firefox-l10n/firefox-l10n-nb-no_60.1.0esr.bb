# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c5853aecef4345c0e9dc5474bdf2fbb6"
SRC_URI[sha256sum] = "b2a32401c5820bed992520fe2d5d80ee6131d28437be1169d54b090a9fd4309b"
