# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "250bb7465b4bf900a1b4471c2ba16412"
SRC_URI[sha256sum] = "400e9920beaf8ba0e7deb085c5a3fcdd01e9331bc17d6f72aa9037051b9a779b"
