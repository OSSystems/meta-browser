# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "de8f67723516f5c979257c825e80fda6"
SRC_URI[sha256sum] = "6624c1669d1a7f09931ebd569599442e773bff12b94583d44e79a7af5a90633b"
