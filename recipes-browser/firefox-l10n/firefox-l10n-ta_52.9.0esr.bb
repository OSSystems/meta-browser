# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2de4b3f5911097118cf5611cbb68596c"
SRC_URI[sha256sum] = "66bfb2dcbe11b41207e81e1d259f0a0783dd7425c26f1c97f02df4e275c9d50f"
