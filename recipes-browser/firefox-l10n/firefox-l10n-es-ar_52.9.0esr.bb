# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5c7261fc2044faaf59db63aaa73e504f"
SRC_URI[sha256sum] = "3567cddae4a303042938d2a2d744dade06ab77831816c0f32295cbebe79c75ca"
