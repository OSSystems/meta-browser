# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a402284baee3aa8c945044d380506fed"
SRC_URI[sha256sum] = "27890cb3850aa0dc2795ba474b6671e90386068d602fc7b3b82e325afa05334f"
