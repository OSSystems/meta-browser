# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "17692125b44fa98521d21dfdc5befe95"
SRC_URI[sha256sum] = "db903ff36e7e4636b7042f166003e17d797d613248e4e5f5a17eeceba89218f5"
