# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0797904fb47547b31d8568c14b7f67dd"
SRC_URI[sha256sum] = "2e1fe45ea63447efcc6c4fdf8ca72fda98ebe19d998bdcfaec1a83120d8c282c"
