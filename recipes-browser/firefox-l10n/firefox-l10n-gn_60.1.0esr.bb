# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6316f07582522dfdacfb531da820efbf"
SRC_URI[sha256sum] = "5670ef65c7597a8928389c2a318073dcf4e20857bf476233047763cedb73fa39"
