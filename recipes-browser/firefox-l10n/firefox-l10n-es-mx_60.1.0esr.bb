# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3391743841884d355d1c006f711ce92b"
SRC_URI[sha256sum] = "459efa11399edb4fdb07c8834cdac4d9efda227c118178400a46b17a52897e19"
