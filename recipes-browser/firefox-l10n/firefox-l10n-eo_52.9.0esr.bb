# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "37c7240cdd733b2f4635d903d8a44010"
SRC_URI[sha256sum] = "e81a9b48b0c87944de07a2cb7bb3b1329137f283c5dd0d81b05ed8b5e62e66f0"
