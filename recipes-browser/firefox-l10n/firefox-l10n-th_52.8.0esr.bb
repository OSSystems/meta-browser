# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7a6c13815509b6de5b5181c90f727ca2"
SRC_URI[sha256sum] = "94942825b0d1a0cfe49fa64e1789635c527064ce5c599740d96590ffd4a86231"
