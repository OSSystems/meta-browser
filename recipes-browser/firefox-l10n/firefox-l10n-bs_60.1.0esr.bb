# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2a6814e6aa6f27d9632a33582b99d7eb"
SRC_URI[sha256sum] = "4ff6cc7c2ce855bdc5adb81c182c07c20f857e78b89a8202ec6c82f7e987f9f1"
