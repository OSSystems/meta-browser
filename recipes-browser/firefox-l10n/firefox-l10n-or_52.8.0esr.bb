# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6316b773942fa3e8745fed4ee06f11b0"
SRC_URI[sha256sum] = "6ab0259bf3666112a6171b0ac11b9ae74341930aa5158f154a2eeebd5a33eeb4"
