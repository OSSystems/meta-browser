# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a8feae92dc685251c53bea0f28150a2d"
SRC_URI[sha256sum] = "167b90a854723e0e90bc2d1275068b2fba456dbc75ee5bad7b7f9f0b6a3925da"
