# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cf8e87b874c447f75c57b6024b296fee"
SRC_URI[sha256sum] = "0e302c329d42ccc38b91a71e14eb9e10efd570455b026d8782c8b941998054cd"
