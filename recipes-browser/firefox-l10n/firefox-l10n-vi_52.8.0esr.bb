# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eb0913c9f7fd4cac521e74706e47652f"
SRC_URI[sha256sum] = "324ff5d2900d58d7c44b05381ac4d280d94586392d786aa7ae3b68f11a5bc4b0"
