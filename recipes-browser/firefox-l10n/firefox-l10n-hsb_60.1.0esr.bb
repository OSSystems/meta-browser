# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b1e7a57e473c706fcfe16a4dca08fadd"
SRC_URI[sha256sum] = "8e4e534ed9559639a49d4dfb671305c7fb9601afcc786f204ebcb8fa34912684"
