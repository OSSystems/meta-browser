# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "93dff48a09da3f7e10d3f65ed0deb284"
SRC_URI[sha256sum] = "516f5142ea7515a127e0937e545d30b7658790319dd3bb6f9a6da8b1e2a210d1"
