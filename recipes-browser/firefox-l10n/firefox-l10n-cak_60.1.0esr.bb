# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "da27cf2e78c1cb935b77b8329b5a2125"
SRC_URI[sha256sum] = "52122df2048402996e66704a58f6ca49059f75eccc945a4ba189dcbfc013411c"
