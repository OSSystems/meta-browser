# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9e202d2189cb237403689ede091a8d73"
SRC_URI[sha256sum] = "119e447221572186d0bd390767e25214f157a8dfdeba461c2ddbf76e5fa3b8e4"
