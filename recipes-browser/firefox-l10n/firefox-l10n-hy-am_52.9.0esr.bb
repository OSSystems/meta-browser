# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7ea92f428067593cf0c6927ced6482cf"
SRC_URI[sha256sum] = "818c2dbfdc5900391e8aab5d27418bdc88959b66164e0a57890cff5ae56d5b9d"
