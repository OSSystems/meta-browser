# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "48772c072c67b1fac8a8874620ca5c86"
SRC_URI[sha256sum] = "2f4b8e0e9377a85fb85a891cbbf1cd2007456dfa22c7ed78462d39fc6ad0c558"
