# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a3b7fb7f206f9531cf42adc48abf1f1e"
SRC_URI[sha256sum] = "d03f1fafa1f45b6da936efedb1bf813af0a16892f46fb2c7e772b37c322b1d65"
