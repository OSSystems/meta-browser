# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "402071a9b84fe6c1f892e485daa5ae7f"
SRC_URI[sha256sum] = "3e5c1015b2b12cd6dd65010a6ef41eef040b2d2ecad38528ad36be900b2a0c24"
