# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3e875a8a08ce6abd986e03c2fb65c7dc"
SRC_URI[sha256sum] = "657225821c9c37fdfe12d09ac561d2702f20b2d17c9141f7e7bbcf7a1d7494e4"
