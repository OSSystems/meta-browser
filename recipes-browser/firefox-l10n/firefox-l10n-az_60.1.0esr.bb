# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b26e9d86fa2e573583f062e9150b8f38"
SRC_URI[sha256sum] = "e7eeea07d9dbc66d403b4b1d6dab762002efbfd94db8c609896e43c746090aa8"
