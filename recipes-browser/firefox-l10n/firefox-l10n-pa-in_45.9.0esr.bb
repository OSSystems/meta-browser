# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cdc6f794569818f3726a44ec3ad39739"
SRC_URI[sha256sum] = "973892c5ed883f80fd355d693dc5eb027794b402b25615e503633c17aaf8f67d"
