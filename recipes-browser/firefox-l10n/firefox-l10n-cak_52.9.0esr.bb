# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8d03c27cb0bc014971781ea063df34aa"
SRC_URI[sha256sum] = "324e161c85f2287502e04abab1de88e8b4c0924a30996aa848f859d2d1d556e3"
