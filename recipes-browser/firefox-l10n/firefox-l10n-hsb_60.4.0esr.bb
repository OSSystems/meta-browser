# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "506efa7ca1653f467955527c3cfa593f"
SRC_URI[sha256sum] = "7bac818f9228cfc14f2ce2630af40a19ca62a8f698f30bd42dc12274e3dc5428"
