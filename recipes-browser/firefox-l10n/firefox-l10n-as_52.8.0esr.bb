# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8f7472cb385247e4ebdfe4e52575fb38"
SRC_URI[sha256sum] = "c998b908c3999c096560ec00ec9abc4e179c2399e4b4c12e67f4db80388a0a71"
