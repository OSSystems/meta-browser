# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2da036f44ff16f4b217483c6bddc80f4"
SRC_URI[sha256sum] = "8d2074da2ddece656e1b65a957cb1ffc027ce21df62e83acaf57deb37c0481ab"
