# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db8cbc6eb7cbd25f16e649f813e56514"
SRC_URI[sha256sum] = "b8799469657e5c39cea9ecb034db50bd0cd28a8ce146d5335a14ba22245291b7"
