# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dc44994b4c92c908a47606dceb13f7df"
SRC_URI[sha256sum] = "7967be14966c44205fb1319350210667bdea3772cc59309c67cff972bbd19fe8"
