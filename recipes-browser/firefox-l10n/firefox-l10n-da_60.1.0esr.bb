# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e03044e073fa98f38924cfd421c7888b"
SRC_URI[sha256sum] = "72ed880f72b10526259c4843ebc6ebb92184548de645f409b397949a50fe4b5e"
