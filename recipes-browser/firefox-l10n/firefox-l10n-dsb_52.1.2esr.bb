# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "625ccb53e1e4bd7d98b8047eab4e6364"
SRC_URI[sha256sum] = "26f0d0313458b1fc54d54f172512d9ab67af3ccd5ab3fb39bbe4e5684a41ec30"
