# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a88f7615f495f457a274c9c872dda563"
SRC_URI[sha256sum] = "1672e7edba46bfb551628e65066b7246270b19159fbae0fabb988ddb21b74ad3"
