# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7b21773d429adaee688a71d11e247637"
SRC_URI[sha256sum] = "0d58ab44168656d85fc4d2a726ab39f7a79a5e3d161cd21c32b190bbae05e560"
