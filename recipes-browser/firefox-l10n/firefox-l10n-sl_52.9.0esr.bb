# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e962c8fca48f720c0b877ecc9a5adb57"
SRC_URI[sha256sum] = "99746474185eb6090a3cfc5917166da3a598007f0dd9a4d864483938c2f1786d"
