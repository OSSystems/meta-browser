# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d42a48357e55a8954d6ad0c6f574f0c8"
SRC_URI[sha256sum] = "a66f32cef38343a78f7f38990861cce9de29a8bb2b3237c52841d3c9336fb4dd"
