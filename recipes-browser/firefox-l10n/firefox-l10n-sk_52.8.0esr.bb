# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "adebd46c1490c0cb6831771f0d7af0f0"
SRC_URI[sha256sum] = "8ee0ca43a6f4600891ee2258879d575aa4fa475421bdd53aac5b66462d9ba34a"
