# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "da6150f52275fa0eefb25d3c84091d7a"
SRC_URI[sha256sum] = "cb3929f9aacfec38027e2d7e9aaeeed3c8480904b39318ceb7d46396292a1150"
