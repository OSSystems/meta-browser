# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c7362339b0b0c9be9a2ff8d2950beeac"
SRC_URI[sha256sum] = "344564cae87b117056bbb588364c61bfed62a37fba6a2f453845202fecbcba64"
