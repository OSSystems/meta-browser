# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8bb8fd79ee166c70e1f7d70f4d0217a1"
SRC_URI[sha256sum] = "8ae009506eeafbece65b118a237df7c91039be5debf7c513625d735f2677780d"
