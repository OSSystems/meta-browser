# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e6881252410260806f5a20d121b9897f"
SRC_URI[sha256sum] = "3d77b4a0d3beabc64208198479192e00e1eeb184def90e9dcc5ab27676b18138"
