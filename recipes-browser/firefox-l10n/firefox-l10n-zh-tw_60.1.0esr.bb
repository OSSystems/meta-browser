# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e59f1ebabb82c306b4d31aa0f1053152"
SRC_URI[sha256sum] = "81269be88130b77836e55744f7b287d4664fdb1f40940568a31cdb3e024857a4"
