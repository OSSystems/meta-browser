# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "15e5ec069ac86af8d8f867098b815d4a"
SRC_URI[sha256sum] = "8b579f446ef0521b83448cf2b284a8bfdb64e024c690929049916c018566064f"
