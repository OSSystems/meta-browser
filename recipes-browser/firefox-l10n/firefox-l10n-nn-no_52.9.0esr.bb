# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cacb0c7333aee0fa134f97c8bb7c97ed"
SRC_URI[sha256sum] = "65be2e545586bda4c63a4ea17f904cd93e8a5ab69e8f692dfdb03e4348ca22ae"
