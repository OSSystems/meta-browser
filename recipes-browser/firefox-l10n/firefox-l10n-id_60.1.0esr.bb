# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c9973c6c5bf6a62a58208589155524ca"
SRC_URI[sha256sum] = "7e84c521512bcd7f5eafb633b064f3f93c32cf3d5db6fb3e6f4f743fe8314436"
