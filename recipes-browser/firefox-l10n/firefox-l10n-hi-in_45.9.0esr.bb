# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b0bc9d36e16a76990c43e26ac7c90ac6"
SRC_URI[sha256sum] = "bf203dc0327b8487ad51f2042f7ffd9e027883aa610e2123164c626b8ceca01e"
