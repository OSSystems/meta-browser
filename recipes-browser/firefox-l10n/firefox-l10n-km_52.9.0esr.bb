# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7f265dce3fcb583992439f41229af7da"
SRC_URI[sha256sum] = "207736a063247eddb70838c1b8101c2b6fa8e4b8fff55447378780af6c2a5646"
