# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "26d52f720b821188cb2dd8c9d42dc113"
SRC_URI[sha256sum] = "0141ddad70db4b227464a34450eff3fc4266c7849e9ec242ac7b8fcd7e87a5d6"
