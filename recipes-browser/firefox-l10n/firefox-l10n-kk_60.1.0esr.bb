# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ad29240709d3013ce5b9ee26f5337aec"
SRC_URI[sha256sum] = "40d120c25c473d423a20ba8c677b27cbdc15fa4efae85b3d7df9a4b83abfec6c"
