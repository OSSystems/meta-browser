# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "60a7f1d8602a4d72e8b2083787e04d4f"
SRC_URI[sha256sum] = "b023c5398ff903a2f276802a11e5acda7d591b0a25f54ad1f857d71ccd3dcf05"
