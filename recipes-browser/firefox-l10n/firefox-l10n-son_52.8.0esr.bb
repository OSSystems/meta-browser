# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8091f438c0de5ac9549f6d1b41170e9f"
SRC_URI[sha256sum] = "16906b5639d0331c96a89e443dc173ff50136c3a9663c769d81cc450a0f8f70d"
