# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bbdb222423c683397d03a689348a158b"
SRC_URI[sha256sum] = "77d97caaf9ce22a35b43e3723219323002a1cb7d013470cefa99020b6b8fa4e1"
