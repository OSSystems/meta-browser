# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b60e6bc74683c5121508ca834122e02f"
SRC_URI[sha256sum] = "487f6643e335e8a9cec42f14d50140de2f0a3b6d55af87aa123c432fd5f5eda1"
