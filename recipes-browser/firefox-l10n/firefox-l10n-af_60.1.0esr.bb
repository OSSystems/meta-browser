# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ca3d6e9569def0b676c02e0074faeb6c"
SRC_URI[sha256sum] = "c632cda90a84f2513615758af6590ab9a742d0cc8118cd15a463482663ec7100"
