# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5bb0188c6b2f9ee516916ecd4eb12023"
SRC_URI[sha256sum] = "c85bb05e1e43bb34a469423efd70d4b3d0bd0266d8f851c959687d2ba346f197"
