# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d7509927f6b7bc4a6321fdf50ea15e98"
SRC_URI[sha256sum] = "bd455ced24f9f38bfbba68a7f0781d78d1e0eb2f2590e6fc666bf4bc3e1db8d9"
