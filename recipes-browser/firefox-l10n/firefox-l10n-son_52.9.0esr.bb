# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7cd05dbeb3f910ad868cc80244586006"
SRC_URI[sha256sum] = "5a9a0ff096f06f5885f0f3b95825fece99c9bffa340d51c2eecf76c6a710e4f9"
