# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "df0ded60fca0958742b227dd374acac1"
SRC_URI[sha256sum] = "2b009ceb488018ac7473e3a3f6fea9e9218644be4fef53e6b88dc27ec4290bca"
