# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7469a1470abc69243a272679701abdc3"
SRC_URI[sha256sum] = "f2f99a9f9b83a47add002c969a29de98e51f5d7030bec80b16c61afc2a813738"
