# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f5cc84d8a7fcaca347656551d449c2fd"
SRC_URI[sha256sum] = "364536ae51d3d6534c605515276bb4c5a23f17a66c68b7d78875fd7cd26d3e2b"
