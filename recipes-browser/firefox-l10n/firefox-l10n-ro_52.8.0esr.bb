# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "09aa4bcc19dd887f7effed4e00777953"
SRC_URI[sha256sum] = "fa81c4bd21272c894d35b273658218a51c2f17e0f6149fcfc6e07c94217a1377"
