# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8f4fc177096cbeb62127b3e132952cd4"
SRC_URI[sha256sum] = "ce197b33b2f47238d4d79575f1580ce0db6b4355e0837c3d0cb504ef851332b1"
