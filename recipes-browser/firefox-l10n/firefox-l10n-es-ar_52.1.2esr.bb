# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8d65fd95b2679d54cdd397c3b7b34033"
SRC_URI[sha256sum] = "28c3696ff63d47e1019bd73a5f96fb6e692f56f96132e297590515e22e444167"
