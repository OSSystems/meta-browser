# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6a3079f9a38f9c10ec84e28890233ac0"
SRC_URI[sha256sum] = "ae9002bac9accfc3037322208e19ab98258ad796e1696cb74ffd17359ac41843"
