# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6c5db3de09fc8cbd35dbfce556e65441"
SRC_URI[sha256sum] = "93bc86cb1507011a84998e5229b5a23b34978b54c22211fd83580334561b091c"
