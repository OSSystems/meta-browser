# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7ee0b38ee2d721c05914cb94764343ab"
SRC_URI[sha256sum] = "7b8b4f669e445aac69fc7b5d6159c2459a97b65af06d8db9cd8acc60f82abb0a"
