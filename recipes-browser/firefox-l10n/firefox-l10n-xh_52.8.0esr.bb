# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0655aca94a3fb35b03c2c3f69ff1c2af"
SRC_URI[sha256sum] = "f2abe016111ec875c19d76e7265d40c3bcbb264fbb3c5aee71835326a8231a03"
