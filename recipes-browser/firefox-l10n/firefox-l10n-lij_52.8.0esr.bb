# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "66abba38eebea02bb4c40b567f94b727"
SRC_URI[sha256sum] = "4864ae85dd728391e3144b48771b26bdf60a6c226924ef3dac3583b57635f2d8"
