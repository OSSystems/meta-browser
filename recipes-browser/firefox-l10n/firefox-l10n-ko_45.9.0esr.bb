# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3d89b8b52058e024fd3e397b31565a4d"
SRC_URI[sha256sum] = "0d696cb1d6d11b974fe5a2411060a8d6e183bd71138cf5c40b91d2b549c0014a"
