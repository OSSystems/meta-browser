# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4d5d9696caf75c0947144856e9f7c972"
SRC_URI[sha256sum] = "608ecc2e914ac17979ec28bd4c18532d4ea7e274b001326e082e2f642737f597"
