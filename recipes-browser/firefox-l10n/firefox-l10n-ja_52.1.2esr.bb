# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2462f6ecca9275f997887c0d6055a683"
SRC_URI[sha256sum] = "221f5b10cd54e5dd366b4bda90d5809b760852b8b25cf3f74cbcd0615d7b57ce"
