# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "97f48244db0c9e5aa9d7367b603be8dd"
SRC_URI[sha256sum] = "bb88d2495e759fd6241d55c2e82911eba8590d1b6a32a91d3c4f1fdb19aeda2f"
