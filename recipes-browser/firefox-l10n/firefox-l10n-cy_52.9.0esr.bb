# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "43b833b90fe72db84f3eb2c70ff1419d"
SRC_URI[sha256sum] = "0e5f8613768bfa6456b781effb1982bd78f8405c30ee3e763d95ed5cae0de97f"
