# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "495207a67bc3f0ad24194567b562921e"
SRC_URI[sha256sum] = "a05cf9bef043afebabf9b7db194706288a3d73eaf1007f4ce6d96a0084b2d441"
