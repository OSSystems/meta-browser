# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9f13a564e2ca40aa2f54e75e57cb3747"
SRC_URI[sha256sum] = "707c33ac13d7b62b3b255729e35781c3380a38023ca2ae2807e0a9b3fe8ef9b0"
