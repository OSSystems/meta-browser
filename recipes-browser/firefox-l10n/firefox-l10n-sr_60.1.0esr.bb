# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0793ac80300670d65bff3e208c7072be"
SRC_URI[sha256sum] = "0c4afb5b094808579f61a75d8393d06af2a3138f5c73edcf0954105997363ed0"
