DEPENDS += "nss"

CFLAGS += "-I${STAGING_INCDIR}/mozilla/nss"
