# class for defining extension dir for chromium
CHROMIUM_EXTENSION_DIR = "${datadir}/chromium/extensions"
