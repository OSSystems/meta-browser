# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "54ceaeda9ac010f028f6ada296686cf4"
SRC_URI[sha256sum] = "f984cece388550467bbbf7c1c70162d42a66049b7a92f673fdfa4e4003428a6e"
