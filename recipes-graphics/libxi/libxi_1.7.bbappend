PRINC := "${@int(PRINC) + 1}"
BBCLASSEXTEND += "native"
