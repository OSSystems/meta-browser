# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "80062bac297bc0f5046bf90fe3c2cf38"
SRC_URI[sha256sum] = "7db45517845cb2c10240e8bc208aa98eb59ca9f7e4ac63458ff73b01c6f81feb"
