# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "86cc118c67f34ba0bb49965db7f61b8b"
SRC_URI[sha256sum] = "d57d83cb9ea23ab30eada256ad77648a8a922bff52016ddd0956c223011d99a2"
