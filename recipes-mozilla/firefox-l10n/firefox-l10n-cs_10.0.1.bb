# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "1b45cb2adbb4f819f425c5909953d9de"
SRC_URI[sha256sum] = "1bb457dde47871c46d795071d4a63962b83420db1555c5e3f53cba2027e00bf6"
