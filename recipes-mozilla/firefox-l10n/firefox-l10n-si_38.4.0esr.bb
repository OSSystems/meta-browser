# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7670c1d997d5f49d122409f3142bab6c"
SRC_URI[sha256sum] = "50692d44a2f2952a3dacd36f34c6b34e85cd16d9d13f795719e86e8afd59d62c"
