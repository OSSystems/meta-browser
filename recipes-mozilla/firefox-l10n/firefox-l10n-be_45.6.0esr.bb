# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "52fa9f6df5eaf565548104f45fac6866"
SRC_URI[sha256sum] = "8e86cfe3765e09fc5d236e369d3888e9336417fa8bdffe3343fc142f897aab6e"
