# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0b331d3504012e6c04ee07bd10ab6736"
SRC_URI[sha256sum] = "17a2771c37d08b1635de6bfbffb125191c046c21cf159b33fb596d9cd5ebfda0"
