# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "930aa23033e2c38674dff13c047ee5fe"
SRC_URI[sha256sum] = "8193a1b1fc1ffc08cd8efe186d11119611f241da6881d289213d705fbe594219"
