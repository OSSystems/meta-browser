# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8346e4f14afc9ede0cb4fd7daf3c83e2"
SRC_URI[sha256sum] = "b77c6eb0c696926727a792b0fc60f95713b4b999d54fc7708804bee5abd11213"
