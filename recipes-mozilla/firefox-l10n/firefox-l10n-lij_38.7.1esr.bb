# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "74528745d1b605ba5b94cf4a808bc8df"
SRC_URI[sha256sum] = "9976a055215e903deca570ea02d453747319629408bcd8b589f8d71848c391f7"
