# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "ad6ff42d79aa736eb3dac16482c11ed7"
SRC_URI[sha256sum] = "4c43e3daaf8609b20244c6ae731fe643ac1cbbc0ee9d9c41708181740a5ffcfa"
