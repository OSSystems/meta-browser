# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a295599f1861b94f2eab6c6aba11f579"
SRC_URI[sha256sum] = "edce42f12992dd7fc01f01581a88bfb72eec67deff85efeb82bdd7be553262a7"
