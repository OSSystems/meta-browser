# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "75bf9adf83806f0e0c36d2aa493f1884"
SRC_URI[sha256sum] = "0bd69930c3b98c198db1a7e48a9ecf5b8831cf93afb2b84d00b1964a7ffe6cea"
