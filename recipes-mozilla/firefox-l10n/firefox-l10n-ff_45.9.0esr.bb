# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "57f595864dd73b3da1e92e778e77c10b"
SRC_URI[sha256sum] = "5323177ecb206f59f6aac589dfc471d15940f7c397ec6d6dd830d183a252f055"
