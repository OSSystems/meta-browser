# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "021289c502b73cd61323c5005562cdb0"
SRC_URI[sha256sum] = "56c716f154f5f7469a52cc6c688b0ee37a86c1825cb746bbc30a8d902696d168"
