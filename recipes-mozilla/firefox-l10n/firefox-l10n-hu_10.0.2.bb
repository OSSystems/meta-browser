# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "4c4347cdf626e8ab384ab4a14591575b"
SRC_URI[sha256sum] = "61ca8a31c76265353d9748f2f7a2602dcebe5b605326113fc84937a84a305785"
