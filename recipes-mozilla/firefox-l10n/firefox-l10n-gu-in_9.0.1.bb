# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "e004f59487fc86e5c830869a23e3e4d0"
SRC_URI[sha256sum] = "f71c2ec0a2ceb1b878d34c80f0d5a927fec638001751a3b3ece11c52eb831487"
