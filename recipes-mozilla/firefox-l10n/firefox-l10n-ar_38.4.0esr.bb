# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6516f465e60ecbc6affc476dd8c4ca72"
SRC_URI[sha256sum] = "aee825dee23f8aeaafe1775918d9a17384073836ef3a934c50580d9cab1116b4"
