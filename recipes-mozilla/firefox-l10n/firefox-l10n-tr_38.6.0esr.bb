# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5e673877f146d8302d001b3044cd255b"
SRC_URI[sha256sum] = "d05ea4e1f54a2356eb9062432280f85ac4733a1938eba039a01b5c7359913a24"
