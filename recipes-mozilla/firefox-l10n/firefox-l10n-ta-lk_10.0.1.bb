# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "c5de7e09eb850d199d1e521582ff3532"
SRC_URI[sha256sum] = "a92e3ed52a308f8f72fa4d22c83048ebe1a5217c84875d22f3389f018deba270"
