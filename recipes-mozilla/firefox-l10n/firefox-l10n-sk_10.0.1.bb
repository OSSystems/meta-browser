# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "e25b027dc06a5a8babf0c9222d3861f6"
SRC_URI[sha256sum] = "2e00995ab6448f8f7edb5319256fe3df50229bbe9f8ce27c23758cd5cbafe17f"
