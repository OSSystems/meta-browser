# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "09080b30adafd30b629fa5360efc261b"
SRC_URI[sha256sum] = "059d36645fa9099b35f100cc2fd75dce78be7c40eb8c969668b7105e383309a3"
