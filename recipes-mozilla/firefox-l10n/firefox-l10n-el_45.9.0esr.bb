# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "22691688d806a360d593aa03611bf4a4"
SRC_URI[sha256sum] = "c9f26836fb487c3b93c588685b6dfbe54defd0c54ef56a540d716cdeade14ab9"
