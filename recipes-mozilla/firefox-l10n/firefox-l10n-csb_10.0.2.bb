# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "da702ed829874be13c2ab19b98764fe1"
SRC_URI[sha256sum] = "9979c3870009dd16cec07c6c0c4ae328897aa465bc1a22a85f35b69150749e68"
