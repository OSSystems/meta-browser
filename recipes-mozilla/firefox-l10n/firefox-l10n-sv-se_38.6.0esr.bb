# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "01a03ed72bb53d9901faa23d38c58eac"
SRC_URI[sha256sum] = "62c5280c5e49f47c0c6136c41196db112b220bbc238e8219b989805bcfe66dd3"
