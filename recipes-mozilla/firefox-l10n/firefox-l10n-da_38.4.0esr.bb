# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cfe1f634c6efd8bdf9f4b3a2ecf2b270"
SRC_URI[sha256sum] = "0c01576ce10bafc4eb825cc469487df34ec305537bf8ff0a28023b3488d6a3d6"
