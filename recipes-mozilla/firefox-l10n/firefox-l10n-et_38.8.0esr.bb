# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "17ddbb8db79d01cfc59f2be102d35f73"
SRC_URI[sha256sum] = "ba833203993143d906076f368b8c31d3d521ddee72444e245ed04bdc541ee99f"
