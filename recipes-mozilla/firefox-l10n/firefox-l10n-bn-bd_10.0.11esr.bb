# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4130e44ed071331e0c8b1fdd34262fa7"
SRC_URI[sha256sum] = "8697b84e257a88664ec88e074fb39913289e15f3fe89370fdb7e53c09071ab5c"
