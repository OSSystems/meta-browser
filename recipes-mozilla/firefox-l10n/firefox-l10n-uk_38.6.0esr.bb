# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ce1e1c111763267cf51fd6e1bfbdd359"
SRC_URI[sha256sum] = "f81f6f044d01cb8fe1e5e56fd80524a735d08dd6b75ed88b05980aafbbaa3c5b"
