# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dd559e81b95d9743d585b8b843a88c89"
SRC_URI[sha256sum] = "47eb3ae29732d71408eaacd2d2346f3b8d6a844eb3c058e26f62f18057081e3b"
