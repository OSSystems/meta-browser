# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "abb0655ddb3f14cda06b54d7305accb5"
SRC_URI[sha256sum] = "a1c447856394e01d5251192d4f29d0f7e9aac49c043ad1e5b4007903e766ff26"
