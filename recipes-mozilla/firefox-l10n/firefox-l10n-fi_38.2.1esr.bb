# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7b531ebf00d31f19dd17e408f5208115"
SRC_URI[sha256sum] = "0930c3a33eb29d31789e7a880a018912da6ca4e9a51013e08bc311d775f4021a"
