# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ecfc9f86287eb154aef8a370692443f5"
SRC_URI[sha256sum] = "b2e7e8507789c75135582bb8f7a56fe1ac866fce75d4f353b0e613170c9dd4a6"
