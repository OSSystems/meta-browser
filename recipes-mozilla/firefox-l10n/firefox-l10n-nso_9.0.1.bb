# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "afd28041af62f64e789d05a7f157b99b"
SRC_URI[sha256sum] = "ab8046164f1333574d1cfcf9fa92f3d0c197348163027b054ef7de3fcf083240"
