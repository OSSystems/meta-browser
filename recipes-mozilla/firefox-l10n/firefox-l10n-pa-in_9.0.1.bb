# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "9229d52e63fa2c42eea9ea35af082a03"
SRC_URI[sha256sum] = "07f632e7e67b299a2bd736524c6f459697c3f3fc7bc6d7a763c00b901d017cb5"
