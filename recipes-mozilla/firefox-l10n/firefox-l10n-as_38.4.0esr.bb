# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "608fd7faf915d00469556f666307debc"
SRC_URI[sha256sum] = "e0c77be1178038fc122951f6522d9c28377c862bed0844ac7e41b6c1b57aaaec"
