# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bc6abbc8451966dfcd8571d472da5e6f"
SRC_URI[sha256sum] = "c6adbc64a942764b10f4cb44ea524d6ee3ac9fa82b23ab856abe8ebdef6c3abd"
