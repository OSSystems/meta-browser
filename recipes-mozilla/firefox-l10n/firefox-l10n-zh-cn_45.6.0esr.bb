# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e04d7905cec9a8a168c628f428f6aef3"
SRC_URI[sha256sum] = "b92849fc289e03139a075cb916efcc1363ed82e2d13a97519c8523efe66244dd"
