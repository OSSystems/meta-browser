# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8d365ba5b69cb05d828615996e939545"
SRC_URI[sha256sum] = "6dc28b0b1167a02cd563b00db2fb20af8dac08e7865efeda05755c3ae29de2a0"
