# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "29c272b7da0d97d7a26a1f58d39e3937"
SRC_URI[sha256sum] = "13f0aa5ecc863eb46ae4c0b0de7546f9c8a16a121869f00ffa0f213d263f6c56"
