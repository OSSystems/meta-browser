# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d21505d654fd2b0d954ca81753bc0ff3"
SRC_URI[sha256sum] = "2f29901396a62f2c294a115246ce76267854a2e7b6e0c9f805966518f23e9346"
