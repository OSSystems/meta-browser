# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a8eb10ba89fc7a8af6f2cec2044e7197"
SRC_URI[sha256sum] = "7b28fb2baae26b4840ab53324646b622523b303d6cd0e98211fa649caf557294"
