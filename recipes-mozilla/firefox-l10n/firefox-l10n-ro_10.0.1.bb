# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "675d02401a2f01913764073f8e46e2db"
SRC_URI[sha256sum] = "20dff46763458f932c4d47c43a8d1b9e4dfe1dec54e169926e0c6635d8c93599"
