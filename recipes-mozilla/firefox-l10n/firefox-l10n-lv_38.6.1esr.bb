# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c5df08391a713652da969c3b186af0b6"
SRC_URI[sha256sum] = "c0337ceb0203e53f46f93d96b82b3bf7f81cd48bd8e0c7883f8d86a1958da3b5"
