# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d5922b1169b545e36d849724c1797d60"
SRC_URI[sha256sum] = "37a6b468044452752eb39d25316d3748c7aca3baf8f641246a578074b67666e3"
