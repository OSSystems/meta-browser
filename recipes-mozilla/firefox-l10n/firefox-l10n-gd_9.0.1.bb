# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "3b0ef47096df57fe43a65d33ad219903"
SRC_URI[sha256sum] = "0bcc61d4aa6fb751e4b278a9f622045da4f05ddf183e0ee424332409f93b195a"
