# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "05f2f4087edc60cf5568ebc012eeb151"
SRC_URI[sha256sum] = "0010843264a6eb9b45a1b7bc26b202bebf77d1684de0babc3740cf399bce1799"
