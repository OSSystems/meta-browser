# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "747fe7ba18583f891e2a83b14ac649b3"
SRC_URI[sha256sum] = "6900690ee5f194f3392ea9fc7d9d6b5b9fbcb420ee10ff21b53062e5dd16da6d"
