# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4d2632d06c161ab0ea2431c34a10064e"
SRC_URI[sha256sum] = "c757880ecef0a8f676ee4710d3711990341a34735af01c1bfd9b476689da8c48"
