# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d9e7e14145c99cc6d73b8fa5cc4ec9d0"
SRC_URI[sha256sum] = "3392b9dab192d4c6844e4927f81a8b45ad7f099a4eee64025f0f917d9448da1a"
