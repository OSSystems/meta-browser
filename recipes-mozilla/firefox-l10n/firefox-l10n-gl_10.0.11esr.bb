# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5b6ab4f347619ae01de03df7f798803c"
SRC_URI[sha256sum] = "96a188af032c3dc13976475d97b936ac7f3e6eb6ee8d4a6cf54494d122fd9f69"
