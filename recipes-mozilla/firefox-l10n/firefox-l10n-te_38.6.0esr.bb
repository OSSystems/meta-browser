# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "684f82c62a7487136d269e6d4390c594"
SRC_URI[sha256sum] = "a87f56bb7ebe1c01c0dd3aca66f0542d6c769e01171e99e6667a4f226cef2635"
