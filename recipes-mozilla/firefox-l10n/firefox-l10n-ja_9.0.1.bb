# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "0e1edc40634df39af781a8849730bf02"
SRC_URI[sha256sum] = "a9853e0f48b4699549de71b21be483d02aa924480a89fc24d75a8c91a9901e2c"
