# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "be8b072e04acf22f759a8b9c8ae718a0"
SRC_URI[sha256sum] = "987259cc1f6dedb91988c3281c5f26c5a07325e289df8a2090e44e408f8efb66"
