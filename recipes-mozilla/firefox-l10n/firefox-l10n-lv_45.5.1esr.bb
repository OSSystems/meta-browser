# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9080bbfb6eab6e12893ee4cf220b89af"
SRC_URI[sha256sum] = "0cff9a5cccae90ba6b1d5a8cd43e18388fe7c1a3ef7b2563ce85e759624f97e3"
