# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "983f7e218de3d81eb3d67d2fae2494e0"
SRC_URI[sha256sum] = "111df04c7e7be23fbd540a6923d4f000e011937b216b2a739952d85578fd69ee"
