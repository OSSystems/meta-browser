# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "745e178215282db3175e9826f14855dd"
SRC_URI[sha256sum] = "73064db0dccc3127d9998b04537d236a288538595e06c0f5d8b6a1712669cb57"
