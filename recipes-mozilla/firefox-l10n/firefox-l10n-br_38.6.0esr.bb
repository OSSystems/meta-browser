# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "98cb224af693f2cfe2090161c4c90d8d"
SRC_URI[sha256sum] = "64ac19d617f39376ef338f13cb114199407ac77c939f6b909092c394edc3567b"
