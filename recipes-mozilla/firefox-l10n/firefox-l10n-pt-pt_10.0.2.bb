# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "bbc3bcf2686e8d92bd7b7865c56e9615"
SRC_URI[sha256sum] = "915a3534b42a952aad218a05ba7bd72bd74619104c9e592f8654704cd96fa4f4"
