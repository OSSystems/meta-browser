# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aba46aee29fdb4b476e36f9cc6bc28e7"
SRC_URI[sha256sum] = "fe133da93e7c1e88f1c39321de56f679db228e7a0b7c6cd08ccbec09579cb9ac"
