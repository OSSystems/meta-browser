# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "34503640359a2db9d7285d5ef9f5a00d"
SRC_URI[sha256sum] = "330804510ccf84a95393858b9ad242b623b5340b0045dbd7874adaa84f3aa602"
