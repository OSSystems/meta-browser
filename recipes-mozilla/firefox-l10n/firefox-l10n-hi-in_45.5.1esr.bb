# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "82a7532cc9db5850025c31759948b7af"
SRC_URI[sha256sum] = "c579edc5c30e5b8cd0c4e8e988aad6fc3c84bef023a818920e18b78c52c4fcb8"
