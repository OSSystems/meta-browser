# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ec680401059b75a812d6f0dfa6c95e60"
SRC_URI[sha256sum] = "f9e656e45fe64f95a2abb818ddcb8e2344ea42545c59f8f6d29909f181933120"
