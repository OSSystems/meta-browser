# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f05923f6eeed36b277b56f65eb1001f9"
SRC_URI[sha256sum] = "6d69d7543694e5dbc79918b630c0ebed94c7cb67dc3ee6cf93f05accc26af920"
