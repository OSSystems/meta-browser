# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "4d51a470ba37ac63e2845d98f0810275"
SRC_URI[sha256sum] = "1453441467a5991cdc33ec56194d801554c69b87eaf677225a79020d59cdaf1f"
