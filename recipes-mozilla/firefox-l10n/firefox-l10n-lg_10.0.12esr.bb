# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "44fb84f92a3d6e2c4ab6db71868af786"
SRC_URI[sha256sum] = "127028d15502046ed87efa35d47bbc9ec705c09ceb26cd65c37ae1793e4ae4fb"
