# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e46c0154bf49d3b2ada9c0389a060b1d"
SRC_URI[sha256sum] = "61c1be8e542963a86a799a1842557e334d62d0121ee259ce52eb701d938db2d7"
