# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "854bc105e0ed13cd7e5ce4757df76e4b"
SRC_URI[sha256sum] = "2cc60c9216dc38d7b28a7fd1594d1755c69378ec05c9edcdaef5b6de9ed3a11c"
