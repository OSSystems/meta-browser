# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "3d93314695ec7bccf4e6ebeaa2e59c49"
SRC_URI[sha256sum] = "2b6a8ad215194dfed9233d6e4954b014300fca96be521faae88d1dfff4c118a9"
