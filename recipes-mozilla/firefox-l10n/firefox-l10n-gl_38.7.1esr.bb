# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3973d82ffbd7916ec3cdf185cbd340b5"
SRC_URI[sha256sum] = "61a24fc4decd3fc98815784183e98c9d631fb0569fc8342c2d052585c5367264"
