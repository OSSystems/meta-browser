# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e587e189a8438ead7451b7c400909ecd"
SRC_URI[sha256sum] = "6100f5ade04cf30db44cb175fad1777f0340c73d57ee0d9b90d6ce8993ae4831"
