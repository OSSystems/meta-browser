# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f6bed98083a0c9adeee21a94bd58439f"
SRC_URI[sha256sum] = "a19113d4d31a1914b1634d7db52e05e321af294605eeadd6af4abb62001dbee7"
