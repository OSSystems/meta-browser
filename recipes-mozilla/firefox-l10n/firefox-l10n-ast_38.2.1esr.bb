# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bd81bcb212d21eabc1af24a87d7b14e1"
SRC_URI[sha256sum] = "9a3dad64dd09a11293936ad421d9cf54a112363497fcf2263e56fe4dc059b648"
