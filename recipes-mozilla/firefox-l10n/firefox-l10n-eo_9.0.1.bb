# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "3b7e885e28df32d945033f001596759d"
SRC_URI[sha256sum] = "ec531522738518a27027a423822534d3badad29f48770d0e9c826a75b82a540e"
