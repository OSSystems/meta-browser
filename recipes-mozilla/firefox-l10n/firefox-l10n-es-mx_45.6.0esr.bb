# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "93284d5ddaf7d922de767035c16396d9"
SRC_URI[sha256sum] = "0551d4f51ca86d3ead5f899bc15cc133260b38f94eaa936e893e29a801531dc2"
