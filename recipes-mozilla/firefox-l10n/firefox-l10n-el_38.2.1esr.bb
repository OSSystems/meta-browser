# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f71e2a26dec562f72d1e00b7f090d248"
SRC_URI[sha256sum] = "b0bece2e1762b042044e676b13ab33b5d8dc6397c84974ba485e656bfa859fed"
