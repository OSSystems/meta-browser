# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "52fc20f6f53cbb6b3fc79d98938e803d"
SRC_URI[sha256sum] = "f90b283f457fd191eddf46d505bf8b2a5a9b6522f47e951ea134ae32d2dd54a7"
