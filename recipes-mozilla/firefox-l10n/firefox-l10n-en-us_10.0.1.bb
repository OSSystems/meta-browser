# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "e8726d2e25da05a270c76085f69a2193"
SRC_URI[sha256sum] = "8dd183606ec2b69637da513a2e2e5291ce3621d38d23e1dd417df412ad861a0a"
