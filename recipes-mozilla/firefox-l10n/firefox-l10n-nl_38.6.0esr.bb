# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d462598eb0d09e9a90d49172a0c3da58"
SRC_URI[sha256sum] = "963ef9ce080aa18c0c4dac7e1192368025be95d7a0e4363ea63006a0950c85ad"
