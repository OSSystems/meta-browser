# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "198c4126991c67bbf0d172ca386e1f4d"
SRC_URI[sha256sum] = "c49964c7be3c339f3306b0c3c4be38e284f02d59a9a7119530976a4a15d4175a"
