# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d2693b1d7bd76b05ebe839a4cb69db1c"
SRC_URI[sha256sum] = "23d0b0a9da9d207775c82f3f0b4b99d1bef54e1d50e9ca8920748ddbb3bd17a8"
