# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bf548055fecc52e5ac41e484fe1e98bd"
SRC_URI[sha256sum] = "b392ec30ce941d4761f2c53ccca02edf7be1b8f06390642b584bdfb2f8705e6c"
