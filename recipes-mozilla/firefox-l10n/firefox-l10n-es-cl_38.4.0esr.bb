# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "015d30b4be97fc44834747b4253c6305"
SRC_URI[sha256sum] = "519db83d328d45e0617e191a03d6eeb852f6fb78266aebb7b5fb20c788d1043b"
