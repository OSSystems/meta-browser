# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e32df30e19a4d93f9d0b59ba5090f34c"
SRC_URI[sha256sum] = "99abed00052cce52ddcd65a2edaa95b0311c75d3522b4784760d947ec7c2e41f"
