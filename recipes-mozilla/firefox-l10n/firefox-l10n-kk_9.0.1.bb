# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "4ca58cdc358f10ff7df70098141ad35f"
SRC_URI[sha256sum] = "c1cf4d9a68e536b40a8a9bedf85560ad8697d08c3b6bf2754caaae361e068073"
