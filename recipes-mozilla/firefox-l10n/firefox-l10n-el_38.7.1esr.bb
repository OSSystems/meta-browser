# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6048448adb6f647daecf070e4ec8d293"
SRC_URI[sha256sum] = "f7798d14e6b623a4390d2eb6aebb5cdcf0ac14a538d0aa60d0f68d6400110201"
