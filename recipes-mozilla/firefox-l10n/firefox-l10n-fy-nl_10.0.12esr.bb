# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "72fa2c81af3b3d7831fb43fec8e35a44"
SRC_URI[sha256sum] = "470ed8f1d8fe386bc3675f67680a3c935f6b5cdc7d08ea8ae4e010739f10cf90"
