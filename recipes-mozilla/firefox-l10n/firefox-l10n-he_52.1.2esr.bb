# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "698f3a428fb843a48b1ebf20d8839ee7"
SRC_URI[sha256sum] = "cc22a555809f706d34d99172523b0edf171980059d361d9aed76d83f2e9b6808"
