# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d110b03a8f07811571a008c98331b13a"
SRC_URI[sha256sum] = "e109740e0837c75732fa40c124b51355ed7cc3cd0dc4ec6a9f078298674c215b"
