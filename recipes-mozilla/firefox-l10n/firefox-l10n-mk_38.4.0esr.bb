# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "425880264868b9a4ab8724e287455e9d"
SRC_URI[sha256sum] = "968070d4aee6819afbbc303e215b21afe2884a3004dc7d7696113b01423166da"
