# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4a4773371a87963be438f06b460e3d17"
SRC_URI[sha256sum] = "d62055e9c602e3d5807cd6ebca9626d2f31bea3155c59a0eb1a8c2fde746d24d"
