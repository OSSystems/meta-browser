# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7d37254fed5a07147bd850a08ffcec4f"
SRC_URI[sha256sum] = "d65c3b8d8796e3bc3383879da80bfad4d3133c61efc4191f50de1cfabb6022d1"
