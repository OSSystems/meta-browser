# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "399f8f3ce740492d09293c3c16cf941e"
SRC_URI[sha256sum] = "e6370c178ed0f5bf8b0a640ada6b83137350ba41fd01acfdac47a0b719ad4dfe"
