# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1d062ef69b128e15eba47ca289dbc30d"
SRC_URI[sha256sum] = "d3fb903212edc4a40c5004fee75b0f9f1c0e04583c8b289192f22076e0c98cd4"
