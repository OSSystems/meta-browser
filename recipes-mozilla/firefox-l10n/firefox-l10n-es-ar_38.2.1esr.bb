# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8e2f2b4843c0336c2839706937740881"
SRC_URI[sha256sum] = "1539d6b82a8a475fab958de03819b9ab866531d826248882f70dbedb52caa095"
