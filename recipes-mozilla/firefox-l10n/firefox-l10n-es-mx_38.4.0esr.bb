# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a1a531af84787d7819d45e0dedc9668d"
SRC_URI[sha256sum] = "c7db8de566c0b4d0ae916877145e0766919379c583405c5ab3f395ddae4dcab6"
