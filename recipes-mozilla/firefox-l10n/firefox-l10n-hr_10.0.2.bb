# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "a49b79d9dfea54f15475b00d580d231d"
SRC_URI[sha256sum] = "4558dd94f4b938c533f7205c1e48024801d63a17b0df290a9d9810234fcb1706"
