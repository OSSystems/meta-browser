# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c5fbcb56c76449c628cc5ea537eb31ec"
SRC_URI[sha256sum] = "fd8b7b2c706fb013f452d27a4b5f908504fc712458c6488b8cbdb631ccac1ba3"
