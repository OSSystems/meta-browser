# Copyright (C) 2009-2013, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "526a84cf109a342a5b778d2507a6036f"
SRC_URI[sha256sum] = "635a327b322995d2bbe0967bc7bead3c19105dc27476e6a657981fe1d095693b"
