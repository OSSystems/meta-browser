# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cce2c726c136cc7ae1343759e6a0c633"
SRC_URI[sha256sum] = "34c8aa37d1e6c914ad97aba939ce26800d71d96ed264247afe56767c57bf522c"
