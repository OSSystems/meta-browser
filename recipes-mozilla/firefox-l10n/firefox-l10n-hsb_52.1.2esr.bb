# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "248a6c78d3d593f2e0a85b49bc3e76e3"
SRC_URI[sha256sum] = "2d359d5b6896bef34eb0006208dd2518360afa8351390595a6aae440332d1f9b"
