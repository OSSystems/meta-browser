# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f0031874e52288d93a419d798b9c6b2e"
SRC_URI[sha256sum] = "b31e7ffac7efc34e4d1672095f716f0cba43860fac1e596b7023be78a8306b74"
