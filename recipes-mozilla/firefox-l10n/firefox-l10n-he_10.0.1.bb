# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "ef49dc011d8f3b97d41a577d58f59cac"
SRC_URI[sha256sum] = "ed442430002b6779a29a7688a4bac1aa175923d5a69226318ce1e30040a80c14"
