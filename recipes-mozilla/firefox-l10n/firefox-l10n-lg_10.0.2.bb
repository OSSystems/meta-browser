# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "49306764b7978df9f76ceed98ccd22f7"
SRC_URI[sha256sum] = "7726b7d8669d11a03cff334aeb360944ec488cf0e8ca6d15b41e1cb59eeb8e5f"
