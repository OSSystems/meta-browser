# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "42d3631d323cbaed5e742f5aa9a94c70"
SRC_URI[sha256sum] = "ae02bc7b8bcc4d5bb9cd56562d1b0329d78c7fdb96bbfb86e35bedf4e2dd332b"
