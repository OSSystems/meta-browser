# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "2c97b8ac91c113fb20d2fc74d33cbc0e"
SRC_URI[sha256sum] = "6f6360f8117ebe3e1fa7cac464af56ad277602fbc8f95f43753a2705f0930074"
