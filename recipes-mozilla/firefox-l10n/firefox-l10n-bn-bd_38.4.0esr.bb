# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eadce4faf22e60aa1b8619d10689541f"
SRC_URI[sha256sum] = "3b9130b35ba2dbee86e6b7cc7e1db9bf5e58ad58629c2c73ac383890602b1cf0"
