# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "052f84a85dd3dced24b05da64cad8b1f"
SRC_URI[sha256sum] = "c8829b4de0bccbf5015788aead4be109eced568610ac2b2452f7348790b58c48"
