# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c18f949f994dcfb8050e739f9a0ae699"
SRC_URI[sha256sum] = "1ae11147ddd2fcd7c4235713a19ca4a31ff6b77d313b1e139f66627b5b839cfc"
