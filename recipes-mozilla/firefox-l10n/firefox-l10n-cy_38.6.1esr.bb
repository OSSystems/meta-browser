# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "67f2e95ecfc81fab27e7dffce4a0702f"
SRC_URI[sha256sum] = "8dc6fba4c340397095f492832572e8b54da5cd57532da8845a577043922ab90d"
