# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "52e05cf6ef30059040e171f5e52da575"
SRC_URI[sha256sum] = "bf7263bf5503f7325be851c4fdc099b6336dad62fa6cb7086d3c3e384f18dda9"
