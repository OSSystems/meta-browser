# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d1642d4a27af2d3f057e3079585a4c21"
SRC_URI[sha256sum] = "847527fdf773269ecb4431c2990877b9b22f047caab4ab0532333185fa30adea"
