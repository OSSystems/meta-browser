# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "af64233de09fd19b9d54dac5ecc51e23"
SRC_URI[sha256sum] = "bf57f779d89cf4e72ed1d4c7b6100facf28ed829dc96f60dd5de52d4289bed04"
