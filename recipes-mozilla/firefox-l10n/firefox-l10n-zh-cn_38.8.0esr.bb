# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "055ed41afe34b443a18eb617eff6d82f"
SRC_URI[sha256sum] = "ee1655f640326e2b294f7c47712ed1c558591e3bb4be531439bffddd89c3c7f0"
