# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "85021f80d790b0e7c9f7f630bee2662c"
SRC_URI[sha256sum] = "d408a34d2889e9ea2b5add8cdfc3d57279f90073a1bc83c7d6a96033a0b73020"
