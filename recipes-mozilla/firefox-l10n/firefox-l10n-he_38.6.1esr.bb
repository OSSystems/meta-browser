# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "007887e904b8b0ea751446362f6cb3a9"
SRC_URI[sha256sum] = "fb8d79576c0ed7700fe1ac0f89880e9cdee41a370ffb5aba6a5ea30d353f1dc9"
