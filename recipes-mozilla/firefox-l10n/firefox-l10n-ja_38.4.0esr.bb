# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "43f0cc70f4e9d4c3f20b3785f17d2773"
SRC_URI[sha256sum] = "eed8773e7f2b2706884ef844805a3ff4d8efb20a800ed9b1359e392dc6f365e7"
