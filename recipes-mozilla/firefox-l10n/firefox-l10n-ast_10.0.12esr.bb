# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "110129c392ed671452cee74b9707f09d"
SRC_URI[sha256sum] = "0cff3692db8cbe875a22114f61319ac7e43e9d39c3f70c8656a2354ab3da5650"
