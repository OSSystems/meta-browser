# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a4225f8a8f63984d65fa300d029533f5"
SRC_URI[sha256sum] = "fe1f07f526b2a4069e69bf746e31fe435058f8eb0daf24e72e0362af00e0679a"
