# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "1f6b1bd0c9e86d6623a60ac9c3b80226"
SRC_URI[sha256sum] = "0ee089701500530e52ff60fec662f177ef98e8c68392db01977eb57ef78e0988"
