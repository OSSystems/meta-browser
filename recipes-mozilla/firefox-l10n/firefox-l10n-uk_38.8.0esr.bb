# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3831902fc17cad28fbc0cb74011f4c6d"
SRC_URI[sha256sum] = "73125a7b3ce0b922a64fc528a790fccf705fb8313a6ec16b20c154475c3d1d08"
