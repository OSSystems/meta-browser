# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "921bec237aa15747ea635212110b4397"
SRC_URI[sha256sum] = "4288b3589e29e0858ba3f31ab326fd1cff5d9046aa89da64b15fe6fd9e8d0240"
