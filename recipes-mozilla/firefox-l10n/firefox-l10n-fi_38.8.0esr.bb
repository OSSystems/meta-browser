# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e5757418bea4f849ac4194aedc077615"
SRC_URI[sha256sum] = "bf16a186835e96e2d5cc0f64437e2d5454a0b859a7ac631ad891be76597dfa8a"
