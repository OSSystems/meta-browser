# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "a6b315502d44c8bb80334434f2f18507"
SRC_URI[sha256sum] = "2731e8d49395e0ebadb6a7c5edfba44b7c5e3ddf3689d35fe6b358fcd5f681ad"
