# Copyright (C) 2009-2013, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "2db725e68c9d3a2f383a9c885a5eb23e"
SRC_URI[sha256sum] = "5dc01d26576ea193ebb0ae6191da70be1b0ea4fefab3f83933ae7df6d599408d"
