# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b3240952c41f39ed3a0cf73dd9da7de5"
SRC_URI[sha256sum] = "75fa3b403ba6be699e7dce4d189231c6ce6c50d0ad44e672140f5ec680635100"
