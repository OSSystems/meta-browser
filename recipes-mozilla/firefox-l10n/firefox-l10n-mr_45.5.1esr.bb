# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6c42e4c818e05e84781f58f5b8f17cfb"
SRC_URI[sha256sum] = "72542cee0e1b8d07a948d518bdad1fd1543f95e59af9adbf578d741bb186f526"
