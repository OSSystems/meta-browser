# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "10369d737299aea54b734a369ac72a1a"
SRC_URI[sha256sum] = "86047af8b5ac6e372c9a5b061fb3df6287a48aa28ec8c379d0cd40cf1a630efa"
