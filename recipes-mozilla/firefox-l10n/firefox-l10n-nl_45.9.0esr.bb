# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ab76f22491d0022720f867258a40df89"
SRC_URI[sha256sum] = "6bbba178e83c39cd59916b4c226b6ee65e05dcaf4fe613682e5fc80dd1d86d5a"
