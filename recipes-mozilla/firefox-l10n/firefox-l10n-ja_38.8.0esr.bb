# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0a73a78b16608fdd914f347a60418f2c"
SRC_URI[sha256sum] = "c9e3ca5c725c328fe964b619cf502a0db1122ecae143e17a1270b64acb7bf64d"
