# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8d8c3493a07b9082860cf84bd945e5b2"
SRC_URI[sha256sum] = "f5b4a1884103fbf70869cc0c6e0971d6cc14f0ba7c70ecfe9763460024ca6487"
