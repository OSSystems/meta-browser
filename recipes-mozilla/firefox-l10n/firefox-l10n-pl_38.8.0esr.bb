# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "474e5f21c7f37e04b86cc458cdcd4933"
SRC_URI[sha256sum] = "5564c4b6deff307a50bbfc4f12f35fbe7fade4f2d97eae0604ac556edc3a7063"
