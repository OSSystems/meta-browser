# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f025343083dd1bdbc65b940d258d01f4"
SRC_URI[sha256sum] = "e749074c9260be3eecc42976c06341920b93015a40f2564f9e04a6de7f9b47d0"
