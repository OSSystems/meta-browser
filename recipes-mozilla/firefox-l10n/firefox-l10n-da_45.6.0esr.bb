# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e42ac2e7c912c90dcb9a2d821442f825"
SRC_URI[sha256sum] = "217d08088073beb852e8ad93bc1c34ba0ee59d4e1dfee92d04a97360fa0666c5"
