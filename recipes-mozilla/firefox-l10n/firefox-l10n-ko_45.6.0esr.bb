# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1ef56efcb7ed9bde0d872a8f6552f8a3"
SRC_URI[sha256sum] = "22176eb8bb6fbde1efb8d67f1dd7563c575215d813fd7100c946ed4220e1ffee"
