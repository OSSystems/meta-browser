# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3d260ad74005ede4cfa5d2ae59e47614"
SRC_URI[sha256sum] = "7d0af6433a55c2b066f136de7cb2e19182f2357d7e48ac7711dc0dea17c27f8e"
