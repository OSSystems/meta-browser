# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f1296a64feebeddba87c755c0b9ccbcd"
SRC_URI[sha256sum] = "bb8abdef553c446d822262db8268beb9962e8085847e1f4735a6838b1faedc98"
