# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b457e04fd32f0e887db6814605b0cf3d"
SRC_URI[sha256sum] = "7c97c296e9117e0ef1d11bb39b606d9c8ac5efdc4808b2c67ca8331b7178cf71"
