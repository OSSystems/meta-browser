# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0158f7689b40d82b4045e6e35a37411f"
SRC_URI[sha256sum] = "4a6b29fc389af54c294f5cbba27780aa6a5e63329af5d1407f42ab240462099d"
