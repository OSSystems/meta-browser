# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6fd0fdd1c9f372485abeebd0c4386e55"
SRC_URI[sha256sum] = "93a067150eb88c7fd59bd982672ae0bd41344dbdde468fcc41b94ae23672aa28"
