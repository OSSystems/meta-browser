# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "66bb68e84b65b01c8e20cdb8a9a4d29b"
SRC_URI[sha256sum] = "1f2d14ece4cd0cad5cc7265a12498f669397b220b335244b70c62e826eda720d"
