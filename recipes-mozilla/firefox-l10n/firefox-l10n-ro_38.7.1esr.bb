# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "84fec9b03aadcd1b9aa2c52f23746996"
SRC_URI[sha256sum] = "5ec5d1365df706e1cb24877df22ac97e7aaa982af951e99e4318d05a6a4c9164"
