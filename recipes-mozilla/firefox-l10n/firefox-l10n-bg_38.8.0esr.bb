# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "71d5b57d3a4a4e8a60a10cf62695e974"
SRC_URI[sha256sum] = "64468e5eedf9e47e3e4bac2fba913e97d93cdeead1a006a84c0bb7f0ac176dde"
