# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c05a70a624034541c4300429820db864"
SRC_URI[sha256sum] = "4d48d93f3a97a0b2853c1aacffb726bf49c32822069904fe419ff3fb9f04bcbd"
