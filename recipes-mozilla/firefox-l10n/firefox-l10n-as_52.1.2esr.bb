# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1417623aa8953939264c9fc8f3185323"
SRC_URI[sha256sum] = "b24d6637f4d513ed580ad848f11a319c25f41080ea6d9f41d9d27ed2b5d76d91"
