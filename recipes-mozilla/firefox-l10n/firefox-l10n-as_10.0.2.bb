# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "65d168befac8473619536e9929e1ee2d"
SRC_URI[sha256sum] = "20da82bf879a19302a21ed599c5fab070f556473a37a4003c1401c66b1b35d6e"
