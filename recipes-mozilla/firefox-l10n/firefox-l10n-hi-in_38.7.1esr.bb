# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "54d564d120e747aa565d2b0ee88ec8b4"
SRC_URI[sha256sum] = "9330e532d897056aad75c33ac89c34e947d45ba902679d67b02201936b4ccdc6"
