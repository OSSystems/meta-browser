# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b09beaaf8ea1ac8ee47d3aea6682ec30"
SRC_URI[sha256sum] = "698a0ac8f2d802d55d55dfc55d6a870d9269a81e73506ba2ccbe9875e4bad00a"
