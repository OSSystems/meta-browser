# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "43d628e5a125d30944118d194fa90d47"
SRC_URI[sha256sum] = "22f4d92fa7c02eff4b0976983c25d151ac3dd6a3b85f502714cd607eec0c9979"
