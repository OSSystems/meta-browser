# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "99597a57445b47484b5b527cba18e0ff"
SRC_URI[sha256sum] = "167346fa2c0259fb4aa5931b9e6ad7e9db8248053ee94e573ed8b1a9eef3614f"
