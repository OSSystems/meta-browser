# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f95773393c8c6eea36d225b9ba2791ea"
SRC_URI[sha256sum] = "d0cf5ae20865a6422d425be16e441911ee7f628e96993693202c3a1baf9cd454"
