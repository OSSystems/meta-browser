# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "552936179c5bf0554496fe15fe0036b9"
SRC_URI[sha256sum] = "4c3ceac9bec6807115249f2a6eb8481dd06b1f88e85e8bd7047fa94187b146ee"
