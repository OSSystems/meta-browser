# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "ec6769a7a81990d063fdf48094e4adfd"
SRC_URI[sha256sum] = "0ab72adb367b54267a6b094edeff5c9f2e99598979854f66ae12d771a6396c9e"
