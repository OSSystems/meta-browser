# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "16cd02867207fa6da075c3853dfc5051"
SRC_URI[sha256sum] = "14741b89eb28ea486b4d57bc0e7ad348039a469b4e7ca40b98f1f83f1b6c0b75"
