# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f503ea2dd25203e70c9faf2a65e20fa3"
SRC_URI[sha256sum] = "2a51a0440d67c3e5067fab99ffed2f8142f058f10910d72b0fec4a461c33d04c"
