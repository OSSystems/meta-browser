# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "eed676f4bfe73af0fadd086e1a918f8e"
SRC_URI[sha256sum] = "99b549f4f9f18e6f273f7ae4159c23b59c16b4956b7a466e35468a3639a2255d"
