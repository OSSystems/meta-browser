# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f846ab7e5722d9f148c6e7e3b58e50a0"
SRC_URI[sha256sum] = "0aae66e099071859cf4eed3217d73121c98e5c3474c3725f93c78dc0d4509edb"
