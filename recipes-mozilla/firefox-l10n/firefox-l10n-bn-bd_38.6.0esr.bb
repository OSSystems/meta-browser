# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4812bfad389487891f9375f5aa08a3b7"
SRC_URI[sha256sum] = "fa83a06b8b8ce4454a3543b13bbed40e92b8be87c3607b93d5efa41fa01f6d3d"
