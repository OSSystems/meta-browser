# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "6cd2d97fba6cd8022a7695cc5d40dbe4"
SRC_URI[sha256sum] = "cb195840df871bd6913430475666264664c7c611485feb76615f2d75b77853a3"
