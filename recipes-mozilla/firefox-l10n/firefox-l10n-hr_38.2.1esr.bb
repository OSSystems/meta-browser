# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ed01e4d1a2bd26767578b62c10063207"
SRC_URI[sha256sum] = "2405e5459c45abbf455845eee66bef90460f4c5c34aa1abede38737d2d8bbbd1"
