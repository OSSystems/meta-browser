# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "eab12d0129ac20ab0b78a446720d52d9"
SRC_URI[sha256sum] = "2146a9718288d4a6c5931601481ada254cdc7575048ea00010dbac3c5b3ac2f4"
