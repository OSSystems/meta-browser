# Copyright (C) 2009-2013, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "7239fd87d0269a238c3a8280f4438fef"
SRC_URI[sha256sum] = "a2dc136240db5c0ff1215674c415624e8f21dd8623dbe87725ef6c9d2226fb1d"
