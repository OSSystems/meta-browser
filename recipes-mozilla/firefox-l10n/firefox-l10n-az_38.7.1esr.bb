# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2769f217e67ee153e76fcf0596d399c3"
SRC_URI[sha256sum] = "f0600dcc8b1b7e0d871d402aa7f93e16796b1560d329bb9e93c65649c6117ba3"
