# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4133d8cbf2bc90721a902e3abf8d700b"
SRC_URI[sha256sum] = "7413cda659eb5b8d18b00b300d214b2d6912a1174ba09055710ef4243fa235b1"
