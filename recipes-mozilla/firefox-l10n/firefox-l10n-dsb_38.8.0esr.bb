# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "19d5c82cce64e6757c48831fce168a67"
SRC_URI[sha256sum] = "949829faf5fab47302c787b2b713af5de07233a60fcfd6c06d9207b81c4e3213"
