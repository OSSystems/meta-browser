# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3456c9c9e05ec0c5cf867e19fa599112"
SRC_URI[sha256sum] = "db861b6fb4eb4b46cf21e3fc56ec3ba98303cf0aa8c2d5c1fa4efacc93342400"
