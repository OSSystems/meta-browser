# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "35762880266f4a9c14c6e03527af00ae"
SRC_URI[sha256sum] = "4782fbe61f664d4435852cce8c5f522cfb90a792282909acc50aea35c6930265"
