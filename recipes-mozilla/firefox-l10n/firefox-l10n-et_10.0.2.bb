# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "0091992f96645d70bec6689e6b416410"
SRC_URI[sha256sum] = "f34b86859b2f39265c06d1709e2699a820e37835ff811cdf3049d9d097ff9618"
