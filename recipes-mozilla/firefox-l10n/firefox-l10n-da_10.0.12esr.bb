# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1e26c844241378906d4a659ffbd4cfcf"
SRC_URI[sha256sum] = "a46e30922068dd1e74d9a2acc6c5136c4b55a344bc9d7c52afc3336fb0db9b4e"
