# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "20ece8b060f8b060b3335184f000ce2f"
SRC_URI[sha256sum] = "c3038ebd54153273d4d510dda53f144b2820944231659ad3e01dccabd53d0a6f"
