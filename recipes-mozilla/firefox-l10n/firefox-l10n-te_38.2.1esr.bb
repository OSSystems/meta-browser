# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "495cf4ef07cfeaa8cadf67e9c3fce19c"
SRC_URI[sha256sum] = "3b73a6b26d29260599d2d2b24a7bc0809a644de1e8347e60ffd4c5014109d0dc"
