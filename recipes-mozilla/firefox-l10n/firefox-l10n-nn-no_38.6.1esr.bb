# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9013692f5f28960a21e86394d294dc20"
SRC_URI[sha256sum] = "103a84989e908efc56fa62120aaaf9056ad6347dafc25672bc8f89bfeef160fb"
