# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "80045037764dc4d172bcdc09254879f3"
SRC_URI[sha256sum] = "6adc74df6836b971922095f42d9014c2b32c5d62086496ccf157fab9e12e3e66"
