# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "16eb56d473816128cc24049aec554e49"
SRC_URI[sha256sum] = "35a2bfc46dadc4aaf1f8725617259699e46509e99d43895d67b5e39d6125c7a0"
