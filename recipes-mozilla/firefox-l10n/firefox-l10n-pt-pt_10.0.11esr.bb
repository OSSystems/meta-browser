# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "675a0ea6ea04234b17b99c0f80b77ab8"
SRC_URI[sha256sum] = "7bee6a6533029db35546bd401ef2b6cd60edf5c8ec334181ab3e4a915ae24c35"
