# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5b7d2e9a13dfa07fc218c630a901aece"
SRC_URI[sha256sum] = "e0cb68b939d965387e706f02fb5771fb091900ec392b135cfebdc3f1668213fc"
