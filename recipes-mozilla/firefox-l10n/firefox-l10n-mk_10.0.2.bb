# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "2ebf64e05d51b50ed7aab906542967b3"
SRC_URI[sha256sum] = "b1c8f2accecaf4ed98e09625abd377a4483321aeaea46b6a780098dffe21c2b5"
