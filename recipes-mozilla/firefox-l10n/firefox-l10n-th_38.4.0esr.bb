# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ce5b277d6087f94fcaf40b9843cbd560"
SRC_URI[sha256sum] = "2404ecfd24b2dbbcad006316599a6f2cceb687cdfca97186f2756c4a2dcfb257"
