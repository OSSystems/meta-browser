# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4a0b458893cd39304b5d9d05c56c767c"
SRC_URI[sha256sum] = "46d94a693d96f4a920aa8401a58eb6a96cff21aa9aba54fecf2c8c0987b4caa0"
