# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "63ea19f5f1259434e822787645093314"
SRC_URI[sha256sum] = "5038a20d58fe4673ac8980b2030a797543c6f9d09bccdc32e4bc2d59acfb3187"
