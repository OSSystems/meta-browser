# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3e89f09d61e6612ca5f0ee679333d155"
SRC_URI[sha256sum] = "3307e02df045e91d4406e1008fca298fd386f707899914052faee11a10cb79fe"
