# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "697fc53ea4da803dc0265d42251bd501"
SRC_URI[sha256sum] = "ef4c959d24191e6abd54eb03bf7848a08f7ac4f0196e219c6074bea377e87ff4"
