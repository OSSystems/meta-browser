# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "1e6cbc70983021fba3c6e487ca213844"
SRC_URI[sha256sum] = "15c33802b54ad2b053808f755002e80905a1780321e3416dc8aaad9cb9520ae3"
