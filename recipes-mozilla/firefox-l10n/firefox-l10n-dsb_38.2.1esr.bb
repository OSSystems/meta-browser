# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8992dde7c72291223751fd471a281ffe"
SRC_URI[sha256sum] = "f925101d6416e20725e7f20632d4e3c3c22131b2becfb393e7811d5dd8e849fe"
