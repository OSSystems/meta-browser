# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a4d081d68debdc63d48ad3b5ae486858"
SRC_URI[sha256sum] = "625db0cf3bc1b23a1fb1b49c21bfbb1671c4fea84db64ca6d0582d817efda419"
