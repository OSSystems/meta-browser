# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "40bf1fad7dbdd91518575120dd5e0cb8"
SRC_URI[sha256sum] = "b0a0fad4a02361f41a75ea4508e1ff34ccb40891246e1a599ce0700795608592"
