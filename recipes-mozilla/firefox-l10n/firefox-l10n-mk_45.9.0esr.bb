# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "59e3239305f9e02bb4daa24858edd3d5"
SRC_URI[sha256sum] = "63806864dbb260b17e0542774d573c0e75904c3477ebdcb23d7dd13a24992a09"
