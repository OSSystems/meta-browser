# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "995e5b9cb696606596c4225ba9700ff9"
SRC_URI[sha256sum] = "c445a5f538cec05c69d2a7838f22e18123f34d7217454984ff9c02a7072364f6"
