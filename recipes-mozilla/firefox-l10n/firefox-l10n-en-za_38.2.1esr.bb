# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "041d513db4293296835935d814679400"
SRC_URI[sha256sum] = "d4d06c2c80202f06a837dcea7e0431f8556a58e7a97e5e1bdd41ef8cd575f8db"
