# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1463a953daa4bd777da2351bb301df6d"
SRC_URI[sha256sum] = "a26ca317025b57f8465fee3052c97d013755f8a1096ae1258adaeb7aa44a3e8f"
