# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f9e2a81b8f01257ac86759f926d5c4bc"
SRC_URI[sha256sum] = "352a476ed6c43d06e44e7196d08c20f49c8df7ab5720b56372a380836924c69e"
