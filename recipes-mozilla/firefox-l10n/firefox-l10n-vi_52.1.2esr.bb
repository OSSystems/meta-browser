# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "380c7cc2c33b627c2c9004ed55f673e5"
SRC_URI[sha256sum] = "a7ea8a77fb6860eb48a582e37df7a51307223c5e3f3096cead181c2da7a84135"
