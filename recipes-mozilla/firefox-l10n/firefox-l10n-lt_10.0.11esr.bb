# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "30a19199a4ee543015f052d2bf921a70"
SRC_URI[sha256sum] = "13fac6431709afd0741a94f4f3ecd365926b43c4a01f0eb1f4e592e32f62113c"
