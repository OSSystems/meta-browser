# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "36e3106f6044afd6bd9c7b6397356ffa"
SRC_URI[sha256sum] = "8116c880098c2efa89561edf0ef0541cea1a1d742dbfc6df97747c3e7d8b4003"
