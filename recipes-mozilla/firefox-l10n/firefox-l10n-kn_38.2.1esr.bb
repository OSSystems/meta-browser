# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8c54e90044ed34b49585ef268cd62228"
SRC_URI[sha256sum] = "b88e298f2e884a027a993b1e08bed8d4b693cc86d0cd9593570cc83561e9ebc1"
