# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "abf0500442633717ec77d5f26328f7ea"
SRC_URI[sha256sum] = "1f57e527ec29d17e653e6849007838926841945c7052c4b63ee0d8c44119d9c2"
