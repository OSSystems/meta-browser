# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "56f880b8a5ab8f867e127f537b079b56"
SRC_URI[sha256sum] = "05c75eb9c8b4e92403bd1b944e664daef3021643dd8220b18275f4f0e8464570"
