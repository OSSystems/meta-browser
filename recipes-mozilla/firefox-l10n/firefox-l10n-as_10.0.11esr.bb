# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6da8f4df99d55daa2178634b021f1e04"
SRC_URI[sha256sum] = "719e62f4992f4cb3cc9ca129e10b72794cdbce864dd76d75107a0dce08d994ea"
