# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f3092cdabb83f372ea6d5f3e1fe1fb74"
SRC_URI[sha256sum] = "dbf3d7364d8d535cbc0c79dbf1addf8a688bf6b09035be762ebc4b64307c506e"
