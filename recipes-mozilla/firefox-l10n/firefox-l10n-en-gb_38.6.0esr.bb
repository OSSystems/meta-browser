# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f525f3d44df4bb75ee37ec59715f183e"
SRC_URI[sha256sum] = "ac83745df0734e618b6a5b52166c9e2564c40ed16691da121ee0aeb7eefff506"
