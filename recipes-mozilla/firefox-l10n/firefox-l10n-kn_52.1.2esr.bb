# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c51ef0dec95e09c5b19b274958c78d7e"
SRC_URI[sha256sum] = "f3806d1154c581578aee37915cc983b35141791c5bf276a1822ff9272bc11da5"
