# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "498de119cf057fb96432281b5ba73781"
SRC_URI[sha256sum] = "3287e490dfe0ae1bb59a61dfa37b3599e4279445523f60ae7db8d0c6cab85f77"
