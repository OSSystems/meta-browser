# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3fb6ae874a60c9613f84bdb442350f7e"
SRC_URI[sha256sum] = "d901f4a9f1067682058d9129b7bb95a9cc9ef87ef509719fd45e6f8de942adff"
