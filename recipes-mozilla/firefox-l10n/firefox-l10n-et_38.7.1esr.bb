# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d99c75316731b8b1d529655306fdea34"
SRC_URI[sha256sum] = "0577f74dac4d36ae9ed87aeffb2e4d6f9cfb2286fafd6d8b45378d6aec7919a8"
