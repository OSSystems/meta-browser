# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "81152119e668cd7d8f52b0cd1f9739ac"
SRC_URI[sha256sum] = "0b910abf322f75867186fb4af8d39a77a7b828e3d0d674a923f277f8ea4327bc"
