# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "66331b24b78504b6852a03f28e3cb0de"
SRC_URI[sha256sum] = "639fb75e4d13ac50db0e70d35a92571353339c004a8bcf2ebb5e348896f57d67"
