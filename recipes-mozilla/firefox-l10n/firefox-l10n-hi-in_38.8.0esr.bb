# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "75081c1d4563df452f9a49f323d372de"
SRC_URI[sha256sum] = "092468b946830c782132aba82c0da80dfa528340c7c544566acf9f4985019dd1"
