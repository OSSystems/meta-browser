# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6b77c6ad7fcc1208b831bc7a8a4eb9e9"
SRC_URI[sha256sum] = "4edf68595d772794d3654d1cd12096076b073d9da9792cc971e5489f80d1d136"
