# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2478777e61bf5be67c181aa7c7868f15"
SRC_URI[sha256sum] = "67ad0c3738ce988fd14536da26873519bc707e554e57e02e08c36a74228328b0"
