# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aa15d83e0aae8e54440890e28d9710b3"
SRC_URI[sha256sum] = "ca7af3618961542e003c28b2c0b0a87b79de1f98d8296e2b3623d4de18bdd5cf"
