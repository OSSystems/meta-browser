# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8dc5155cba07ad55849175a2b551c333"
SRC_URI[sha256sum] = "7613f6fed1915aa2f9eb19d3b0457c15fd1a871a8e08b090db90c131defc36d6"
