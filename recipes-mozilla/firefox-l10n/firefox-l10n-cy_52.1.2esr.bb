# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "994576627fb1ee024ddddfc988efc933"
SRC_URI[sha256sum] = "34b277fc043114d04b55de7b09665d60d96242b83078304db4067673b5e163a3"
