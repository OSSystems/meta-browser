# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0188257a1ac4321e95929b073c180efa"
SRC_URI[sha256sum] = "903c9468cf859252d9201ab63b5ee430e46979eddb0b20b5e9bb7f7ef764b729"
