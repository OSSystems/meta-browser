# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b012e57de4d6ca59e22560713e6d4e1b"
SRC_URI[sha256sum] = "31dae92e00f0fc2c81f144de3168100d10afde441ce5aa5c69382523cbab5d83"
