# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "e17680cc913886f87cd58f052d2a2956"
SRC_URI[sha256sum] = "f2e1121cbee28b8f279ce06ae1018f8eeab6a99ee8a8b3393ff71a3f9ed20474"
