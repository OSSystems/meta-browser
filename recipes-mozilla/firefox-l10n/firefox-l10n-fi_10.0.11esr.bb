# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c95dcdf825bea695ab66084f1814e25a"
SRC_URI[sha256sum] = "72e96b22cec634a5a05524c17aeaa2480374d60cd6862e5a4aa9bda0c6f29a37"
