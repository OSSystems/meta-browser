# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c99e0bd9f7acaac73189c7dbf0f92eb0"
SRC_URI[sha256sum] = "497a343fc9a1cdb8f46068ae9ea5dc7b2c0aa9c254ffe88d3ffc9147a95155ab"
