# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "40cf834613f38c3de24cb8956484e6a8"
SRC_URI[sha256sum] = "2a7f647f27b118ecb238ea39739afcb285347fdd581d2aef6ee31921d5f88187"
