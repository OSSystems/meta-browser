# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "1cc49b5850bad48ee6b21ccb7597870c"
SRC_URI[sha256sum] = "aa1f6df071934b0eca89abcb82a6276616dc463c4955f6a2003e27d950a02b7a"
