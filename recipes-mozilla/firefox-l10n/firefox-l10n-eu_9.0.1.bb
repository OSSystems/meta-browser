# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "cd752ea9d76dd2f6a45d8ecb5a1a3065"
SRC_URI[sha256sum] = "7eeee08a99c8a87f9ef638d9d1ec876f6f8a357241bdc08351d2cd0969ad38be"
