# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e8d45d58c141a19280109c7811c98f4b"
SRC_URI[sha256sum] = "0fc4c95ccdd5be47938906053e29ce0b86bac996c1f0f9d2160da89f83e0bbe3"
