# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "59fb5f10fcece7167021840b4856beed"
SRC_URI[sha256sum] = "ab75b09462fe0addde32aebbf57a905c7f248e43aab130fbcce0d5450684d3aa"
