# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "56987988750e80ce1d860854339f3eb0"
SRC_URI[sha256sum] = "59ffe1bbd930b12681e2576b77e01ff4dc2aa79250e2f3f460264f8b68b6f1de"
