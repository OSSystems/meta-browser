# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "440d2fdc9a6d9ff2f7d3112c79506fa4"
SRC_URI[sha256sum] = "60b743040fbf19944ed28d075e43bb215a362f17910fd821d7b70ed329f8bf2d"
