# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "febf805cbf54a95424220fd6fc03b880"
SRC_URI[sha256sum] = "37f6e75f021a29756ad6b417a4383407a3339c75a97de594a58b654bf7efd4cd"
