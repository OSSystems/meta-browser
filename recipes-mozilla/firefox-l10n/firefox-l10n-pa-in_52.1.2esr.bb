# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "656ff4378b361f802a6e6d1d3092c140"
SRC_URI[sha256sum] = "2c97becbb99c799b35f23e58893446bf50b2174d4a3bde1e319afa6bd5663012"
