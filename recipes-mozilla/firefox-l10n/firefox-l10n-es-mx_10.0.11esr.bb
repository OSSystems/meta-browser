# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d56a1eb7355840de6756af6c33e05e24"
SRC_URI[sha256sum] = "86bd2bb3d9b5480906f8c060432bdb824d616dc1376536cbd3d7169a65afdc64"
