# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2ce0d3d4c3e6db35c02d87411a58a7de"
SRC_URI[sha256sum] = "903e11f0be03982cb00da9e709469c98f321ebb96cd416258b3c5ed807c54c29"
