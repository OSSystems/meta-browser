# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "842bf546fcdf02f6d8ee46f808e3bf5c"
SRC_URI[sha256sum] = "000dead139dbff4415ad2d926f669e5a22afa9de8ffb209c47cb61c6c6322f87"
