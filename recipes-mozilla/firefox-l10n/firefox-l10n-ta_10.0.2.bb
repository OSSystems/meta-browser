# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "8d04aa1d64223481ed856d028b485612"
SRC_URI[sha256sum] = "9fbaf396db32be7f05c1f0b22a98bdacc9b79ac1ca1e808188d20659240c55e1"
