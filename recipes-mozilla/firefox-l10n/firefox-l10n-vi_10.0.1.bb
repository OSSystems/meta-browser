# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "35fa368598296c477146b56a76a48070"
SRC_URI[sha256sum] = "08504e38560f08cf9baec0f11e0f99c4ad09b38a1abbafd70d06ccff4ed00ae9"
