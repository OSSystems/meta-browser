# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "48e877882507d8a0afefde6f2705b97e"
SRC_URI[sha256sum] = "4db2bb1cb2e6ed5e97c30a387e3b1ee971ea5b8f9f62314806d9256439bffafd"
