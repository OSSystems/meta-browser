# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "50761cf38fd75907694994354f156d6d"
SRC_URI[sha256sum] = "9c6900b4bdb2c293471c4c898ad2db89d67de66f388771f7ae0f8bf4e3598e3e"
