# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4c2086c05c6ca18b1ab9561617a3da1c"
SRC_URI[sha256sum] = "49035a4c7bbc4ec29388a531d13a73c6d6c69dcbcb55fcfd0f09866378a795d0"
