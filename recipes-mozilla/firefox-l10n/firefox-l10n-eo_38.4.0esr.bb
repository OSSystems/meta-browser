# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b42d5100b48aafea0e076c22f87b1da0"
SRC_URI[sha256sum] = "bda681afa425465404fd3b3ee3e5ddc78da046884ad1288478f3567ad23f6cc4"
