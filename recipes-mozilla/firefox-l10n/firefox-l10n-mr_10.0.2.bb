# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "ea933b76c85d8bb8773df28de0b55e12"
SRC_URI[sha256sum] = "431d2cf448041cba56245744c18a24c68679d922d1c6106e45313009072acf39"
