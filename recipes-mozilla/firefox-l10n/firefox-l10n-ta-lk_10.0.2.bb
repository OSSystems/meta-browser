# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "f868b6d9a8a5d50f86e9c8320d791e46"
SRC_URI[sha256sum] = "c4bcc4120d35c7dc7d5d57854b38395f6a3214736673c64528045adaca34d8c5"
