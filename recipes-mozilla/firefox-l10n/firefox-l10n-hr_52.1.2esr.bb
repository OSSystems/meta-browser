# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e62772dfc3d6821ff45084b72d2dd410"
SRC_URI[sha256sum] = "c02ef2781b73d84ed1c7cff1c2e1a1c90579616e2a8b0aaf04f5b559a7f80ae8"
