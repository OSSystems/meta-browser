# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "6f6a026f06f7892dd08902acafdf63ae"
SRC_URI[sha256sum] = "dea5d915777969b71096d056bf5b407cb215a4e778908190d3e3fbc606cbcd39"
