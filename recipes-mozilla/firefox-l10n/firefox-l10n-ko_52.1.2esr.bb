# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dc698ebd7683eddc4a042ddef097fa60"
SRC_URI[sha256sum] = "1e454aeee31483c647def1da8ac765a7ddafcfabe2ef325384bfa3507cebd9ae"
