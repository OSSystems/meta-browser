# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2d08a109291ec396239f2f53fc462ac5"
SRC_URI[sha256sum] = "548f4326b19b535d9925e51a87d63df9e94c3fcec475d330123cf2426c8a3abd"
