# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "05f079b75bb891e229803b86441a066b"
SRC_URI[sha256sum] = "6f09424512979109b8e2292de57fedb9753d293d550f35114402630b7fc93340"
