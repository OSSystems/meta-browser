# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8078d98b0c867614a1887d55449e4567"
SRC_URI[sha256sum] = "f9a125661bcea85258fcfd99ea01fb2438477156f8cb285d1da5f46374eb7ae9"
