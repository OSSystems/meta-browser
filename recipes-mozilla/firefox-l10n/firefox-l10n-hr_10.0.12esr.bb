# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dc35837bbd4961f3e13972c67072a82a"
SRC_URI[sha256sum] = "b4559dec7bad9ed97798498cfe386b3a475e2efc67e97d378ebc6711082d1010"
