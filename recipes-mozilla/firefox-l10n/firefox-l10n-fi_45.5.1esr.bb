# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "45f8fddd5c683aa998d7507aea30a123"
SRC_URI[sha256sum] = "95830ab1777a7abbdb5e830b6444f3ae4189e353ee3f1c91c88b75bd1eb09b50"
