# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4ac6860f8dc1d4fd4eca3d4724d805d0"
SRC_URI[sha256sum] = "c4c0744d55113c5cf6ecf9c4ca2a283f7b63a4d6ebd952b0c271f5932cb50120"
