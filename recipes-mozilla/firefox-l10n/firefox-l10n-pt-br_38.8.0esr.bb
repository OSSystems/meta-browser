# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "feb42f7d8aa935f04d7440421c79c3ef"
SRC_URI[sha256sum] = "0a923433ae4ce912bdf097fc221b4211babc7b535626475ed0f0bb1b2659e41c"
