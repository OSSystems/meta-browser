# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "881d854ef327bbc9f664afd74ebdef71"
SRC_URI[sha256sum] = "d7f0c4e82b6d4b2ede6082430189c0571d03ecb2cf0e8b9b089754b4f1b112b9"
