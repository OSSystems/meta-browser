# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "dfcd93e2de450a68550ae94fd585b814"
SRC_URI[sha256sum] = "2a4e2d83622d22b0f41ea41a0df1ff58abfb395eb372c553ae7b41f8f36e0173"
