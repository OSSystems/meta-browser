# Copyright (C) 2009-2013, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "7dbacf9701b343ed2e5f35320693ca4e"
SRC_URI[sha256sum] = "166d3c6f4b30cfa51bdddd04834ff95461650c41bb83c02482f12f119f0630a9"
