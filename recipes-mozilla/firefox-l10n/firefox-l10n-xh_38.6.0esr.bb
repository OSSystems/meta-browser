# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d67180219ee4f40b6b69b8954f3c1a85"
SRC_URI[sha256sum] = "5d23ed0ff61a1f9b7c4153450df002b3f4e559a60ed17e93d7b0f350f6130974"
