# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c2a33edf0ef3812894fe712b64baf9ee"
SRC_URI[sha256sum] = "30c0d33590c2ba72ae9a1e22ecf5214ca3f44e24db871f337f8a169409b75f74"
