# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ec9417f28d8d8b44db9fba42ecec929c"
SRC_URI[sha256sum] = "5d7dd6098f7ea9dd0c83f9e57a4841ab6112ce9930367ed768614b6de9d3da5e"
