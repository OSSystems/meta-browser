# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e22ab636c6d51620b1edac0cc17766a8"
SRC_URI[sha256sum] = "cb5bf958ded05de2eb578e176664236366232b00f4dcd77d2c39134ffc803aa2"
