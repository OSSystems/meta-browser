# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a3d09d31ddac80e481a1ef649aa485d6"
SRC_URI[sha256sum] = "18606b3f9447e008b8af1e1c7e167003cc8c038aa7f298fd628d4ad4cacea889"
