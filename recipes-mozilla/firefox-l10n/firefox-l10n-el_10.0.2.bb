# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "4b978b67f7e0259e22cc2b163c8ed044"
SRC_URI[sha256sum] = "4e91ab483fa6d62c7e2aeaa418549954695ecc01c674893c90faa4803355f541"
