# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "b6570c9ca260eed33001be4b9f916bcd"
SRC_URI[sha256sum] = "9905f103df5f5656abaa5bd5bbbf3d0ab07512e2527c838dd7cd0137807f4f8b"
