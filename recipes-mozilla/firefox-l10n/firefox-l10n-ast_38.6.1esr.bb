# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c1235206729092cd6c3828c8a202df3d"
SRC_URI[sha256sum] = "3d53c59bb823c287718f2f2fd1401db97244aaa51f6df769b9696d39af2e59b7"
