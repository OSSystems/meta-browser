# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "45ea0326d05f68f26ec2d700392fcd2b"
SRC_URI[sha256sum] = "fd0bf59473302f78561923cf67a3743ba859fd929b715e8890403c872d911995"
