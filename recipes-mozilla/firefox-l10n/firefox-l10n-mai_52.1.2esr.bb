# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a634f51240804d6a84738e11a884367b"
SRC_URI[sha256sum] = "c3f5794e02928e508f1d4104ca2c13f339b69547b7bfc921fe2a13d87a056ea7"
