# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8c2fb294898ce50c30c59c74e9794e10"
SRC_URI[sha256sum] = "97d829a2c7f31575f8c6ef010d1568ebf17b046ae2cc2e3a06a229910e6a5a93"
