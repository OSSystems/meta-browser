# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "307eaa5cda97f3cb6ac2271c8fd085a9"
SRC_URI[sha256sum] = "dca858f9a3dad9633ad13f52e97cf9121c34a499979a00ca4f85af1636b4739a"
