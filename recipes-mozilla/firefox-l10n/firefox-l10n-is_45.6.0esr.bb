# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1081b2d3bd746d52b5d509753b39a9ab"
SRC_URI[sha256sum] = "f1756dd05eead22b7bb07a970a12db53800fdd3032de4ceec94f830f3d095aa3"
