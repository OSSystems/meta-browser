# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "68017684b8bc2a5ec770a3984d1e86b5"
SRC_URI[sha256sum] = "54ebe8d284782bc256b26fa9256de99a2b338430845a2e2634a8a21d445bc403"
