# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2a5eb22d0b2e276ec377c1187d8962ed"
SRC_URI[sha256sum] = "cb3a5f1149b08ab063504d642181db5b23a31bd068d59a98a3e15e9f94934335"
