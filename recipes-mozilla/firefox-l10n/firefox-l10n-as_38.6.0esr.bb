# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "02193e8fb216ebc256990a8387e5c646"
SRC_URI[sha256sum] = "fa2194dd7e6a3b7dacf813117fe96f901be71776cf41cbaaa49fa2922edc252a"
