# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c7343d81b5b310f3e9dd5ede1d90a75a"
SRC_URI[sha256sum] = "6e2488e7136dc5d67548d806175feecd0d94b75f48901e023305c7befda9268f"
