# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "94a1ecc117cf07b4d7684bcab494a871"
SRC_URI[sha256sum] = "b5c4dd26fe506edaa3f884ac043dc12776f76be97ef81be10529bf41e5cea26d"
