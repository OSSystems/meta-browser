# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "0aedd199ae05bdbdfbdae7dcd0776fcd"
SRC_URI[sha256sum] = "74f0dec5c9fa7576445c2d230074218d69b62921211a0cd72c1c0a99394d8e5b"
