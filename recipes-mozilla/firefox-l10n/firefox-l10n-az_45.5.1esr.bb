# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f53f1be947dd745ea955dd2168ed8f7c"
SRC_URI[sha256sum] = "96da29f386a990c177f09fdcb6f7a2de19c3fe8cb137668104b8484a277962ef"
