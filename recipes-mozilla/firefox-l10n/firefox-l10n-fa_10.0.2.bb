# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "1b1d887356c414a31e295e043d75a5ae"
SRC_URI[sha256sum] = "b5a2e077af5549fd4fcedea0d86beeb55d2badf806048eb4df83dd74e999df9e"
