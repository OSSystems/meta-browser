# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "6d00a14d6de40a098ad1bc0896e8edc7"
SRC_URI[sha256sum] = "5ef6c1f39c331ab694a17f7054c56c3c91fb43cdfcfe14d8e24e19b299873ff0"
