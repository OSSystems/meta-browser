# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "3bd2a883284a51e49e90142537c9cd8a"
SRC_URI[sha256sum] = "0babc0fec70fa7b170cddfd453aba5664ea0c96d8d4dba752b994c9dbb8eed66"
