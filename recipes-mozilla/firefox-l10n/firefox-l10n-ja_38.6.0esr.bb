# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5d4a395193189f143078fe070139fd9f"
SRC_URI[sha256sum] = "693b4c0256e2252077bd4b3823ebf1cd2fde98d145da0ecdf8824133e445e165"
