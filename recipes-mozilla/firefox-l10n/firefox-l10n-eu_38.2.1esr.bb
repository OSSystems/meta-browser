# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9c0872f6e5841b512cb27be095dfeabf"
SRC_URI[sha256sum] = "4b34e8fcc664fc47de1ee7fe1b8c4054a8416288a89198f1e772d37bdb0d6dad"
