# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "2430fed18db7a031d0312837d4592471"
SRC_URI[sha256sum] = "3a869fe9bfa24d48737a1c53056303112c9185d931a6062533ab5febf7482c81"
