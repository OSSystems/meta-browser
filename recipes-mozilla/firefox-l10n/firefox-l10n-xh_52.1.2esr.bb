# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c853fa924dc254551ed4fb69e78fdf9e"
SRC_URI[sha256sum] = "a031421901782739998f630dc1e97f6ddf9134c7236532db9ac2d201ed0f5a14"
