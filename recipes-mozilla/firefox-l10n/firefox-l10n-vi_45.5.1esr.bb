# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fee1bdc67ffca63cecc7b58ee62e3365"
SRC_URI[sha256sum] = "e131146d1a02c86fb5a5e3da02b173ebaf14c665fe7b086c482892fc913d225e"
