# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6502b91a22b5b7d58714b5a00dd95aea"
SRC_URI[sha256sum] = "3bd231cb050c37904d42efee813209572df9aee0cca11e8dde097b0fc8d98a3d"
