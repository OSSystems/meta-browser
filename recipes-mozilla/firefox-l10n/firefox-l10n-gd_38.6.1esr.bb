# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f7a43b6a5e87ebf243e51bbee5b9c7ae"
SRC_URI[sha256sum] = "851314d85d257b6cb683282e8a63a83cd320ce15e15bf949685534c561009dcb"
