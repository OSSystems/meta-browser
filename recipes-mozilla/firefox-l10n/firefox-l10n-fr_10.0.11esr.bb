# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3c944b143ce943dc1de8d23a70a0f148"
SRC_URI[sha256sum] = "31811aee809cb8896470d5f9e279e44e2ffbaa99b7265a9e21a52c2c35324c68"
