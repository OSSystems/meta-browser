# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "73236c506d622c54bad86dadf8dab114"
SRC_URI[sha256sum] = "8b6e911efe4ed07b67af05f6e457d44711fb09b5fc0030d339fc24290accbb9b"
