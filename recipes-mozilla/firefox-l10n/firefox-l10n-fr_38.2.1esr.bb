# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "63bb96395ae1544d28d8db39a056f63c"
SRC_URI[sha256sum] = "459b100943ac236091e5945aa84047c7a0b540769c8d63cf2f527cbbf645b401"
