# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "54d0a3770c5997cdf0f96ce2dc471a2b"
SRC_URI[sha256sum] = "41d2318c0c5960f715a6b414d7a510e626bc712843d8202806d77e44b8610e56"
