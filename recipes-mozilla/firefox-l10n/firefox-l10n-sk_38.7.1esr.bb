# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f8386e3571ae1fb135a2cf8f6170397b"
SRC_URI[sha256sum] = "d85f0a9f7ed32c93c9006af642e1442aa65860a8fe0252f1282575f64f790305"
