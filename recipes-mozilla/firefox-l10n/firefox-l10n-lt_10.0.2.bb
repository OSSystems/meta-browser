# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "c17b2c4fd8a2f168cc8be04b12c286ab"
SRC_URI[sha256sum] = "9a7ce7dbfa680229653b9de4024f29629b4722624d8cc4f8c3714d52dd616116"
