# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a51f1b1d44f493a1d2320530b56b4f82"
SRC_URI[sha256sum] = "443c2edd6fec5e81d19552ba514b2dfc8330285fb0f984fc735f4a1b5de6a4f5"
