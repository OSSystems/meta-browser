# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b3340f36da92ddc1ccae6d31251b7090"
SRC_URI[sha256sum] = "285a30026c108ad7775fde79bcf5e84c6f0af5bb6dce747bd8d4be308d83c3bd"
