# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "23f06b6c1762c8f9cb1cea05efbb5ecc"
SRC_URI[sha256sum] = "3e153fb554e5001560d76b9e8ec57fa2644a3124b8a68f9830514bacf8de4898"
