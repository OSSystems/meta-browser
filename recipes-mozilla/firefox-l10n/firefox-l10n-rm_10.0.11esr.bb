# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c0ef89c5e014d497889df88b33e6365"
SRC_URI[sha256sum] = "31190db630ee3dbb8f1fc8f097dea93eac380ee99e87b581b919d3a47af02f98"
