# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8394c1a81a79d4c87433da4e2514e8a1"
SRC_URI[sha256sum] = "64c3cd285a2d6e489513c48d7c6819459329d38e1d0fb83be97094ce7240b065"
