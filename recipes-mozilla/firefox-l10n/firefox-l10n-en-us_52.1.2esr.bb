# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7b6f33b7d38b06588da32cd9e2756c76"
SRC_URI[sha256sum] = "2b16c12dec5e3ed011d575a17390c124cc3094c9469e78a71b26cc3ee57ca82a"
