# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "b6b8bec8801a20a89e575651ca95d87b"
SRC_URI[sha256sum] = "e863dd18264fd2016e25e27f3473b7cea0479578cea6425a0b8929cde15a543e"
