# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "36bb2c6ff6256be07885b4b47ef3ec1d"
SRC_URI[sha256sum] = "37d7d2dde1a9d320e005b67a23cc8866efc59fa0437867f0a25f8feffe552775"
