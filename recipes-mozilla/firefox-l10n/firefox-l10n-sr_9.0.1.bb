# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "556be45438b8b5cc8ee722050009e827"
SRC_URI[sha256sum] = "77ca045fc5443fae803e8cedc45ae367e7fd693dc3fb511eee13d02ae03a4e5a"
