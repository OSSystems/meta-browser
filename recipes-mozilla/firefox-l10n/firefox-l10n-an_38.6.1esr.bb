# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a624a447b805f6a57350057347dcc2bf"
SRC_URI[sha256sum] = "5cfbea6795bddb30c1b2289369199109f798da8be140721fa8513e504e9721ae"
