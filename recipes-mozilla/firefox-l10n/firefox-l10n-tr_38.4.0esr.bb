# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ba33a962ea6c66aa39d7bfaecc1abe76"
SRC_URI[sha256sum] = "f57103f13eabc494778c281d8d0eaf81a9a9c63f09ae5bdb8a3eacbdcb00a05e"
