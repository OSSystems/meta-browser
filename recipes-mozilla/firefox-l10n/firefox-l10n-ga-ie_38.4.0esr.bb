# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "08d0ab34506d3ec89bccac86ce8187d4"
SRC_URI[sha256sum] = "b5ac39f748c770e2208cd61a83819b42d1dff136e6dd5af230f7eea51d542ce2"
