# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "2b09159ecace5a4723dfac6c3448d417"
SRC_URI[sha256sum] = "259c1887a1839acf35fce86c74d6de3d794f7b3f7370de1122d9ea30c31b228c"
