# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c017e5476ab3be70117cffae009d7533"
SRC_URI[sha256sum] = "f7a1d03f01b6d4c9a62ba35c247935bab5ada0a644ca3072f0549df690c4d647"
