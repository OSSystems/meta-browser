# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "75ef053f058810024dec94035b0c93ef"
SRC_URI[sha256sum] = "c663bf7ec450a45c3c1ee7a46e89facfc43717831e014f077e4fb994bbcfbd1b"
