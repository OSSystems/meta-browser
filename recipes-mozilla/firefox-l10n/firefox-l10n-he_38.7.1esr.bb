# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0774ee3d17c1ae85589eacd65ae9b3f6"
SRC_URI[sha256sum] = "fd43f7c6721b6b33fbe65e64b6b6bdcc8c64d1801ece8cb30ac6828e90ed682f"
