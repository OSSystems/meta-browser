# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "e949f060ff05052e5109c3ddf81793c9"
SRC_URI[sha256sum] = "30f32977a92c31369f1624cdef77cfc093fbb947e6b13cde006c0eb277e633c4"
