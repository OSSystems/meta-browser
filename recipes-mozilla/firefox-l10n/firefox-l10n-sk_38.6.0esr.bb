# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f86eb2301c62ee95f53dcf6db1eb1308"
SRC_URI[sha256sum] = "b3cc30232399d25c130fbbf8476ef56013589b370ec44c18e76eb61caa4a457b"
