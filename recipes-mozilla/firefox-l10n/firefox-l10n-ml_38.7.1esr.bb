# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a42add0ef465ece36aa1627fec966571"
SRC_URI[sha256sum] = "7c5b7d6e67a86df253b8f865035a049cc8541d35d7741029faf5ec4f285fbd88"
