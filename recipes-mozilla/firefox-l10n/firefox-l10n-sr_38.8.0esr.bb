# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d63447f623045e6962aa84815ca6a4b0"
SRC_URI[sha256sum] = "41dacc86f65f9ebbdac4c95a9c0d5d210d5d7187a7d1f1081f68d0e59a0c3407"
