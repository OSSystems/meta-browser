# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a59adbc457ac79bfd633fede09d7ab4c"
SRC_URI[sha256sum] = "44b50cdaa3d51520fa546b3afd7fae9d872567e25344666938773b1f3e2623bb"
