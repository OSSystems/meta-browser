# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "252af6625a65ffa20f315fdb196eb430"
SRC_URI[sha256sum] = "389edc15450db4664667237ce42a7f207278777bf13fb7531ebba54a09df460d"
