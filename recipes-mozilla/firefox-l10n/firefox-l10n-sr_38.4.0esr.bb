# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e27a3b883a6044a6534c8c7fc419bddd"
SRC_URI[sha256sum] = "2447105f3d0850f8d7aa402196ed34df8e5dcb52291900dc03f1d79f04ffd1cd"
