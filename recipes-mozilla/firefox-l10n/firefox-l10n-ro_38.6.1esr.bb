# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a1bfafe543f219e181f3d12517ce42f0"
SRC_URI[sha256sum] = "8d099dcc828dce7d14f4ce838620e717b8e7ab442a32eeb19287ff310295f75b"
