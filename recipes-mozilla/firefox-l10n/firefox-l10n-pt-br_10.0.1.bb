# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "c1f595d1db20039d850638cd7e5d8d09"
SRC_URI[sha256sum] = "d14ac8772ff65a978e6df01fad39eb93067e26a572bb0c39a00f4a205f01708e"
