# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "a0cf04d0a4d808bfc20427395c110214"
SRC_URI[sha256sum] = "5ea221d3945ce36df401d76338b809168739646c699dbc08dc77714aa7c3ac80"
