# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "265867d21d6248bc91f4cb7aa176332f"
SRC_URI[sha256sum] = "c149a7c5885cbea076d822585f2f62c2f1c9fc09f7dabf06af027b15d81c7ec3"
