# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5a6fedb6e9ae90d7c9ef30b35326d5de"
SRC_URI[sha256sum] = "60c85929955d76edb00e420ca95409a57607cff82b8863dd89a7788c336c0517"
