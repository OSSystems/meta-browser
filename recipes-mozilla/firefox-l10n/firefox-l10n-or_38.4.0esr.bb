# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "69765d38eb20b1e0deef24c426bc245e"
SRC_URI[sha256sum] = "3866337ad94d5ece643389ed7654d266d14b689674b92fbe4f87db1a11608419"
