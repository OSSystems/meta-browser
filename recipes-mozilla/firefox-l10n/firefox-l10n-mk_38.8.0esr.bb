# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "804e96b0ee09d044111beaf9da9262b8"
SRC_URI[sha256sum] = "425c7deb256cab16de08406dabe040703feec297d4e280c63c5cf07b002780a5"
