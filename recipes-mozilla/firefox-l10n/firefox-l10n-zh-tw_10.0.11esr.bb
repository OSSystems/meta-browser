# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dc5fe151034465cd9837dd2197108666"
SRC_URI[sha256sum] = "0d719d4d9635df855bde99c8bf654c5172672eacfd6d9d068706683464ddad2b"
