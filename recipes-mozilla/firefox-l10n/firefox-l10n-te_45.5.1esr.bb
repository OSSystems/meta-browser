# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "236100c8c3037e3c10b5b992f83d1124"
SRC_URI[sha256sum] = "d1fecb274f34acc257d58c23417abe47b6222952a1da3e6670f4b69a418e4e88"
