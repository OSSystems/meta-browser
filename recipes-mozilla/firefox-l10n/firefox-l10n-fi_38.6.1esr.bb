# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fc9f2f35e471bd9ca9844c471b5cace5"
SRC_URI[sha256sum] = "94d1216d8f44caba7d10a9835c3906d1c85eb7d9d53dc59c5a47fd8945211adb"
