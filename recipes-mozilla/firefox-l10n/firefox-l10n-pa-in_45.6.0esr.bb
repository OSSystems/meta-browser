# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1dc6b1c51d809c74fd90676d845a0515"
SRC_URI[sha256sum] = "62954f7ef1d85b9a5b8e0a1c9feab3cf722c75a522948180877f4162bd274f24"
