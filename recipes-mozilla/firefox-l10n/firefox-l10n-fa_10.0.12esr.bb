# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5a569b5e667bdcc0bc21b6cdf89f7fd2"
SRC_URI[sha256sum] = "c596082d60d9db633f0228eccac07efb257a222b606f9a388aef2d4906fad7df"
