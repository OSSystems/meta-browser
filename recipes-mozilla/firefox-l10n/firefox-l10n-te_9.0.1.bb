# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "815f07c8166701511bc20f7dd8df9775"
SRC_URI[sha256sum] = "ad9468ec1b43bc15075b6367ea82560eeb991b3f60a744b0ad2b4a3b5810c136"
