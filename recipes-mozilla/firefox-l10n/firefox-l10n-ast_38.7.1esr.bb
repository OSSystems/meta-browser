# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4219a24c95b58f2068f5d0cb8d50f1c3"
SRC_URI[sha256sum] = "54915a1d3d4e241cfa11a41384db5d50cbf13e2053b74ff38d49480550d4f0b8"
