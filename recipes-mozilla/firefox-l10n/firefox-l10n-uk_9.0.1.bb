# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "78a86dc48b3c62c0e10b4439073056a5"
SRC_URI[sha256sum] = "3462248fad0553cf05dac4af70de97e5a7a79ec2879ffc552ace98037ae5e507"
