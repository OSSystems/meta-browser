# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "51c7b50d86b5bf145616534bd8a3e739"
SRC_URI[sha256sum] = "8f85dc374f46dac6f622d0e22222d7e7a7536fa26bff799e1373fa3665999220"
