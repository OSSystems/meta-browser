# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "895d3024550b1b03deed764b1b7aa9f6"
SRC_URI[sha256sum] = "728489bfd623e9ea4b8dcb5852594bdcef8dfcfa23bb04fefe7b844c5c8f398a"
