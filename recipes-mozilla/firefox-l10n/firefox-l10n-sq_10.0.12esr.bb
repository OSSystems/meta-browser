# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aed0b2c05e4ba8145182122ee1f7e391"
SRC_URI[sha256sum] = "c3a8d6154da20f45417cbc2a8ea1506426c84b604d6d5f4e0b2e1c4ff3ed4597"
