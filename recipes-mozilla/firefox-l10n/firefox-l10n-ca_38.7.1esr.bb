# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dd1dc741706c0e0d4358061476f3b78e"
SRC_URI[sha256sum] = "febf01c4ebe3ed48ced0bd4309f0baa1423fb42e992286669d32ac6022ad5625"
