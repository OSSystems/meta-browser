# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "95413bb9e2be1db4ec2c5ef14fa791e7"
SRC_URI[sha256sum] = "2264709d232cc097ec37777bf0cb6a7934f453058ede2a43c8c17f95d76b3b4c"
