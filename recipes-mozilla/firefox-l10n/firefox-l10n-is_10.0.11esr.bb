# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a33546c8d1b2d1848ec2da9c28d74dfb"
SRC_URI[sha256sum] = "5fe7ae96611fad428064aedffd35078df7ad59eacaea80c74b84deb2d0affaa6"
