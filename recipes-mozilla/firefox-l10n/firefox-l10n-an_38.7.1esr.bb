# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "23b6328734a7a0532ed79f3b66d26d3b"
SRC_URI[sha256sum] = "9e3c9588b363b08ec230bf0518a6709a84d9efe0cd89f4577147e91f7e223fd7"
