# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e2803f5eb67ed1631807aa8f673f275b"
SRC_URI[sha256sum] = "9cd59047387c3fb285463d6d6f13bba45a38fe3dde2533b96b00f54e657ee9a2"
