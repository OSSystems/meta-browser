# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2aa564bd94326ccc006254ddfd329308"
SRC_URI[sha256sum] = "cc08b44572131a220ddf5e690c12a674376535875c615922b93a44b0a8b64555"
