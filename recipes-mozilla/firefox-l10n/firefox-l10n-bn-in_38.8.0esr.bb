# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "51800274424539d9859daa2b27205fcf"
SRC_URI[sha256sum] = "e5dc879be24543a3d7b01a2d844c51d9ff33aaf21d5689437aa1cc5e0b5cfe80"
