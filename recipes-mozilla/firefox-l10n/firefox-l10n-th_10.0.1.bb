# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "23a04abd724870dcdac1f7fc2cdb64de"
SRC_URI[sha256sum] = "f61511ac665a500075c835fe31c903f15aee725e221509ec0af9acde6c71c1e9"
