# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7ed626e6cd5c57631ef5ed979a6952e9"
SRC_URI[sha256sum] = "a94fe56de96737ffd6d945bf287c48b602ea2f117be17480f1143727e56625e3"
