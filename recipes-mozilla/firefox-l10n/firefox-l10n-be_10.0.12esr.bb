# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b29eee5ae05473eb3e2ca791539bf76a"
SRC_URI[sha256sum] = "17a5d58a3866567b93e16fdbe6e6ee1815dd0d1911461576bf68a0b77515dd42"
