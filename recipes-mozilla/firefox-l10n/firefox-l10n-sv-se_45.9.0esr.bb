# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e92cc96d3435d69174597f4be8c9abc8"
SRC_URI[sha256sum] = "7171652d7a35850c16cd1be626f2e19910bb96bcc9c28ccf3151cf6a0bd70c86"
