# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db5f37170758855429530c1a5de3438d"
SRC_URI[sha256sum] = "697f91adab0ad879ab41b9073533284b73bb42a75d103adf80dc2bf3df16a9d4"
