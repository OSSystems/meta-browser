# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "931cf67439a1f3c43eb455e2b5db818a"
SRC_URI[sha256sum] = "8982310d306ce78b1b03b23271cac18757b06ac68817517c7cef7b35e39918f6"
