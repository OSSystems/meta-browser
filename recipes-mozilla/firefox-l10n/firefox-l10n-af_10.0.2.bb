# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "7f4701eb3a8a1e62e78f47eadbf9a91a"
SRC_URI[sha256sum] = "daa87573d904a63438398e6a974848b8c1fed735f4daaeb08ccd3f8c6a36c93b"
