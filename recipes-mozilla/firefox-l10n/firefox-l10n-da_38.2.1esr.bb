# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db46087a504e5f6057e602fd6cd501da"
SRC_URI[sha256sum] = "269107b93e0f7df8b9860672ae5cddeb816bc184d8b083dbb0c12af4723da666"
