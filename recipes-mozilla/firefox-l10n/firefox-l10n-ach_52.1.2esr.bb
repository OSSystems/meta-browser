# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1ff3eb9add1b9627dddb74c9579590db"
SRC_URI[sha256sum] = "6e63e6c31018a75476683f2f8bd6f3e88ebc7de6453f4ee39dc6a2f72f42b29f"
