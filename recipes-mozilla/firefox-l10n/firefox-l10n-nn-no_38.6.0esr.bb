# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "19efbdaa42b7bee636417886a0bf05b4"
SRC_URI[sha256sum] = "a05ec5d5da615d06a060df9e005d1cc4ebc2c82bca7d8836c06ba9a138f3ce5b"
