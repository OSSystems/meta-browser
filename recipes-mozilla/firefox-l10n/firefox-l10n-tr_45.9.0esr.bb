# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "00f4b13ed971ad18e6bf822693c7fde6"
SRC_URI[sha256sum] = "0e2bca710ca7649683ecb1d486d9c414434b0e0d3116789567cef3f0cd7cfd78"
