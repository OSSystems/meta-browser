# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5becadf73ac531582a4beea0a62c5add"
SRC_URI[sha256sum] = "0470e0f449267d1f55ed30e1cb28e77a1ed5c682cbea7dd634c5008efeb13807"
