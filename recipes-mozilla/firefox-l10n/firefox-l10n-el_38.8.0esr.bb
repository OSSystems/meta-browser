# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "945aeee633a50d1267a4b805b18c7278"
SRC_URI[sha256sum] = "66304c46d4d502d82a65b6dc79a8bf3261c0abd4b3b5668209566e15fe125c89"
