# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1f25c2c48b3d8bf6270292f2ea886702"
SRC_URI[sha256sum] = "3ca1a8c8ef556d6b80bc76f5d5e309b5cf6a1dd29d8e8ba29e8b501d14bc3d7d"
