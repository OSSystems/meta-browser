# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a419902f9dd91ab5b6c3c0f314574192"
SRC_URI[sha256sum] = "b25c05f8f767ec38c5a40c10330a7ca93509dfef5769997170b9aa7caab367e8"
