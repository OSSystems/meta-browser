# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "e99926ae86964cca90686e8bd26ea243"
SRC_URI[sha256sum] = "621bc8ec3b8dbf8d5d2d76bf105dd306812d1f4e5c524ec5afb6ae7b039d86b9"
