# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "22a131aa7101bf03ea961d4645820d64"
SRC_URI[sha256sum] = "bf2fc42e2ce825c191b1daf45b045c3c74b7e4b1f4d91794370dc4f7b21b88d4"
