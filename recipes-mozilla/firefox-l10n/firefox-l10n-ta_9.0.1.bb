# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "cadbf700cc551e63022af680eda5a9ba"
SRC_URI[sha256sum] = "1dbd47f1c25bfecddec124ec90b92463bb3dd2b2263301a1737e8b9f747afa64"
