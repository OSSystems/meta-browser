# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "8c4ab8856b5f0801188b45088bf802b8"
SRC_URI[sha256sum] = "2e7228dca1056a04f794d618070c4d287b93daf87adab1e5b6111f99d4907613"
