# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "29c248b333c01d421f44a3d968317866"
SRC_URI[sha256sum] = "59550c5311cbd4ae6947f772062573519dff438588ec418ae93c3f129f1ea287"
