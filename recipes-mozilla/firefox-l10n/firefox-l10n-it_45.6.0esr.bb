# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b2079bfbcf006bd6ac66b54ff4c950af"
SRC_URI[sha256sum] = "bb4a9037e63926ce2ed002c87f84eb3f39aab425f6bed61a06c81953cf6a1f66"
