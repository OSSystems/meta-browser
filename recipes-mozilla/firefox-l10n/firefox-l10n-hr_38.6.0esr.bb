# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7d0e67c9583a8713735f103519887875"
SRC_URI[sha256sum] = "34f86d16e2f1db465e44bafb53d23f858caa0f2e42f46b0a9270fe57c1a86fb3"
