# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "4993448d3a7d41ebc44aeb54ac16c8d8"
SRC_URI[sha256sum] = "e7dbdb40a6d8129bce25d65c213c0a1212ff7a092e44a7a74f241a206d8d3633"
