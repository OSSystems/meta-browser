# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "85a7ee841232306762db2426a56ed130"
SRC_URI[sha256sum] = "118756171112229f652dde0b4d60b3ec22865ed0eb9986ca426a7a76073e101e"
