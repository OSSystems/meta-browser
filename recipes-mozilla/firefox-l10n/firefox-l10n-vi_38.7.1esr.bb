# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d77bdf6c55111bf72e2d4cbc47f17721"
SRC_URI[sha256sum] = "e44d8ad1601ccda0f534ae5a7c5afbbca89723ab4dd35c54ff917fed15112914"
