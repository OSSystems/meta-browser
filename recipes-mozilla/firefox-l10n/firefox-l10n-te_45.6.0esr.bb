# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4c48941ff55ea701a6639ad139056f8d"
SRC_URI[sha256sum] = "bb043c63242f7d0c6c14e900c3aeba3c43238058fe838116c7706f2058b01bc8"
