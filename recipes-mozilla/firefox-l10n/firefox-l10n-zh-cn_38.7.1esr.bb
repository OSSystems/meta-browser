# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "28948b35e8ed6bcc620da50752a8f013"
SRC_URI[sha256sum] = "8c99716132f6268368d632e150cb77ad43e4a2374f85566fccbbe88dcbf76512"
