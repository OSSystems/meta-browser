# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8f1fde4f783e301f342af38ce53ff06c"
SRC_URI[sha256sum] = "05fa6961b2be007719c72eef010d0c8b612c41ca34ecba3c6e878f4bfdaa92d9"
