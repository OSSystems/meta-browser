# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3a95d3247dc17b4fd387046974491ff9"
SRC_URI[sha256sum] = "35a2bb1a97c053604e82a3b61adff14724404a7b4f5fb156320f3ec346ac7ff7"
