# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d86c4c581253941e94cab599d9360774"
SRC_URI[sha256sum] = "657f674449fcb8c4af1458a61315ecd008f72ce439a4a9d977476f00d6fd249e"
