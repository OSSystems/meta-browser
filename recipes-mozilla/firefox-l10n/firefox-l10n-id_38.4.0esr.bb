# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9536cb823ea0d8f1f7e6a9dc8ba48285"
SRC_URI[sha256sum] = "60220cae6623614bc6b11667849ddb5f2251c4b8f4c0bacf99bfa81c4a407d4e"
