# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "8e685d3ad253ed013b95b1fdcf094ac4"
SRC_URI[sha256sum] = "127b23931398cde56990204e0d62e6e5b91bf30e82d978c10b598e7eed7e666c"
