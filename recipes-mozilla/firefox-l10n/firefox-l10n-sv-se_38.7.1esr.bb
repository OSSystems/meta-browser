# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dd89490ed58b8ca48223974525cfe836"
SRC_URI[sha256sum] = "980c79937cdd273c0275731bd26c03d57e82c8a5e0d0fb79b0dbd0a25b606ab8"
