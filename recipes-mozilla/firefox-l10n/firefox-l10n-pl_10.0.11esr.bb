# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d437125e1009b0f12128ba7f766a192a"
SRC_URI[sha256sum] = "b3c34eb9c030976f6acd45247c70725c22ce0dd1262376ab155e73670b627cca"
