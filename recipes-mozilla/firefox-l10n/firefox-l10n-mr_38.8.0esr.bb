# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6d9c737d7a629c31906c5154e71ee371"
SRC_URI[sha256sum] = "9daa0e3d22c28b1e4011ba49fd529b8037a5065d53a66d865493febe1ce42ac1"
