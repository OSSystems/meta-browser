# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "df4f6031bf0a0759b1090eb3bc23661d"
SRC_URI[sha256sum] = "130daedf9ad2c3b7bfc8c9c84643c11a9abea92594106d8e7d566f35eb619560"
