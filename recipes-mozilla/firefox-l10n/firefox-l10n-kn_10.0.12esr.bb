# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "934dbb4d5982ed1f32597d7709cdf895"
SRC_URI[sha256sum] = "295ebccf2462e33facc6018f1124a888e12fd1ba23563bf9545ce4588669ec4e"
