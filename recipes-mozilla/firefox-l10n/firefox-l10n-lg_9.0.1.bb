# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "2baea1844e9e60fffd842b98161fed2b"
SRC_URI[sha256sum] = "e64b26286904c2c7afdf793b8a216125e87e52666b391948eb9a306cce59ab59"
