# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "9d1009072e1968ace2dffa6d2a1e4c00"
SRC_URI[sha256sum] = "46cf14b4f079f513de43f524698e4d8902ebdc61f9f8b311d357e2240c02dbc5"
