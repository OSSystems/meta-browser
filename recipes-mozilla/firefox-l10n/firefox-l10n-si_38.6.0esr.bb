# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c54d6efde1a4a51d6967acc5db89a2e8"
SRC_URI[sha256sum] = "1ba99487b2dba24c1a34f9cb3355492fc7002d1e15f00402788aa14bf1ea8483"
