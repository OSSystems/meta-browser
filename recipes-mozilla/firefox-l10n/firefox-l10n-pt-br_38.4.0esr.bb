# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "47a86e5ed19f9ae232d55edba1821e1a"
SRC_URI[sha256sum] = "4ccd547e9ac19788c99ae876bd829e349e22be55aa9c2e194547d6986aa20209"
