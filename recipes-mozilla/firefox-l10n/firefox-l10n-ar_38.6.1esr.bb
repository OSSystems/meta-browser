# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "539900eff0a7e5bff192ff8caf532a10"
SRC_URI[sha256sum] = "3937af045d28807a4d2941bdc26e8cd9a437f5207c71b638e86268e758a8acc5"
