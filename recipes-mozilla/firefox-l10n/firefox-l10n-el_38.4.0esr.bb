# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6a6d9f474400981a2b88ee6c78d2e0df"
SRC_URI[sha256sum] = "5ac04011963f07691b6406094efe3f16455c7cb952d08891e6a3d072789130e9"
