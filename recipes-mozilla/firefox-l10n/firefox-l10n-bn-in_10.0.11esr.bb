# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b68302716bbb274f7a385559a91f265c"
SRC_URI[sha256sum] = "f96afb1587eebb95577f1f55d42396a76ed660cd3c91edcf62d765906c6975f2"
