# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "18970f0fec289ca43f7a5a0f3d2f1149"
SRC_URI[sha256sum] = "032bc12bf506bde68d9d64bcadbc09ae5f0ddfa740ea9d4cf37fee2ee488fb88"
