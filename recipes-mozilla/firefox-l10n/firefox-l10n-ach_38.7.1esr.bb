# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "50905a12d868868ad899e069327e4aae"
SRC_URI[sha256sum] = "e426d4a42a3a5922ebfce36791f3150eec4be09b82c48a24cff82d54231ab1b1"
