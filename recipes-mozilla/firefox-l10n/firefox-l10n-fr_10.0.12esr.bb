# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "283cedef2bde143989e1161c7dbcd650"
SRC_URI[sha256sum] = "e6a6f455e9b0325fc836060d2e2cca71acfb13296017293f018437346d79c19c"
