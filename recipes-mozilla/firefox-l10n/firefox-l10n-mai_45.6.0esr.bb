# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ba964c53e1ffee8bfd448d2daac048f1"
SRC_URI[sha256sum] = "bf0529141003ab3deb80cad52a05cd9a51146af9203e8ed0ece569fa221a7670"
