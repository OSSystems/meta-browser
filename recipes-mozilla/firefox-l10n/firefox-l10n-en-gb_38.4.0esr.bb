# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c584fe3e9407e32bc9fa548b96bc5c20"
SRC_URI[sha256sum] = "21f4db34f3277636b6cc41be7508025e201fc9770bf962906eefeb04543a26ff"
