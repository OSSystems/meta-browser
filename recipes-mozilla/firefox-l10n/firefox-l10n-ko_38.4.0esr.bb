# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c3f2f41721c61f1255d8822eb4d1c270"
SRC_URI[sha256sum] = "89299b59c51db6b5d0d55c03df290f1b3cc2cce728e2ff21af352c2b568ea44c"
