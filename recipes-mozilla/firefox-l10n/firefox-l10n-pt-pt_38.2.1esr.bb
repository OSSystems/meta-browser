# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9e34fb9be6d4875ab5f93221ef27d38b"
SRC_URI[sha256sum] = "6f950c7eea881dbcd2f4ae4cce41f6ece38add5e511c741a6192c1431b6dc49f"
