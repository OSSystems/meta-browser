# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "631151df0df89dbf14dae65579ded28c"
SRC_URI[sha256sum] = "dc2f7c06e9a5d704bdb4ac066e78335d31bd9c426e8e17ef6945e3a189bd493a"
