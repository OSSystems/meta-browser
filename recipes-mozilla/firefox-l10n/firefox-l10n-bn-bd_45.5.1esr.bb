# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "286094b6d48eb6bfb5de1b98423f908b"
SRC_URI[sha256sum] = "1ba09838893f1923db07f937f659217c630d6bd8ee6940e356b6ac9f5962608b"
