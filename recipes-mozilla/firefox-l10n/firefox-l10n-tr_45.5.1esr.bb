# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "acc8ce9704b766a24bb3c27a3596c303"
SRC_URI[sha256sum] = "4391d231bf7d54727d8611357b2283634c74545568a07b2711ace36819ab250a"
