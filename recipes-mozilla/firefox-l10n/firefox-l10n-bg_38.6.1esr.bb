# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c20ca96678cd8a92dca9a4618a10f516"
SRC_URI[sha256sum] = "5d825b6387dbf31d5c20650d87ff3b73643826b3143c178f6f0707cea4e0c72a"
