# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "29ef5ac08902e8dfbdef3bd4382c2c79"
SRC_URI[sha256sum] = "c8b78c6eb3310260de8e1bc3bff42c647da6b46b774c42651a34e54c8f6a1f0f"
