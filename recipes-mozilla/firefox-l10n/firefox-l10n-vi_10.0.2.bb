# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "125999659a554ba8f41572f9542679ad"
SRC_URI[sha256sum] = "d9cf5c1f7111c3db76315b444d9ef5932d84274b6fb360b24e7e341f4295cac1"
