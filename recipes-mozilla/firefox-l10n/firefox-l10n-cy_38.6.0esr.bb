# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b3d09f4ae6d06801014547e2dd984fb0"
SRC_URI[sha256sum] = "6c3ee40c1b326172a55866b1f21ede38d8b94598e85c9b6f16a6ac7f269d515a"
