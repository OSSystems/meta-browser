# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "79360625be246e46145179566d46fc64"
SRC_URI[sha256sum] = "d6057c0c72987fd3cad6c8fd5866e5c65db5c54755674c745a2d76f3b5dd8d01"
