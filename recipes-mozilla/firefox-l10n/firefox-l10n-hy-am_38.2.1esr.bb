# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8129c59bce70314602fd91bf7676ca19"
SRC_URI[sha256sum] = "20a4c0b5abad43617850551aeb00c303fb74a11cb0ffc88a5f6a21500e0c707f"
