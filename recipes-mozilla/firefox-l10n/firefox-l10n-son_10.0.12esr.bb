# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3deaa5b6f52d5e5677da30f1a66c03ac"
SRC_URI[sha256sum] = "f636b42f13657546f6086f52aea799f899f4d0c316dc825240b759db7e41c08e"
