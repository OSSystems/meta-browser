# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7621011f267c7e8f5ac894aa4acc4f33"
SRC_URI[sha256sum] = "6b9df8158e63b30bad7f112852408cda926f89677a44cf4d9a37a2bcec635eff"
