# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1887a4025c29b5554af7001fdde913fd"
SRC_URI[sha256sum] = "8d918d988341c462b0b621c7d0cd9d77ff49c14b0e2b1bf134e99e9cc4469fb1"
