# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a6d32607401f1010740b7178c334d578"
SRC_URI[sha256sum] = "6e90022dbfdba748891f6e28582cab5a4b0287dd0c46774f9020250097eff4d1"
