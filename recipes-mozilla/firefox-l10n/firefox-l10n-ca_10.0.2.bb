# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "b100190d7a0a40b24236e99b031d63d6"
SRC_URI[sha256sum] = "fd0823787e2517ef868a732956651a578b92ded60e3608c2474a776677578590"
