# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f9bbbdf685a8bb8dd8bc9329f7256f9b"
SRC_URI[sha256sum] = "7722037c116ef1827c1316b99bff0d22612281d122f2e54336a4cf2b218469df"
