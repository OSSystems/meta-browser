# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "46ea1da4fd331fd5a7e48a9320e787af"
SRC_URI[sha256sum] = "91b4bb3ae51e156bff6c96d966dc35fe525729e3976faa2ec557adab051ca0b9"
