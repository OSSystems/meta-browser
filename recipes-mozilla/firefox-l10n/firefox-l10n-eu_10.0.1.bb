# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "40e67c1bbb8f398f7a3bb88f9a7ddefe"
SRC_URI[sha256sum] = "4ffb6a1416c9aa1f1f1c32987781c2949f520976c31848f65d340a4304409442"
