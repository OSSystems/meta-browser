# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dec5d2d3c954ff9a4c0bee17f237685f"
SRC_URI[sha256sum] = "eea9ca25dd45f1257131e32474ce0f46a04b5327b333afa77c1809d7a017bf10"
