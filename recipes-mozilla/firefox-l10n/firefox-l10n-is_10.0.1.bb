# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "3ec5f60c6a08ac721f6abb161f194b92"
SRC_URI[sha256sum] = "ef225faa4a51a5aa6f4f10726102bad4bcae0435994b2d2a75dff78623b40a0f"
