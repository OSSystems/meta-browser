# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2703e285bbfc2a622ae0d112516eed73"
SRC_URI[sha256sum] = "499f11c6a5f8dad76dda59bab9007daddae5a878e16e2a6fc4da46319dc66644"
