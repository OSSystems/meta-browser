# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "5601c9a4efc363e3db726cc604457533"
SRC_URI[sha256sum] = "0f626ff4d716a02474e96df485c28854a0676c3b62678ef76b5fed03e0c320da"
