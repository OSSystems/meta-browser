# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "ed58df2d9e9fca6342e177579f5ac830"
SRC_URI[sha256sum] = "50a49c42f10daa00c9a8f293d538a9896ca8279b6c033dd90d6d9b86632b5775"
