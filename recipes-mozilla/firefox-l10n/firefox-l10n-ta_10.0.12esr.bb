# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3a688b30114da995660462f0cf8751b4"
SRC_URI[sha256sum] = "122e636e6f32e5fca5c99a4bb088e5f9eaffd71d0aca739a8e19fb9a339adf23"
