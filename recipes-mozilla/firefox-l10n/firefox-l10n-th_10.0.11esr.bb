# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "19fb21b95adc4c47c5362ce1aa027578"
SRC_URI[sha256sum] = "b37d9376d43608d0a96a7d52ec7548822936bb853dd08a0b62aac16102f5c0ea"
