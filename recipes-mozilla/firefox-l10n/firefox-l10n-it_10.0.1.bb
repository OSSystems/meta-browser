# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "57b7d802ef7e0af0dd73f10346c73cf2"
SRC_URI[sha256sum] = "540ebd73da8ff20222a362ef25de78a41b7a123da7e80fc261bced258733c0ac"
