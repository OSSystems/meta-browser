# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cbedb047d348391c9ff448222b757a14"
SRC_URI[sha256sum] = "840e732a96c8478d0815888c79496d1c62dcbd6133d2304b0920f93d0f6eb3db"
