# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1c04d7840aeb67dab3610af6154bcd62"
SRC_URI[sha256sum] = "ed284d229062f2568afb09e72e41f7905c40dd4aef5a18f3732dbb5a4b246a13"
