# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ff1617f298190852838f519dd0384528"
SRC_URI[sha256sum] = "976713479c27a6e27eb8aa1264c690e83ad006be284e28e4762f9b76ddfd2170"
