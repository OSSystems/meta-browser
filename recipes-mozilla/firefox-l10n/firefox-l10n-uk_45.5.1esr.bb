# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6498b1566bf81d31b9f751d7df8354c7"
SRC_URI[sha256sum] = "7f59bdf3cdec6c0042341ad6b395ff7cdf3417841bdbe405cf87bf957e7de123"
