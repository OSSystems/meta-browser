# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "49a002195c26ebf44a318e8e3c359c2f"
SRC_URI[sha256sum] = "8200d464f56f5edd6ccbf6e81620b9a444082f55b72c23382793501c31be8ab7"
