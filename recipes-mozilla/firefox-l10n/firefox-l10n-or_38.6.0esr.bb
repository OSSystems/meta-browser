# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "39cf3363391454931c9ab5b62cf4e945"
SRC_URI[sha256sum] = "526b2590f5b213d4b90d2e8a3a55723f3a551dc0ad98fbc8c40898cfeb82d58b"
