# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2bfe6afc4cb4ff57d992b47684cdbebd"
SRC_URI[sha256sum] = "285abdd84d600b7aef0eb17371879573772e357d147178d02cbb9004cfd01d70"
