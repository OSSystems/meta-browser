# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "51b177d9ec096b5dd17966b28348846b"
SRC_URI[sha256sum] = "7b6fa8c4ff34c25149992c7ab9bc469198aa92598c6cc42554ca6f91bb75dfa3"
