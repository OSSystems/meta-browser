# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ddb734fd64bcdb0498102bdec7d9bac2"
SRC_URI[sha256sum] = "132d33ada5dd333e1c862980222ef0740ca7d48bd7381319db63f06e606e0df4"
