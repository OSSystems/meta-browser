# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2539d15a6a215c1533c9f293c4241849"
SRC_URI[sha256sum] = "bc6db8fa74f36e725a5c3b13f81240353dcb5dace0280b045b70a7e71788df1b"
