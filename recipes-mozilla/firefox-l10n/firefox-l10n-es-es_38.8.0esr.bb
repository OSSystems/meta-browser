# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c28713c1d69531bef89d828aa05711c"
SRC_URI[sha256sum] = "3d0f31773315f30e975cad54ea71d6195b4e931035230158d00e97c2dde6ef55"
