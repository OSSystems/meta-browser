# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c5939bc8e2f461c19d7629381fda0d8b"
SRC_URI[sha256sum] = "e8cac9a32aea385bc389abf2e15722295de61776a4cc098e65c6b5b512d1ad89"
