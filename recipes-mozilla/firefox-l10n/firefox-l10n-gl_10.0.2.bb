# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "631258d258221542bdf75d4ed9290002"
SRC_URI[sha256sum] = "6bc2beef01163c295b2f25bb55b7e5d0a40edd0fa4a7746625388baf33ddc899"
