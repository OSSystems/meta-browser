# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "c4b181dbda18672b371ee3ede30a3178"
SRC_URI[sha256sum] = "fa09349dc5d7f46cc1b3a02e8bb67dd789016618a6e5d4001c63461dfc80d82a"
