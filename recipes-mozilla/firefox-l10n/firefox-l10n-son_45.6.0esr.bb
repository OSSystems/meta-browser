# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e52a05567e08023617726c9f1e17c3f6"
SRC_URI[sha256sum] = "da8d54259390da5d28f8ceead2727c6fb685effd7cbad08a868d2321edd0ae48"
