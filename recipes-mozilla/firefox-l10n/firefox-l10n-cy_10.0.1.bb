# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "12736ef82c8f829f25fa6c107ca21964"
SRC_URI[sha256sum] = "1bdbf6ac9cb4733a6168d49d3b023e339728c847e9b7db394f8cdb0301a80865"
