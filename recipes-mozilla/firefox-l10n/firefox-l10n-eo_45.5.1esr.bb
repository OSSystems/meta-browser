# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c9c1ab089e4ca81849ba04c3851f66a7"
SRC_URI[sha256sum] = "fefd83295e99065d7a8117d7a0e300baf694f019b90ee221a723a44e82a8d9b0"
