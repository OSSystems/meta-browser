# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ab3f8eaae10e46c62a251f949ebf213d"
SRC_URI[sha256sum] = "49f3f8ac436c99cfaba4d5870a8b7e52a36534ff6eb1dd96b9204858da93534f"
