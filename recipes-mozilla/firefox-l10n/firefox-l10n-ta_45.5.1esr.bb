# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "65bcc1cf40aaa43156141d29c813e4fd"
SRC_URI[sha256sum] = "dfb7e7947ed7cbbd7becb0d3a33b096481052343842d47f3f507ed8da094ab8e"
