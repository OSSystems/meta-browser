# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7ab971530760d84d3c31d11285fcd9a9"
SRC_URI[sha256sum] = "b39ef0e44adba821e4f9ded5d5bc3fad5f6970e090453fa509b104bd84876b00"
