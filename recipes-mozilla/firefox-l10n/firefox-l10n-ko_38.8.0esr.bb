# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d7977514cb16e91434fc4b3fb8bdfdea"
SRC_URI[sha256sum] = "368e0022398aee89f15192bba73337a29ce1be4214c01d680928000c18b011f0"
