# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b35e32b3a47607049404d922318a8d34"
SRC_URI[sha256sum] = "a9b05aed46cd06a7338703322c168699aba8093300ceb8be9a4d90753bf38f3d"
