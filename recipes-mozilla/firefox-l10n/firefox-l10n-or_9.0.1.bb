# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "5d392f80eead101e54fc5cd57f574c9c"
SRC_URI[sha256sum] = "1b5e9a11ebf4433093791a47c5fa7dfbea7342f93c4c6259ce4c17268933f6fa"
