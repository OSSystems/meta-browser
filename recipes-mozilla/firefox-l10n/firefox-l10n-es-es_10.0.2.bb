# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "d9b4ca176968c3cdf5ee9388505dd657"
SRC_URI[sha256sum] = "b7375eca052c9d9b18a785cb36ed6e589c38420bfd1949df4cf6e8461bbf2490"
