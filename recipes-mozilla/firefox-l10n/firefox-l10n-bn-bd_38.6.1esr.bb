# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "09f240b35e5d8f481a992c7cf02d3f3e"
SRC_URI[sha256sum] = "6438c81f0bb6c9e294a1c11f11436844964ee1867e1c4956e281e1564ee17fba"
