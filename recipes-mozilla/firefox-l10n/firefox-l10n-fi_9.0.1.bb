# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "ac2b7c3858b19b46c66d9f1296eb8998"
SRC_URI[sha256sum] = "b9bb0ccf1df6a6825f14b51f1243838e9580c4af82632bedf072beb1032f46bd"
