# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8e475be40d0353fa4b2d4dbad1f85cbc"
SRC_URI[sha256sum] = "d94a25ad6c66f064097c78e82ee5adc4234e42721e322adfc077363b0ebebd5a"
