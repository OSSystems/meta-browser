# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "2ce49520306a1db907af13c503a95e02"
SRC_URI[sha256sum] = "c9a3aad5bb766f1112b433f9920ac0b8a2042b2c52817cbf23ac3eeac9e81d33"
