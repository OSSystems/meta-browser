# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aa97ecb9a3d0cbd224176227dab2f797"
SRC_URI[sha256sum] = "f2cb5cbb019acab2de7b7e4f186151d92ea0c88fff29b94a48e4d80993d9dc08"
