# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4caf5cac426b0a05b9bf558624a197d0"
SRC_URI[sha256sum] = "3aad4f54d6b17a1e50ecff8f88d43723fa7d423ef5523a01e80b2eedd4d40ca4"
