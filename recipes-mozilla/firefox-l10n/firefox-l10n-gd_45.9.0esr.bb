# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "171db8b1dd1f475883b6a0633291531e"
SRC_URI[sha256sum] = "47674b76dc58ee2ed7f6da2ba33e3ea63b061d1c857ea83bfc8a2264dcc95450"
