# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "51926ea153d37e5e22998d2dac453603"
SRC_URI[sha256sum] = "e4b3003ff493901d2440ac633a71ab68f6dbe5c6602fb19ebaee7b561af5620d"
