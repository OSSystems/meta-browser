# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d0cba0f49c263800ebbfd4b630ce18d6"
SRC_URI[sha256sum] = "e2c78a08058def239a95be921b154538e9c65b0bf17b894323df3ebddfbdaa54"
