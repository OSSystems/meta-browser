# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "274d4cfe65bd34941e565475e83ffd3d"
SRC_URI[sha256sum] = "0840811a6557ab15da539e0782888c47c6944ec80371f86025ef348b048a73ab"
