# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "55bbec19e4573fead4d7eea9baaf3c28"
SRC_URI[sha256sum] = "c177b177ff309f9dd483ff0bfce5a70a75ff9d67dd983994c368ccf65bdcbebe"
