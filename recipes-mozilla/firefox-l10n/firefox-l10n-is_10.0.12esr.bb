# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "784cdc9f2f8ed756783597eb1fd204c7"
SRC_URI[sha256sum] = "29ba39f7c363bbbac34a95d7d2af610f1e05a140ad04246eaee8d50dee1b9c73"
