# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "43f85ac05b518bd46d535166da06d5a6"
SRC_URI[sha256sum] = "68f9d1abd49b20a3b3bd79d4b7ace1099ab8b6d9cb094a84bcabd90cd3a4142a"
