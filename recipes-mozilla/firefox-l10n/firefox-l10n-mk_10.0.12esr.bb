# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "48a3962aebd8cf08a29cd290f95175b5"
SRC_URI[sha256sum] = "15c5cf3bddf26c5d54e88a6806a730ac1816694fe5b946930307097bcfa3224d"
