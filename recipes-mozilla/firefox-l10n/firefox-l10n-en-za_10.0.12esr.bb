# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8d6fb025dc26d5d8920e94542dbe917b"
SRC_URI[sha256sum] = "2963f434230260f29bb1f69a1e2638568f6c10080d1c4179bd5669d537a6fbce"
