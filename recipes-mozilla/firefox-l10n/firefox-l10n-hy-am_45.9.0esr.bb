# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bdbfa2add71b9695159ea8620fb99139"
SRC_URI[sha256sum] = "6c17ed91693b3b3c0e5931f96a2bd7e09b589594988cf6cf0a284480355a5e1a"
