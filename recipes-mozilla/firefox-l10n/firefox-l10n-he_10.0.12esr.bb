# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "19ab7f1e68ffe50f6f40a8e8c46f133e"
SRC_URI[sha256sum] = "ff8c9cc6568a556c01e47eb398be44f4ff5fae1507272c01f77b7f31210fd2ad"
