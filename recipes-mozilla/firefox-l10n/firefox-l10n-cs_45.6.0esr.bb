# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "78bc07cc97a019de75034fb4ffaf88aa"
SRC_URI[sha256sum] = "194c74a13ae82696e39b6034c94db1b04bd308382b2edd72dc256e0ca94460a0"
