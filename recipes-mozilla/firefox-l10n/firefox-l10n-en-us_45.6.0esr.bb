# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d8c566cd08ae23138af128e02f27f222"
SRC_URI[sha256sum] = "0fb6cb0ac97d02c107bed06120fb7b2ca395b5fe06e9e09f67129ce0890ad100"
