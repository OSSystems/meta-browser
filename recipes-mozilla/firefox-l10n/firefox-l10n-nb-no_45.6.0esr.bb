# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "39d58f855ad03ad815a7cf72631608ff"
SRC_URI[sha256sum] = "e550c89cc083420cfac125e6d9674e472a8581c127610ea439cbf5c44df73662"
