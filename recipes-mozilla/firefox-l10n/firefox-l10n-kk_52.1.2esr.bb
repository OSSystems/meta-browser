# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5494e83b5881712c730b729b4d3c35fe"
SRC_URI[sha256sum] = "3c708f4bed1618e655b6cd57bdc06de291ded676767eb34e65d2c287059010cf"
