# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2e9adedb51d2d6ada4042b6f29e0e7dd"
SRC_URI[sha256sum] = "034e5b66421dfd7f918fb2a47d6f3ec5ba33be82d546247c793ecd9d30218097"
