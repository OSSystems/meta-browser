# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "f3adbd10e4e2f1092ff005d2b7d699df"
SRC_URI[sha256sum] = "187eaef870790ff25d2e7a5f676f612989d141309553fb884dbcb99279988457"
