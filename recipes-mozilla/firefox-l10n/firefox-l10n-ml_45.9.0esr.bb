# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "42a6639f80b1c6e5d723aff6cf828c73"
SRC_URI[sha256sum] = "3ea1dfbbc68a7186633bc80106c40054561fee5e40b6623a58af9bf351bca56b"
