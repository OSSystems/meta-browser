# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "4058aefe2988d911f62e9dd2a9d1a7f2"
SRC_URI[sha256sum] = "6b8f03e07ad020a9ba0a6935d916ef6c707b72faefd66049da4718d08d0bf0b9"
