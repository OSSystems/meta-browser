# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cc95b50d9508cb65ad96396c77a95544"
SRC_URI[sha256sum] = "ad3598ffbaafba0437249108f764bded1280415ec0ad142b39d5b97924b26011"
