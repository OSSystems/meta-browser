# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7d92e3fc4fa50c66722260053662de92"
SRC_URI[sha256sum] = "6229f7ff2312dba7678b51d7b63b66c76bf0f044065149393627513bb0939fb0"
