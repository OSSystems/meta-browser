# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "b44b249224b023cb20cf7b787a70de4a"
SRC_URI[sha256sum] = "46e2a3c5999e860a701795cd9f007f23ee85d172089443771993cc3f749fdc9b"
