# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "2e437797a42fb4ea84750ac131618203"
SRC_URI[sha256sum] = "987d4b6d9de72122136b6022ea5fc02956c2dc59a7718cee4f06b43a3e8c39f0"
