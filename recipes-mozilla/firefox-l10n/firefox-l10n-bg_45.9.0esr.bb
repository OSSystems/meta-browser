# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "174a8cc37a773cf08391053f1f536025"
SRC_URI[sha256sum] = "d16a2ebc6b9f530e584a239288a91f586f31bf2befdf6974f65b3014430e2e12"
