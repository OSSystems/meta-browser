# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "3114c1d68988198fff1204ea10f85878"
SRC_URI[sha256sum] = "6c29b51b72936f915b2c8d0231afe5c557111569227bfbc8e22e9a45c6865d3b"
