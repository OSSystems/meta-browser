# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5291bda1edba86300ff079d9ff5af200"
SRC_URI[sha256sum] = "00078a06e6392022ccac75c005ce5e3bcb8cfbd41219dffdbc648ed3f1c9d458"
