# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "58bb5fb65c8fea9443bac4aeb18e4238"
SRC_URI[sha256sum] = "5ddd9963c85db2e99bb26908e767ccb4b079fe87ee08feb15e62d5bf8eb56414"
