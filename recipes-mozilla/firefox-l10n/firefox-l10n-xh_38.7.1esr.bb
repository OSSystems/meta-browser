# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "866d8c347a67ed003e02fbb618efd280"
SRC_URI[sha256sum] = "e758251a6189df898e7eaf67a794d5160e82b0a94a703b1821f4dc6e0cdb86fd"
