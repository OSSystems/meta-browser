# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b08a40d876e8be3e08d4811b7991e6ff"
SRC_URI[sha256sum] = "4b98cdfa0085550a2714dad4065fbaf841234fad3041487065df7ec468734f1f"
