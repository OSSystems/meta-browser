# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8396078d24d9b3e13b8ac62839e91ab4"
SRC_URI[sha256sum] = "e7a64db780496953dfb9d623307ef087f09009daa4c0e1161e99100e5c971339"
