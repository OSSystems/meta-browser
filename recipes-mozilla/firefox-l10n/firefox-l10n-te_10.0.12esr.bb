# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fb34a6ce053fd6d5134e1304f853ef25"
SRC_URI[sha256sum] = "1664e90a12b04ce01de0a496ff844cedfc3c99a781067f823f1ef2d6c7dad36d"
