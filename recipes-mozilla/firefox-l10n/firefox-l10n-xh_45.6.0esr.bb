# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "23adeb32cb06b77396aa7f43b321dcaf"
SRC_URI[sha256sum] = "bc0c472e5aea467a22f4db2216f9c25b11c904214df2380c49283ce6bfba3bea"
