# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2c87aba8edfca670191032aa11a558ae"
SRC_URI[sha256sum] = "03dd766b490847583cbf2765b4cf81ff23da75739e60918811c406af846f43c5"
