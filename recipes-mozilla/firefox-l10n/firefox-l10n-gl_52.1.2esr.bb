# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "02dbd2d66fcecac0b53ed0782e925356"
SRC_URI[sha256sum] = "1ab18eacde902df416bf8a0845f306ace58223f201c3578a88f9a6607f024f90"
