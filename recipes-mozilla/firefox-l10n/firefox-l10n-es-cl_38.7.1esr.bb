# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ac133d188407907c0ba700e908d83c2d"
SRC_URI[sha256sum] = "cada53ffc8c1a0d35cf16fa8990d1e4678937375fefaf5b464a6c0d6e0a4d398"
