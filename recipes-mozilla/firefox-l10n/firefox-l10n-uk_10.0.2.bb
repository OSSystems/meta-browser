# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "709c3e9538cfb44ff0d07bd207176045"
SRC_URI[sha256sum] = "de97a8491be17955c05fbc9cd19698c89cd8fec9878ea99576608db6d989d1b0"
