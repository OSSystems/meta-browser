# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "54104ca47760b80e0ecf0f1cca36c378"
SRC_URI[sha256sum] = "3fa23e7bdb71b43ba8ca5ec9eb8fccbba1a0daaee4598350bdf6a08fb12867ce"
