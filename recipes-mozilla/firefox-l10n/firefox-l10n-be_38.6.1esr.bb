# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ac79f2c785b0943caf83b87e084f5a07"
SRC_URI[sha256sum] = "cb2bc817cb8cf69b170137c46baca6e5e893dba940dd14e24ee3e93ef3780528"
