# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f3ff0b764596aa0c561993534a0b3044"
SRC_URI[sha256sum] = "7264bc57b263ff32a5e1a93e8047cdee44fc6bd78be737ffd03648d2485a9aa1"
