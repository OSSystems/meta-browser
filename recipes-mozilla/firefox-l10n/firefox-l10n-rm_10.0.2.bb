# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "2887b2d0791211afdfc1b0bba55c914c"
SRC_URI[sha256sum] = "0e3f3e3208d494fb23577d88b01e8540889d041e9cff140470e87634c81fcd1b"
