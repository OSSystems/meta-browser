# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "d78f80d9f8774e72205c785ca30cc70f"
SRC_URI[sha256sum] = "09b19ba4a7c3d84d2d8016a3d5b5447800bf5e5714b4a07ef46a27307339bac8"
