# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "fea37a88ac67ea3cb7db2a6b44bdcff5"
SRC_URI[sha256sum] = "57b3195bd05b2c48eae3117b957f448c0cc8810b8c89ced9f690184f889656b1"
