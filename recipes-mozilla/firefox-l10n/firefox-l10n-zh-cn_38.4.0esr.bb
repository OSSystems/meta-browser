# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "982d6bc2038de93eeeb1be4212731556"
SRC_URI[sha256sum] = "e981e5a29a7fcd9752ebddb587ea57ca64d67363ab2b77d9ca477f58f8789a3c"
