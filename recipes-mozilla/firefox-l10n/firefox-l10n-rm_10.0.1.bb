# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "7b82f3dfef8837e39019c4e36eced72c"
SRC_URI[sha256sum] = "6d330b3644d6e7a85968955ef6fc1aa140b77f8da675b1468c5d38ba0834deb3"
