# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "10e45f931d2129317bdae9f3cd0bd27f"
SRC_URI[sha256sum] = "0c34cec01771932438fa78457a65bb320d5246e003861caa4a2b099f5bde7194"
