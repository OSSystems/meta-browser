# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b70b2e07ce6590682e643a3beef35d4b"
SRC_URI[sha256sum] = "375b9c390e90612e7a9e847ec2b3a71527ee4ad79231b70b2ae9c67ca1fd5a19"
