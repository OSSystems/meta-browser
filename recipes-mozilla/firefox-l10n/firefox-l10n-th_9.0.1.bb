# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "310b82d4a8c5d1d27ef31847c3c61090"
SRC_URI[sha256sum] = "db5d96f88b35b45e467bf968ac0cba8c49842490eec92825d564d19246648815"
