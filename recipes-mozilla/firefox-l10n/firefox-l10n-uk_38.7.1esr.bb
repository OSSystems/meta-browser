# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "103f2e9f2ab52c8158a762668dff9ce8"
SRC_URI[sha256sum] = "2fa352e22e30f6ad80c4884ab85b9036483223b17470cf0d559875c9da1b815a"
