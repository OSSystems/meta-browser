# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "af37cf50fb9235a552ac9fc65368fbf1"
SRC_URI[sha256sum] = "a7226722764ca450ec478717cde9082e60d7ebf564bc4b1ae05d88b5747662bc"
