# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "79bfea915507b750d7027ff1aaeab539"
SRC_URI[sha256sum] = "bc690ed31ab5e890682ba08ffdd28210047394e3581ec960043028dc5bad911a"
