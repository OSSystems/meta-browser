# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1b6b016e358a09f2d6bf54ddbc8620f7"
SRC_URI[sha256sum] = "fd6d9e058da409985c1f9e04b608c897e3ccf81cff733029c4c6571e7d128022"
