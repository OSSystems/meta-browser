# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "91c0bed9e96f018f9073a75a118ea473"
SRC_URI[sha256sum] = "7f69136d81c323374b0148c5d568d069824c21a550fd11df7516251982312a11"
