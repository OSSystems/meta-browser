# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "36a73490384b6493e7122defe405dd54"
SRC_URI[sha256sum] = "b0a828f1f077ebbedd6618e85de5172f2f51f4baaf13acfedf7b5d94fbf6f85c"
