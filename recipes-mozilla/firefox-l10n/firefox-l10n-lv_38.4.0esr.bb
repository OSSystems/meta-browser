# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "af6b94c7f5ec7597b4df00f7af5f9586"
SRC_URI[sha256sum] = "0b90f73e86ca10f69d0f06819f7fe226a84886d42f10e653133bdba67112f61a"
