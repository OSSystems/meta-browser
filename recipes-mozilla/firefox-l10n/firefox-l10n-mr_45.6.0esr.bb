# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6f2b8093404ed925e5aeaab660c7238d"
SRC_URI[sha256sum] = "280aa77f29befd555c10681a9ca8b7c869e8a12b4e2319bae2e97dcf5d88d617"
