# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "57ae5245221385a56d311bd386131a65"
SRC_URI[sha256sum] = "bafb8f90a8162dd03f3d2f49aae061411e0b412ca15c85c9da82150bb034769a"
