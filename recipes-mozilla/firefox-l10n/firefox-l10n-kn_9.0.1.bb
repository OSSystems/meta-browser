# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "03c4c95df6cb14a0a07d163fcc77f962"
SRC_URI[sha256sum] = "5885d9596cb71c2b7365ecf2c9e0ce5add56161964225e8da24981d69f24fa55"
