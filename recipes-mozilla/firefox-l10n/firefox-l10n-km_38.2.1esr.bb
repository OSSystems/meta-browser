# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c598844b8bc47b95a2b7d1dad6084f18"
SRC_URI[sha256sum] = "35c67ac083036edbc00351f3c75b6bd59a57f49b8f49326b966e49ed1c440769"
