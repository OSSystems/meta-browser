# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "6eb7708684954fe6ff768852ee00aafb"
SRC_URI[sha256sum] = "74aa3898790162e8b5d64a477683155e5fb3e5c93de04613125ea0152876e2e0"
