# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "64dd21f507332d47a51322ebfe51d49f"
SRC_URI[sha256sum] = "07b83d2cac216a8e395b78f816d29c812af142a59c63543785dc2b16f8242e39"
