# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "236f7460e1ce1dbd37b7ce47be07bca0"
SRC_URI[sha256sum] = "231d1ead106e11a9eaa1b9915df98d5a8734d6db3ab6e563303de44511350c63"
