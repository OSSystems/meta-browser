# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "1adc9f41248a12f4e2e081fda0c81577"
SRC_URI[sha256sum] = "9744fc961c9185c9c5585f563aa8075767ad3cfb7be310c6c48bcaec6538a3f5"
