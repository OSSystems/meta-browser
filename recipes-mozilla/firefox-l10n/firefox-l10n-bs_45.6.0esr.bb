# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2971072e933089ebc1d0a68dc10cf2c1"
SRC_URI[sha256sum] = "f85df2b22ac201dfe5779b86c751a182a260cd233159a75bd6118a600fc4472f"
