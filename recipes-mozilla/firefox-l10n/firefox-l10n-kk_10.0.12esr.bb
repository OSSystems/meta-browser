# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "51633b555e17c58703db80a3183206dd"
SRC_URI[sha256sum] = "1e32dfd312adbba86e06e88790cc934c4d1dab6c1a1d611f0bac4cb5fa05456e"
