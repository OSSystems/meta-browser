# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "34ae51cdeabb137bd58285f5318b6d1b"
SRC_URI[sha256sum] = "984d09e9bf05dcf25eaf46109fe64237763f860a6eecfb74c2352665d2e4c34f"
