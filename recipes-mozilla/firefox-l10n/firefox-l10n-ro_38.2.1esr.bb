# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1989bc8f199424924d03987fb93eda72"
SRC_URI[sha256sum] = "d086f67dc27bb06c194e12bc0f47e52b58584637916da61c42da977204d6739f"
