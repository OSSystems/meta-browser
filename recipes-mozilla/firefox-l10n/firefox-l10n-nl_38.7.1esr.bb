# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9eeb67e9204acaadb8780eb65e7ffa81"
SRC_URI[sha256sum] = "0f794624e2e68eaeb33c2d225dbdae3ff407c887549f4969ff702f886fb68c36"
