# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5f51c19416e0151bb06cbf6e09e2d986"
SRC_URI[sha256sum] = "ed9f2a66029b53ff1b7214275c1b22c8656919ed5cad2dbb3a0936be6c632d32"
