# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eba0820a9b7f45c8c0a896102f8917b1"
SRC_URI[sha256sum] = "271b84195258f417bf60ca33ed677d57338f56776d6652fa8f8cd7c92ba88315"
