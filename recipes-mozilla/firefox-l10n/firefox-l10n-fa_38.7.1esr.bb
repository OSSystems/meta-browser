# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3a08b36ed26def013ca3d71a36691821"
SRC_URI[sha256sum] = "e41d3fa8b4af987a567faffb61199417bb6fc7c691e8e22865d5a5cf73074506"
