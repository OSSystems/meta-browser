# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ded01bb1cc163477cefad127dab8ca1"
SRC_URI[sha256sum] = "e74a1044b30ce08b536840eb97fc41322ffbbfabb8d65f32f86552f9055adca9"
