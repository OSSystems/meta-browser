# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ee42c9f050fa5ca5791119207539792d"
SRC_URI[sha256sum] = "d5e1f81c716bb307a73c1d25ec22e72666b4f9e27ab2921859cb96082bbc05d5"
