# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "69b693eacc0b3639c7af86db3d650039"
SRC_URI[sha256sum] = "0786a95dea8d77e42078484f65f2e6f1810b9c35585044a687bbe135604c83b9"
