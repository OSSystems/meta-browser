# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6ebe74e91756289408d7bf6abd33b167"
SRC_URI[sha256sum] = "a605ae15dca88ac5c33fd3ea6f38ba9a38559124db1881acad80895877b96b70"
