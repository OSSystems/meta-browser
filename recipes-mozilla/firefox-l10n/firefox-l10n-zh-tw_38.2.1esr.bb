# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bd5474f4afe478a3ef54f0df8356c4f7"
SRC_URI[sha256sum] = "3fe5c8582898d0b7a030028700a58f0d7313a0c9edf88568d176175dd7c3f40c"
