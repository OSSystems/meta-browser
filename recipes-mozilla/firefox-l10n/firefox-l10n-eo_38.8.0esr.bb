# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "51042961c2da76bf5c4f1ddab0e2c14c"
SRC_URI[sha256sum] = "aa93540baba2388acc2268ff70cdb767432bbc22d956c30f5a1d03a796b5e08d"
