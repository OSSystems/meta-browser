# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9977c96dd5fbaabd015fbc2be4493740"
SRC_URI[sha256sum] = "187462ce7ba1931453210cdc63134bd7ff33d87f116a7655f882e673d4fd89a2"
