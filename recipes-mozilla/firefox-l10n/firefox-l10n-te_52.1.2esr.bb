# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5cee7b4289c747e8700459a74df20530"
SRC_URI[sha256sum] = "26194b24c7f085600c388e46440464ec1e1adeab73e400268adbd1c38f41ff38"
