# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "8556d86c0e8308df9deac2b0f7f1aec8"
SRC_URI[sha256sum] = "984038c6eeddb0b8d0dc06b9af4337b93384de5062632dd4f7a1eae49f0581c0"
