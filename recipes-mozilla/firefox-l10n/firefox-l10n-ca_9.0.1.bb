# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "8b6e09d0ddd5878dd51fab1efbf94c3d"
SRC_URI[sha256sum] = "6c9bbaf256379ec83574b3e9505924a6043718f9b6d800bddb17d10e2be99ec4"
