# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dc516e31d6351a46d7d3a5110f020e2f"
SRC_URI[sha256sum] = "8748e52bec3c524216046e9d76d402ef336da4cb068b48a588a9e5471a3ac4eb"
