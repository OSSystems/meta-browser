# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "c5df7357307d2f7ea16100ab2f763c03"
SRC_URI[sha256sum] = "822889e8a6991e9f36a81d6faa382e44f5db7e0490fde8b66bbd85830e379b6e"
