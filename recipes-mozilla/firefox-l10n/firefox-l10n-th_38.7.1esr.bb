# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8b8bd3d46f813b4b13e89de94917c00b"
SRC_URI[sha256sum] = "45c2369c227ccdd786cd9e99bfe3ef53f98bf8d86c17286ab7182c60b66bb042"
