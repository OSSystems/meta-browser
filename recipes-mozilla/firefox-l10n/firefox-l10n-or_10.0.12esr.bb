# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8f3dc3354297906d74ece9218feb8ee6"
SRC_URI[sha256sum] = "b29ff9654b439a487fd8c195fc710f0e7c7151cd0dfaa881d6b3cdebd7ee5a8c"
