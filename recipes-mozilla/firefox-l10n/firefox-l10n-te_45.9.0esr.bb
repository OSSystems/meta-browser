# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aa8fba9a3332b895f2426f2f813d59e8"
SRC_URI[sha256sum] = "6f5d2f10aa530f1c43085a4a5de3d79d84466f72a64f2fc9bdea2d383c714ab6"
