# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "180b92774aa07443f551806db7695635"
SRC_URI[sha256sum] = "7b7b1216c9a5633ff4b4cb2eabbc3b36c01e81e7a46d3261e9251fef330a8311"
