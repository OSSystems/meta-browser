# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "acef9754ce127085009687dc7febeb6d"
SRC_URI[sha256sum] = "8908161f3c1dace3cbf54be15f75075bc4dd9cd3a17d939069805837581a22c6"
