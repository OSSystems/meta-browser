# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8de14fe900501a69c22e5073c7ac128e"
SRC_URI[sha256sum] = "54c7088036c89fb3f0c0a43d8b06e99a06d992563f8c8ecb3fa71ad25029e348"
