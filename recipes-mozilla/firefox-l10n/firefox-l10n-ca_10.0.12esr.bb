# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dd6ee6e45308d75fd544b6ed0a42854c"
SRC_URI[sha256sum] = "df940cb5e7169740f0d3604e5954dd79f255e54578d6931e6fa7a5c1117f5f9e"
