# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6e71bba136ef63b8e62b4c13ec879f7a"
SRC_URI[sha256sum] = "e8671bbdb3caa20fdd1c3335d2aa454fd0df5c68b7441aa4b6d355258045bfca"
