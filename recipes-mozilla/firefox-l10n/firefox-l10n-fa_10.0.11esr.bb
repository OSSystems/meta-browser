# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5ddef0d87bdc0820acfe2de0fb40d08b"
SRC_URI[sha256sum] = "4d740a9f10d053c58358b2a98557954ca718aa8484786c8259752b2c395b0dd2"
