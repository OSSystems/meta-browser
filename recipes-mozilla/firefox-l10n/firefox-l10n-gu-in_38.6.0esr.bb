# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3ce4b07ac8ebd74933999e4b52750304"
SRC_URI[sha256sum] = "e5380052b2adae2e99e592cc28d9a1ecff4dfbb74103abe4432d9688feabe452"
