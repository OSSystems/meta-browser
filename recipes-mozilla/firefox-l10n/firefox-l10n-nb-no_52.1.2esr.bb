# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3b84dc784c99aaaf53ee000f3a9789cf"
SRC_URI[sha256sum] = "a8ef68bdccdb49ac0d47c2e8af273137bb1e06e92e6739f9f541368547d4d7e9"
