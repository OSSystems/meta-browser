# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6f62d4bee821200628959218d5a39189"
SRC_URI[sha256sum] = "4e9da99e5dd7b2fbb5e5627c91415ef39d1fca7e7ae1a423bb5830b37bc423e9"
