# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "ddd5628c65d2b3f78cc7f3f5088b2e96"
SRC_URI[sha256sum] = "435b98d0c72b62992f5c9766d4854099a5168e9695b312b4966df646ec016286"
