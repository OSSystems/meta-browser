# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cd3be411699413ebd7f313f7a0f747bf"
SRC_URI[sha256sum] = "b336e6a490d2fb5d6e7dd1f82d76fadf624f2a2b90ab7439e46f68f04b07f8d6"
