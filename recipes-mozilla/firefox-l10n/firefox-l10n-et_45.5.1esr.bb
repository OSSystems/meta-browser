# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "551f957400cba28d624a6900fde734bc"
SRC_URI[sha256sum] = "62070863641bb8163b0570a22a41293c1382f7755157bc418a445a580d818f07"
