# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "afffb62a0e53f92d949992b817cd0f85"
SRC_URI[sha256sum] = "c615b79dc9cad1c97a8dae9d855db41ba4191ce0ec6af3ec9c3a832b6b19662c"
