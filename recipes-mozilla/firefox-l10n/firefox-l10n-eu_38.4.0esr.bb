# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9b6e89d6334a2daa82b4b4aa2b91b333"
SRC_URI[sha256sum] = "fa7ed638416b030a54104bfaa399aee0670cbcb9066a7accd3ecb543dcfc6774"
