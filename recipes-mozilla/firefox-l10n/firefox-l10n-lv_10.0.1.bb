# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "880ffd11705d0da4a8bc9ac443b62154"
SRC_URI[sha256sum] = "8db5b21e06211584a7e1078ffa2471656c278ad4203707e9aa97b87343b6038c"
