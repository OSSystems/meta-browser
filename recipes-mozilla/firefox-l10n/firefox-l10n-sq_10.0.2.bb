# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "89c33e78a267c0b616ae04e00725aed8"
SRC_URI[sha256sum] = "a5eb8a0d32fb14d631287e26a4fadc6d4a11af6524c4212afc7a09bc1b04705f"
