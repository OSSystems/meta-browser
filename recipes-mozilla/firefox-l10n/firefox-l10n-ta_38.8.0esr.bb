# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db2f6443fc2ff3eee0f76ce58a34b66c"
SRC_URI[sha256sum] = "b090a265bb6874bd895b615cfb5dc863e7c5792f5508c4c3cc7e2bfd633e908d"
