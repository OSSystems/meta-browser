# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dcb626b43185e2c358e3d767b62a1d35"
SRC_URI[sha256sum] = "1ddf11a5b3ea9d07270eaf70fb766b75e123c5d45bb6c0bb4d1c94047deea9cb"
