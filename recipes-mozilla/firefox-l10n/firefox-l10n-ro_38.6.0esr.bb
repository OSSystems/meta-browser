# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d717ab75be5fb23595c78e7e3630a24e"
SRC_URI[sha256sum] = "7476011cb35e32f3cfa265621d830cac44d4912f5a5a3814c5c31e9cc5b899bc"
