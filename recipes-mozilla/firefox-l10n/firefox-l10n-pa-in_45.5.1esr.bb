# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "92c49ae28275e38cc05172c1fc0e1799"
SRC_URI[sha256sum] = "0b0babdc524dfd614680b85b22d77a88a6fc87e230e8a821cddfa00af9d56ba9"
