# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "a8b769f4d39b22f34c693d2698005453"
SRC_URI[sha256sum] = "fb809623835e0c1cfd6c1522dc05c5f3dedf9a04e86f63dc8d1d527f0f7deb55"
