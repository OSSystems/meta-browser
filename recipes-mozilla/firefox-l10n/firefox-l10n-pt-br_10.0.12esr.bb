# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "077f3e424ae219176c4a39cbc21f36b4"
SRC_URI[sha256sum] = "4bcdd89faa32fcb5e0d51a5e6987de58250437191cb8f44d248ce03dd6b7cc11"
