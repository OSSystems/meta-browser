# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "29412cecb046bef71d7e3bedefc804c8"
SRC_URI[sha256sum] = "1d3b3f37f4c755915bf091d0bf21db7312d5d26bfdc72362aefedcd51d616e8e"
