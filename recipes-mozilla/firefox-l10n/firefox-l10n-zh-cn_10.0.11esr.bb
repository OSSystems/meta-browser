# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b94a8c40120b8fc771cd06c03fede64f"
SRC_URI[sha256sum] = "7f948e543242bdbdd14de4d63cdbf81999b83709f1d9f964565f525b3e9de8ac"
