# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ad0d9cb083ad2080859149fa3bc5951f"
SRC_URI[sha256sum] = "da9b0b1f9ab8a49ce64a0b912b7d30f1cfd746a33ee0fe3391660fec1c792f55"
