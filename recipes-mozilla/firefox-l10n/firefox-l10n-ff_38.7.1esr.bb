# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "16088ea853c702fe347302552ce66385"
SRC_URI[sha256sum] = "c44d2a4fa2e780027332c2e987a919c4b515f79b9cac7bf1a919c336c8602673"
