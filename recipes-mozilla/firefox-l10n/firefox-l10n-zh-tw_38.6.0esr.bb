# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2fd955ec919cf05538c5d7d972501ae1"
SRC_URI[sha256sum] = "e94521a7cabb0230dce0448e743c5986cff74bc4a7ef8ea7280e45e1d257237e"
