# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "48668eb2ecd27bf1b57dfd8fa5a06015"
SRC_URI[sha256sum] = "2bea2356abef2c556197f1d07b427722bbbc15b697505ec622b98d1fec0af4f8"
