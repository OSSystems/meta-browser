# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b166bbbe2be2034d9f2e7b928960e296"
SRC_URI[sha256sum] = "bb7f4562361941f1f6cb5f157b52a0c8584e52eb8b1e0d643b00dd7bb0b5c51e"
