# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "fbf639e37fdfe1f33d69f6f2a7b46af0"
SRC_URI[sha256sum] = "5593268f5c528941d639ed7e6caec84bd7439e00838b2f8d7951277d311d7b4a"
