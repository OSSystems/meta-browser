# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "81b25728f8354ab267ccc15e55296e3d"
SRC_URI[sha256sum] = "b856c77141af93ccf0268278e7325e6367da86c53d3644089ea22b1e8daec828"
