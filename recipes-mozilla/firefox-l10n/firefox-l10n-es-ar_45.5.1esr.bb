# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "613684ab04be851e11997beb603590f7"
SRC_URI[sha256sum] = "cd3636a291b5b97e7a424d051e86dd8d524758991400749135b6ad22ccaf6d33"
