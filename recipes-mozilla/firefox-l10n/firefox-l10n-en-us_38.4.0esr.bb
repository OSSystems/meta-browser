# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e5dd4b266f0f84a5b910bc30baead791"
SRC_URI[sha256sum] = "fa4b38cab1689369da78e317a2dd8aeb2c5c9575a3a3bb971118e2c9e1984f40"
