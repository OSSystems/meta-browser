# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e78d0a09d0e9a7b04fa23db3dce3e041"
SRC_URI[sha256sum] = "acdc6ac3318a9fefa6fe86ea4449cc58b2e5fa251ee9054b65a77ba6fa6203d9"
