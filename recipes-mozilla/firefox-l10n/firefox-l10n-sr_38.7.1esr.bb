# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b286a68e4249a4123bad803ea79097d3"
SRC_URI[sha256sum] = "b92988b1bee95773e35639ed3f02db267916bc2cff8a71bf02aab38fa1cab520"
