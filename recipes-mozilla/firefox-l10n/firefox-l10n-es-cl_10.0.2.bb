# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "01669b3b8b1c6a197b65dd411fae6911"
SRC_URI[sha256sum] = "1feab4d72b4dc178f6c96c13eefef8f60f8c8eddc7312d887c06cc0332b8ff78"
