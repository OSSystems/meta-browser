# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "31d1131898218472e7ea7fa1b05a67e6"
SRC_URI[sha256sum] = "ed56af85b5ae041aa56986688d51e1f14ffe210360483e744c1350508961a865"
