# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1220a490352fc279d9c13b5263fa0801"
SRC_URI[sha256sum] = "47ab6785c89f0b4962d2217754e3dd12ddfd7a12ad5eac640334531a2c16bd20"
