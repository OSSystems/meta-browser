# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "2bfbaf1e739289848a7a2ce521f33741"
SRC_URI[sha256sum] = "a635053cefaa36becf730a990892f130115d9385c93d6a41fa3b9671f9e69809"
