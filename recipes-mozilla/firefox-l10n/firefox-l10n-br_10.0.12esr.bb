# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fc9b36fc2d1124e9f75d05cf1800bcd3"
SRC_URI[sha256sum] = "d91bf32eeb9de681e216964cd095229ff89cee79fa636edd3b0f4ae263a36d6f"
