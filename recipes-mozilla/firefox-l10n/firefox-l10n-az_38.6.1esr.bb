# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0779a267dfc480f09d7cbeb97e9d0947"
SRC_URI[sha256sum] = "2e56064128de639c7fb5776cbce3f4ea35ae13a823cba5ce2f79af6251e74a7e"
