# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "81834878c62b58ef6e01628451ae3c28"
SRC_URI[sha256sum] = "fddb690247aa04c6310e6d44e89a68b9e57ee3b49d047e153d38671e72faddc6"
