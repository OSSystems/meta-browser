# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "865ca6f9d2e97feed34de359495a4615"
SRC_URI[sha256sum] = "cfbc660b78d50c195af3acd8263f53bbb37334ed142091a0c0792135c569710a"
