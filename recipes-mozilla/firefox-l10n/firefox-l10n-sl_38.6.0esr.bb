# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "31f1a1fefbc421246297e59913b22e3b"
SRC_URI[sha256sum] = "77982fb211296342a39d5b16e2d538b8d4cecf7ab5a8ef7d958fb373bc32dd63"
