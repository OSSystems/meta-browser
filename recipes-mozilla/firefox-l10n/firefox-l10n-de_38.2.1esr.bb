# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4e88eec6d43dff85472a81e2c5e19e6c"
SRC_URI[sha256sum] = "3875513fb280bf215f37062078f3dee9e19b49cf43db4a1722975d086700fb9e"
