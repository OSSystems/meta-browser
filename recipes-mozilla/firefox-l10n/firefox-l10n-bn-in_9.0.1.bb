# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "60c34633b14b5eb30b7dfaf08592a529"
SRC_URI[sha256sum] = "bc87ff903308c5514f8f6f5d1281c36903406c0d138dc86ddcbf53c78bfd53a0"
