# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eb2b7d2dd9a225bc74bf04ba384affbf"
SRC_URI[sha256sum] = "97ba5815bd7c313861484d194664c05216b33fc259a2bfe27405e8e75382b6d3"
