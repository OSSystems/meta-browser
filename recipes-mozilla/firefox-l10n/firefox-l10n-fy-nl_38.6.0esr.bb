# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f26c7dc51610d909f0d4352f082a23dc"
SRC_URI[sha256sum] = "ec064490e4c4bdc05eca33974878cdb079ba144f9dac4fa497296d030441265c"
