# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "23d585b91c5ac0895386ce32b2d0420b"
SRC_URI[sha256sum] = "156b1133adebd0fabc47a7b398cb0ddee3b4a46e843356c3e8255b5000d54564"
