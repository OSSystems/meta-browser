# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "518faf91032c00ef519ed2a76899e8d3"
SRC_URI[sha256sum] = "3703c88885ab75b8a187ad98eaf31dcf4fbb8cb8d3c97d5efb6b3900a0ec5955"
