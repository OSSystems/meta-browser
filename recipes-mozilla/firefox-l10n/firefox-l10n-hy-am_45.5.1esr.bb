# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0b3dbc059cb0eb55a8cd771f594c2734"
SRC_URI[sha256sum] = "3579966a2a86dd271f710600dade51d71788725f4a78eca29a354e4e1ea0cdce"
