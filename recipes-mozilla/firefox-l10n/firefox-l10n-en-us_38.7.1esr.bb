# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8ce28e8cdd40f3d433e1d86bf2d829ff"
SRC_URI[sha256sum] = "2850454d1cea1aba064f69e5d3b845ae3591f6b65b54011c4e16f7816df22b8e"
