# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "4b1e50ddf9c739c03aa5f01a37d661a8"
SRC_URI[sha256sum] = "d4bd5dc2661787b398475d5d2f19a98257a3213e73560a76fad1c8dd1efe6410"
