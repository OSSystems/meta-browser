# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1bdcf552b8e581f04986cfd73ecf039e"
SRC_URI[sha256sum] = "114f0b7a0266d89545475d9e84b17ce9e44ef9430ae7e97dd8dfe746aa6924b4"
