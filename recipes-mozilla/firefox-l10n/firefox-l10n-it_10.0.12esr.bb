# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8cc49edb54910ca782ea14c0d166a51e"
SRC_URI[sha256sum] = "6e533b3610fde4b917f924154f6ef5b7f9593128d05df655dc7e1e46b4cec10d"
