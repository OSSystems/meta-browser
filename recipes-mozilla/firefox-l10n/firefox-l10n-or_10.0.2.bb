# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "50166fc7bea8714d48908abd64ac220b"
SRC_URI[sha256sum] = "7de503c7fe755f0878c367b464a93d95863ba2b18593dfcfd6e25f43f7e6a961"
