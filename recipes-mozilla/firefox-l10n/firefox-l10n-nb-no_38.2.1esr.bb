# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8118e13a6890a350c7829adf15863566"
SRC_URI[sha256sum] = "ff22df16587ed823ddbd422ef92492737e5a995a776413017c688f7b2f5cfb6b"
