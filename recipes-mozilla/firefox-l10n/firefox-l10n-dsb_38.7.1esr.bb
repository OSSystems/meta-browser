# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1c6305a4a2dfd9d71faa7f71b6c96e6d"
SRC_URI[sha256sum] = "995d87f77fd6da8c3ae62c1dceb6f74caf32c0b135b0852f4259e6fba31402f8"
