# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "ccdaf566315bb4d8108b0c400bf5b28d"
SRC_URI[sha256sum] = "cdce3a6a1b8c2723ca748da738fd803a0130f13285009197b7f5e65b935fbd31"
