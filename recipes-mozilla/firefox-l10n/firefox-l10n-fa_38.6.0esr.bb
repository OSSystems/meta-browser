# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "da15723a1c060978e540eab2a0e6295d"
SRC_URI[sha256sum] = "6a1e3e580ed74ba93e3691bb25a4a1775975d13e6cee6c911735a942f1b78e00"
