# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "12cf6f97bccbec51795e508ba123ae58"
SRC_URI[sha256sum] = "a50abb5b26d99b2015993d38aa2736b049e9784375f29c4340c67b5ce5901e9e"
