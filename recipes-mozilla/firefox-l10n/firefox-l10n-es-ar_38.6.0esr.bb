# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f7bbd8f3e890fd8edb856e4b3f1eef23"
SRC_URI[sha256sum] = "c2599ff3ee9f099478427831f8f244252d16be7fc165f9d686cfe35b5a97cafe"
