# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dffaa4e0c1789be118d6653af8acdb53"
SRC_URI[sha256sum] = "f08448a95f8fb2b0e959ae8eab09bcad64d170b1f9f4986552fad0795dd47256"
