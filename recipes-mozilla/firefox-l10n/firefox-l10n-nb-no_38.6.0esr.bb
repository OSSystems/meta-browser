# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8f6a64f386764a1d5c3e60bb90ecdd9b"
SRC_URI[sha256sum] = "d2d6e1fb4c126dd0736994613682439201d7f0b4ec25a64aeedd18ba5ce89c79"
