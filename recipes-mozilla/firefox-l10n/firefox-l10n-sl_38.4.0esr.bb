# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "384eb47f96d9b6c89a69673a78aba05a"
SRC_URI[sha256sum] = "84f23d6d865f70f1e6701ac34bdf4f894f20d31fb098cbadb4bc0a3d7182e60c"
