# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "40e313dbcaa09243b3edf95cd4b1de9b"
SRC_URI[sha256sum] = "f55fecbcb7a2624dfdb557584c962b04e0b54bede3bb007cfdbb28333022fadb"
