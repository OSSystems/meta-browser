# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "71551c25e780f052547d7ccc648a5640"
SRC_URI[sha256sum] = "c8b0774f386e378237af65aa7bb034bb1abda1e4b6b02b53d30fa4b50c09fbdb"
