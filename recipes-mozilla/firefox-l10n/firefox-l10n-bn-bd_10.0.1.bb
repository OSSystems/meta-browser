# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "b9ba6ffda7de6d9e494abb33ca73910a"
SRC_URI[sha256sum] = "56e155204142cf07ba36d6cf3dc15db0b2c466ecd066ee35b452ed206a67fde6"
