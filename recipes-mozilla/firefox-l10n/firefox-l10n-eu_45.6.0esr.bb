# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ccbc2859672a22561cde3b05bba7005d"
SRC_URI[sha256sum] = "71a47516d6b618c50674d15e3b4e6dbd41a2bdef8d69fcd167af6b3fe544cbc2"
