# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cbfa54c6003c6303170a193be1609e8c"
SRC_URI[sha256sum] = "a65a8dd54047ed0c4f530dfa08e2f3486374da8fb01207ae92b0cbe2ed81d831"
