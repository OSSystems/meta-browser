# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "23c7cc86f7110e5d4b261c17f6ae9ee3"
SRC_URI[sha256sum] = "01fa6077c6c05be1ce76db8e44b2c8462fe0a7a7818b1ddf9f6b2fa0d44c41cb"
