# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "99f63722c38a275a24e3e25288117414"
SRC_URI[sha256sum] = "a1e1eef9671fa728fa59a8e682d419b30e46335f822232175f41e512e86500ca"
