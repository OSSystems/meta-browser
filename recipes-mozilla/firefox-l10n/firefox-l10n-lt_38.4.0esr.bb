# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "51e75814782dc6a330363911d62a061c"
SRC_URI[sha256sum] = "769c238f3d90b896e6e6bc0b04ed29e348e4a60a08df49f28f943358ad036063"
