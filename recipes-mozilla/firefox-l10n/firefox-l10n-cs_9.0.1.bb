# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "80a3e2c0475afb45ae510410ccb00c4b"
SRC_URI[sha256sum] = "b9ce83191db181dc317d444e109ddbbcf68f2aad8ddf01f431a16a444400ec2b"
