# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e2f6099c4b7890ed07c30ceb4fe2d25b"
SRC_URI[sha256sum] = "16c2d17420c49a4f7fffdc978e9a114748ae0cfe76ee0f8db721ceef8a9bdc94"
