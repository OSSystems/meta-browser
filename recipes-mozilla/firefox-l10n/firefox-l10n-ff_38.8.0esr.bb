# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c7434ded545e041d3bd714712a0c85cf"
SRC_URI[sha256sum] = "edfd124723ea09d62b5f8ae4528a007513c59441b5e6d55ad9887dd4085f39c4"
