# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d12814c2e72ec4e52f6e7aaa389d17a0"
SRC_URI[sha256sum] = "dd7f3d01a98ded87e1af52b46de7baba6be2effb0d51ff1c95780bd37c6fff59"
