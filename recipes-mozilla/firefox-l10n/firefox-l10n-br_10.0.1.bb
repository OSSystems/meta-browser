# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "ad168d792fa899ccd4a72fe3778f3504"
SRC_URI[sha256sum] = "9093e623b00213f0af54e3beed43920573cb59f808e9a049269eb0eba56a1a69"
