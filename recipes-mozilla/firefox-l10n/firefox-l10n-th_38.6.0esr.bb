# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8e2c962cba05370b64b50aa9cc761907"
SRC_URI[sha256sum] = "c0e6584c2265cb1c2a5c55547e9ac11ae09817e26e3dea8f6b00334c3262a60a"
