# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1f2d32ecfd2a43f16a87a4f9b73bab24"
SRC_URI[sha256sum] = "b1401c37e9e44bc01e2e3627ec82dea93346681d6259e6cf14079fb973ae20ca"
