# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3e9fc8f47bfa0992abdd8d825194a903"
SRC_URI[sha256sum] = "5127771f5b665e0cf38a111a8cbaed71cfd223a238ed72e075c6d271d7a65222"
