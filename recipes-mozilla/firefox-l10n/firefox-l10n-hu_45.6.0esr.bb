# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "749a0787a1bf10f9a2db10aa37cbafa2"
SRC_URI[sha256sum] = "bb659f779b6e220c3d285ea70f9a067a731b3d8e2e2bd480d1746cd4c898f29b"
