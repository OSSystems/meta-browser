# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0d42f4bd1b75bfcd67a1ca9273243185"
SRC_URI[sha256sum] = "d5c098767669768cd01f626cd53bd7953e212e23283ce4894b4da9bac8544f3a"
