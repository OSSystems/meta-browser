# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5b06ddf6421cbd852c4e0e353bfb9aed"
SRC_URI[sha256sum] = "dae76d00ef18520fa1242273b13d4c5e00755a538e59931101196afc8fed3c3b"
