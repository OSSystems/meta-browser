# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bc7c7aff1b76be5311773aea366671df"
SRC_URI[sha256sum] = "3090a4c7144c2dc3da2e48e12d6de8948af810230b9ed148213af304f0652fa1"
