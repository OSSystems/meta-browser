# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "40edd000dc65fd886a562908cb1d8546"
SRC_URI[sha256sum] = "305df206828887322e4f3d4c689224e1187e2a13b16dbcad898b2a3aeff5f25e"
