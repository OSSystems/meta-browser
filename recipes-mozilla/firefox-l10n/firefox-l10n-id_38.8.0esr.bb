# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "482bfad1358119eae58faa767b28f840"
SRC_URI[sha256sum] = "7ae86a725d170a28464e88f7d60a281f6149cd164be567c09c32751f931fce8f"
