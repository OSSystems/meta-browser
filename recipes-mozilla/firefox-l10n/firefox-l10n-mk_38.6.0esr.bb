# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b62e2f1ff83ff5d9db6cfe0eb45f7aaf"
SRC_URI[sha256sum] = "69bb1d10e0f265342b4f4826766d0f6b13f3d777a0bafc448173f6441512a3f5"
