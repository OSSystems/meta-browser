# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "0a27e88bdee857c0e3f5d3373404a16d"
SRC_URI[sha256sum] = "1fa91ae74f1b5eeece382b7bc37b0038b6c9a56b47d200080e8f565bbd18e685"
