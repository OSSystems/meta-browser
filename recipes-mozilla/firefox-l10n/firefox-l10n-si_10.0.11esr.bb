# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3b544db2fcc106d80b2f82da6a482efc"
SRC_URI[sha256sum] = "16791cce9532b68b946e90015235e24f7b9b3b7f3931c222449f0da9342624e7"
