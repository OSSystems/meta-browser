# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f760e2e08f607620d2f8213365e0a785"
SRC_URI[sha256sum] = "fa418bf4eddc971c53d9e2f2dc46726df63820fd196bc17b4c51f9b19fcbf6bf"
