# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "45606f08a063ecca7a18d3aa7172a0b9"
SRC_URI[sha256sum] = "968c1256ae207b2c972a97a6d80f675521bab2d9a63f1487c65c1488cdaaa9e0"
