# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2e84630b8611e53585989ada4143aa1f"
SRC_URI[sha256sum] = "401012eb6828fced6f910b74714f9f7abd2fdfa15715b4bf6c8225b0274c074c"
