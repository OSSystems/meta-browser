# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7d4e138114830209b487cb94511756ca"
SRC_URI[sha256sum] = "773deb6abe3dd09a515dd3987953120f51ab701a4d83eee40464b8f1e4b275c5"
