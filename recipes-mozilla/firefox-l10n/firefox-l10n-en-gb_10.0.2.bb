# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "857009a7d9c60faf676bb42b09d4fbe5"
SRC_URI[sha256sum] = "d2055988dd8d93d849dc2e4f6933f0d31cf025377d29d9a8a4bd7a32d8b06075"
