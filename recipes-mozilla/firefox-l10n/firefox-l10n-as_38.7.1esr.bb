# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "73b5e40600e9e1a1b0517cd1d40641bb"
SRC_URI[sha256sum] = "245b472e0a22f66afb2aa1b5c5121be45a51137e5b356be40c2e792189593af9"
