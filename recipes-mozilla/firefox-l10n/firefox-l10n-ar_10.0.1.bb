# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "3d90a674a953a333fc3eb4eac49fdc20"
SRC_URI[sha256sum] = "2e2e90ce071d8a00db1b645e77d5448468117ddd1ec21f326a1004c71617b63a"
