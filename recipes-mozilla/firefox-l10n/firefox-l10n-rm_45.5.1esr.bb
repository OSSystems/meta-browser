# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1b3abd046c6d5c598d38adba4e2e5831"
SRC_URI[sha256sum] = "b974a691a8eee4342aaee6bfb8917899125ddc3d8d80fc396eecace952ab1e54"
