# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e56c07e987c3cfa738ec28717c3fdeb5"
SRC_URI[sha256sum] = "f03dff7d4f838bdca115d38ed9b858eb6764e5fcc27ddd0e8398b1c2209271e3"
