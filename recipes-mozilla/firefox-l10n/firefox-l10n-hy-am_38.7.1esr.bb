# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ab2bb9f96891d54e34227d6e2d67a16a"
SRC_URI[sha256sum] = "fb2c52d224128732dc2efa22661bc74ccfab729a263ea92979e0007a151ae80d"
