# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "8d59aa0a3dd7296a0cdd3461455c5d1b"
SRC_URI[sha256sum] = "9e28607f32c02f090d9c4120ea154d28ba70547d1f92ee06b38a93435846be98"
