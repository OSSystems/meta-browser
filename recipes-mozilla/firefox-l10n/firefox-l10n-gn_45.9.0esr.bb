# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "119122745ee8c787ba4c32413b33b295"
SRC_URI[sha256sum] = "2dcbd6f8d3765df6a889ec6fe7b2b9a6bdc9e377c7a877a9e3466579a9d76e0d"
