# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "bd7ae99d5cdf6773c44b04fe35df7e99"
SRC_URI[sha256sum] = "115e15a7a05d8b5e10eac83d805120023eedbe222354f94ec4f22957649f076b"
