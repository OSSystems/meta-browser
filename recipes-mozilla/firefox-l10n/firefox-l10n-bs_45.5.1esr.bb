# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8f3e911402167d6cc7c8bf9fbc80aa08"
SRC_URI[sha256sum] = "94d9dbb9863b76764c3f84686b003ef95d20c85fe893ab4a581f3cbdd87f4e91"
