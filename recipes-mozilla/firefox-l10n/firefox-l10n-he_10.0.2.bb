# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "4f22aba166f56bd528d307b0e7b541f2"
SRC_URI[sha256sum] = "8853d4a52b1e045b29659c97fe03b4048155b54841b53e20765b220eb0af2bdd"
