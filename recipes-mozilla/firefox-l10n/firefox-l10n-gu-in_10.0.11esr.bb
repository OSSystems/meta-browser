# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c4c3dca0fef1bfe9a5d399d4f1942edc"
SRC_URI[sha256sum] = "facd8483801bc169a9d5ee4674e5a9ba343b0348ee4957158141f73bf291e8db"
