# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d570c57a766b94e06119120cc3a791ee"
SRC_URI[sha256sum] = "5ad2299d95f27e0f6b7be9c29bc2139334f0cb04808fc141db2810251c9dc92e"
