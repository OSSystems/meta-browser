# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "e3cc6de453da650747e89fe222c7d236"
SRC_URI[sha256sum] = "9c691c1733ef5a500f37e87b11fab6852e9bc1c0da6c6252e4e9f01e6c0ca7ac"
