# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cfca66b1443852661c52b5cdcf79ff93"
SRC_URI[sha256sum] = "a4585d5dc8052f53c8951892fd72a2c853d92174e94ecd1a002451983e461d6d"
