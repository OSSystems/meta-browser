# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "668d6b5efa34444dcae9017d871aa339"
SRC_URI[sha256sum] = "6d74f9d8143573a7c8abf3dee1b3634c60e035ced131b3c02758078a28e77259"
