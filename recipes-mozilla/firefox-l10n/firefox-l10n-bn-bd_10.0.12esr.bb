# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fa9dba9b48585e5dc0a9bc8b6346f300"
SRC_URI[sha256sum] = "d55143b3a14e88c24a58fed3865884c23e24194b4ad253624d5d45b7d59d4ac3"
