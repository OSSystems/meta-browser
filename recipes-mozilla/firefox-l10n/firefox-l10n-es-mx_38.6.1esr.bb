# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "83e962c856d7d11efd339e021c425b48"
SRC_URI[sha256sum] = "b50f5e2ac3fa83521d7f5b6fe87038588d1c3747675c7e6b6e3c7593d53c7475"
