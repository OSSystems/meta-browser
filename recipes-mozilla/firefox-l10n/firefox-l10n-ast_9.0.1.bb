# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "4d1ef184884a27f92a00841578365e25"
SRC_URI[sha256sum] = "e5fbb8214d5e9ee79cec75d4fc4de85af4595ca4e51ef9fd63b6e8c1d57a72e5"
