# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f2ba17315063d276e2e868b619259543"
SRC_URI[sha256sum] = "6cac270d43a71cbf833329197bb5d965be231bb5c67311a005861c347b64659f"
