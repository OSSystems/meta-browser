# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3a4ed286cbe1934316357f6479ebefa7"
SRC_URI[sha256sum] = "39e09539cbdb65176f5f7505ed717bb6621492eaf24782a96beec3059a06c8e7"
