# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6f23c36d041b5ceb1c2150733fa61443"
SRC_URI[sha256sum] = "ff9ce14401f460ecc47c8b60ba131b41a5e50b19fc3abc5cc8553c339bd2ca20"
