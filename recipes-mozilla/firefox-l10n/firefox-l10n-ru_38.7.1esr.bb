# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6fd8ffefe429432abdb72f9e36a275ec"
SRC_URI[sha256sum] = "b993cbfaa34fc2c2b06993ab1a1b660d9f9c58830ce0c1ef6afa6eb80e566932"
