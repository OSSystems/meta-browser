# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b7343fc089eab5da81376514e2c0817f"
SRC_URI[sha256sum] = "0704f5f4bacf449741213825c95fbeb72482894b681aa43469287412fd939e3e"
