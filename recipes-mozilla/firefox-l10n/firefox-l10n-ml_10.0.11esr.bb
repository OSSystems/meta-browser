# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eaec4aba2593a8d5ea4874e7358b02c0"
SRC_URI[sha256sum] = "0931b0d3302867d43724e61a7912988f44de9d72d671a7c70675cb641efa72cd"
