# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "499ae56c575e652c582d203db87143c3"
SRC_URI[sha256sum] = "b14462221fde67c0fffd2fa0469e6c5a476540111088456842a59809e1e6812d"
