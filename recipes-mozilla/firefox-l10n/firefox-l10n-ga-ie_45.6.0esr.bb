# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d29b2403f775151f3585eb24663ce74b"
SRC_URI[sha256sum] = "e6d46c50a5dd6e866866fd9461a2442438695547cad6dd650579905b585d4209"
