# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "481187abc298353846d90fb7b087dcfe"
SRC_URI[sha256sum] = "e926a61de3fbc8f7120bb07fb0450cce81d9da6842bcd5fa7a8df1499fa11013"
