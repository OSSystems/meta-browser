# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "a08bf8949d6088cc3367be451e66cb0a"
SRC_URI[sha256sum] = "53cd27bfe33ee42321c27c11b49a4369eb7175d622f568c276f468c46898674c"
