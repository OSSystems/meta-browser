# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "02a9b459783e326c579f85ee24105578"
SRC_URI[sha256sum] = "e7b96756bf6fa67491b52b36bf4278b318fdf19c17f8b229a537a9a7d991fcf2"
