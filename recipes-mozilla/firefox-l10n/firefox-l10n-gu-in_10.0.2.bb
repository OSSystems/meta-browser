# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "fa0e332f3b967e21892b3b9fd70e7454"
SRC_URI[sha256sum] = "295729f7aa69d6cbac135ca9fad1388dc73298d04dd591607480ed3eeec49196"
