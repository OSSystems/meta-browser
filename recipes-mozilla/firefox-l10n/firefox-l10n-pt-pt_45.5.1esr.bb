# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "322e4ef6d228d59e3666586a4717001f"
SRC_URI[sha256sum] = "f9e608017d1fa1e3e4076efa20947496eb4c259fc5c90a7269222c4fcce50f53"
