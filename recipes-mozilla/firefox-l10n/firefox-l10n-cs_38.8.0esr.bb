# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9e0932f0c8f9947a99f43568248f260d"
SRC_URI[sha256sum] = "9e4eb776ade9aaaa582ea6502bb5929f7c33c9dfbacbfe26a315bb06e89da667"
