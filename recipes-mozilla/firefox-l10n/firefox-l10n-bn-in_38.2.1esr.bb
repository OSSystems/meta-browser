# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ed59a8ec211f063e1e08992bb8c4c3dc"
SRC_URI[sha256sum] = "bab25d7ce5747110b39b2b99685853a5931f340daa2cb88a4d53b01b0534f211"
