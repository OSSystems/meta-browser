# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e5eee628d6f94b0f84569c5d0ecb6b14"
SRC_URI[sha256sum] = "cc92f63d0326c0ab462a6eaff22719645f5df75acaa509ccf219bf056d71c49b"
