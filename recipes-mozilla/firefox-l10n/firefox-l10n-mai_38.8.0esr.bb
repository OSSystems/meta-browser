# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6a258afa364161120f92c1bc61d58134"
SRC_URI[sha256sum] = "2e58aef3761f3c5f63632d2db1570358cb72d6f298954dc7e0680f10e8c871f0"
