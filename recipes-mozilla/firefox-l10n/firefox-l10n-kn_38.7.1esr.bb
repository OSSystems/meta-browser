# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1c3f21f0aa32bdcfa5c8230804a855a0"
SRC_URI[sha256sum] = "a045b0e508b2b25b69aa5d59a0837de0dcff30e89c699ce2a679f8681a38b8e2"
