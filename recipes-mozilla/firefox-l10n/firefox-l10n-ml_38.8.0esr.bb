# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6db7673074a985e3d9f3c9271b4c6b02"
SRC_URI[sha256sum] = "997152ec467ddde80338c10818f75ae5f3345d8f8c8f26242f50216a3ee4319a"
