# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "9d06038f9f2c5d1ee69b078daf2180aa"
SRC_URI[sha256sum] = "312932f83d20f2353642c839667f1f2f5d82eef12e1c852858cf627e7908501b"
