# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "47e0d3f898e067198970b8a136da5362"
SRC_URI[sha256sum] = "7014e996175ed59c0fc020c8b9471eb188261e8d8788fa3cd36a74ace2e9ce11"
