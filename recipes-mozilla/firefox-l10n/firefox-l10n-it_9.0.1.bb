# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "45fcdc26be2c19236767d4bac878b6c7"
SRC_URI[sha256sum] = "948cd54537f83ff2d9c5cd13c940509b964923edaede4220700da0e49cf8b1ff"
