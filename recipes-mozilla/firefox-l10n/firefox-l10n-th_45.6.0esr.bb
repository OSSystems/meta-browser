# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "754aed1fb6d742557366f704fbb353a3"
SRC_URI[sha256sum] = "b98df316512b85fe33bf3d928852253f6892151da29df968cf79e2765255ece3"
