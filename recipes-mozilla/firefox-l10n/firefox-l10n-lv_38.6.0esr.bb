# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "deef5dcb36caa68d2973a01850d2f0f5"
SRC_URI[sha256sum] = "28cdc44b46e3126c60091b664e9fe3c5ed8116372acd13182e46ef5a6024bfe4"
