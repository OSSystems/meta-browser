# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "88168e8b758feecb4ceb270ae9a839f2"
SRC_URI[sha256sum] = "bd2bd9395d42625c8eec9cf73a3c054b484b0309e5727f74b41197082a3d3d93"
