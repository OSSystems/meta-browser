# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bb214d187b1b5f0421f514db1eb97202"
SRC_URI[sha256sum] = "61c2b5e3037fca2759313b6a21c6abc056e8bd9f31f9781f5c6ef1289af5cf61"
