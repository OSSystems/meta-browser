# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6095c4d23efec8efe72e820f70ec6673"
SRC_URI[sha256sum] = "3bf09cc69c2250394c512e783eff5c00fbcf2696000b4b1ddbb7b73f9fdc4dca"
