# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "2b1be4eaabe326ab3aef5aaa5f16779d"
SRC_URI[sha256sum] = "46ff60c9c6bfb49cc16d976851904189007110b2a41edb9f82b3343d87b55514"
