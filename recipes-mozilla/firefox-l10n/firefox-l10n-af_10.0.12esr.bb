# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ee09b5ae0b124cb02c91362fad37b08d"
SRC_URI[sha256sum] = "e67b05f7b2586299f48e1bb2a1194300b07e1645b7a31a41d4c18a3810d6da2a"
