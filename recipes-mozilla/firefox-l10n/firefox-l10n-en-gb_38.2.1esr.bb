# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1b3bfb37f153df5b6c6fe00a632d39d3"
SRC_URI[sha256sum] = "8f5dbb40d08afd368f74204ace917bc13e384fa305b5a588f87aabd7da741177"
