# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "74ad399cd608290dfc6151451ca5c145"
SRC_URI[sha256sum] = "327be0ebd57bd9e5de8e20fc6e89ef6a0c9f56a227f50e9f74254f817169a48e"
