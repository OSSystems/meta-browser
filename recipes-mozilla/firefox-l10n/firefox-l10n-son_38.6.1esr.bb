# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "53fc725adc358d2fbe06cf3792352ad0"
SRC_URI[sha256sum] = "e770d1aed090386d07828cf963413fb35e85475fd8a8128584cb5e57fc9181f4"
