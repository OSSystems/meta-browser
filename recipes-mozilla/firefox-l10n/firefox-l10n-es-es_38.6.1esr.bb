# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bee6a4d9c56ec73626dfc5700c4dbde4"
SRC_URI[sha256sum] = "0cc9a3eec376216c29818cd215dfa858396a2075cba808e839cc259e092dfa48"
