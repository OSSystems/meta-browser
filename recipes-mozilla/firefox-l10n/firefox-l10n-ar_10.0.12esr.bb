# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b71a07fa3242aa52ca624fa5da3b3bc6"
SRC_URI[sha256sum] = "31fe7aa9932fc554924bb034d9345ed9b57b9df2cc802e34621d037ee16737e9"
