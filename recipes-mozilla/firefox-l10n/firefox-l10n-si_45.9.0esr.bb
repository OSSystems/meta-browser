# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "41d2c0712b3ab8a081910f631caac85d"
SRC_URI[sha256sum] = "41c1a1bc3a308dc736fa96159016de2825f20ca5ca74ba1c14af1ba747ef9aba"
