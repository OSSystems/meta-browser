# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "defc9c1dda5d89b8e88f6cd855bab1ae"
SRC_URI[sha256sum] = "7e60540c76c0c50ab3c7f191e0a1d0df3ef187c95da89a53d25ad7ca46351d26"
