# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cd8cb1220deb37766b6cea517d53a96f"
SRC_URI[sha256sum] = "a1eec2480d601ddd5457e2db32e093ea1fa2afb86f5e994efcbdb1cb3a04ce30"
