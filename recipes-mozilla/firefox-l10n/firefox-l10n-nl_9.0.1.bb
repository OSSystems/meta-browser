# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "c046b69c1b90cb2c38e38580d8261ae2"
SRC_URI[sha256sum] = "000a1fc40a8230e51bdcd449b059e810bab8e312321eb9a0c85839bde8bdf54e"
