# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "677160f4166bd7d271b322a5a3753be7"
SRC_URI[sha256sum] = "e0cde1825e0e59dc9d7ca9a820c506978fd142d43f563c75cb7121485e436344"
