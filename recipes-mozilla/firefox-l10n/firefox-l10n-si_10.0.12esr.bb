# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "90999b92bb9c55127416effde548cdaa"
SRC_URI[sha256sum] = "88b5b496bc14b392ff9f0d4105cc89cee74663f7976101ceb36052a89121ce16"
