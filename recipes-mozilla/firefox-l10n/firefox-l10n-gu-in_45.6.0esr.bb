# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6ed69fa68522f356e992064f3206d2f9"
SRC_URI[sha256sum] = "c0146a7e562a98366f3cd6831f5573c5d30f8967f208b752900922f6522dd623"
