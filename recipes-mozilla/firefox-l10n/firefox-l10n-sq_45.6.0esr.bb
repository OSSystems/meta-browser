# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a317d9a9f37e7fcef6beb814a7a18e2f"
SRC_URI[sha256sum] = "1f18a2036fea7121e7e4e0ff9900b9eac4fecfa7b6afd56ce086a01f4b8d08e8"
