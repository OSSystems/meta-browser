# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bdef34cf02bb67c49ae1551a8d7c87b4"
SRC_URI[sha256sum] = "4e68a008b7d0fd078d239bfc417ea4dcf2f505f97b39351c3b74d4147f847186"
