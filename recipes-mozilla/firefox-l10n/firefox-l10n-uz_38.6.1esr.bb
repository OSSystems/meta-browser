# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9297e6fa9ed657eee7d1c748c0eaa03c"
SRC_URI[sha256sum] = "76965b8bd213077cab2c62265d4dc3b389c88080ddee50fdc0a9f59e5a567bb7"
