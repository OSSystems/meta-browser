# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "f1534cc436d5260b2ce1233c0ee218cd"
SRC_URI[sha256sum] = "19587c35b14604c5d1d558b9436803d551b148aa74852e16488c8ab072636723"
