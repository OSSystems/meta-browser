# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "b37a8d6e2d7a7e4016fd2138a80da481"
SRC_URI[sha256sum] = "4affad358512d3751ab2897bfd7c0ca12f288dd8fe37c575e6797d0ef21ae968"
