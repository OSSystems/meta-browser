# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "85e78651109e4a1a8fa2147e69651448"
SRC_URI[sha256sum] = "4b11045857c9d215826bf13ae3a8dac8b8e87e3441593d49b263aea83a48ea26"
