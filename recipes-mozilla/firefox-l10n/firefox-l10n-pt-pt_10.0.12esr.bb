# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5bf54a3c9081ab713dd2dc65b90364ad"
SRC_URI[sha256sum] = "540c41fa445af03b6b8567cc268c55fd5923d4179c40c6b1dcdad51cfc264c0a"
