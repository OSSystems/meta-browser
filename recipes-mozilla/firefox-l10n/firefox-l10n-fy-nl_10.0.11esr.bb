# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2fc234bd271bdd9ce868f0047cbe4cf0"
SRC_URI[sha256sum] = "b4282711697e6dd54b31765355e3cc488c00f375022ce81dad0a8d73bad07d2a"
