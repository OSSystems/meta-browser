# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7ae77814565227a0aa00fa624336273b"
SRC_URI[sha256sum] = "bbe862b7fe6435ec18d2671ea8d3bbd0a3976cf7258f4259f4d500d92d3965f8"
