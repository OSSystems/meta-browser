# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "79b3c229300e0900a7d33ee3ff0572fd"
SRC_URI[sha256sum] = "a507c129c1cffc8f3cf1d824f3684ef91d3abdb12d3cad9e9665e6824289495f"
