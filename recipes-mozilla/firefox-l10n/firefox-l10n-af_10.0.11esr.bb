# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "49462b42ebcfdd5c9a2c48375133ae04"
SRC_URI[sha256sum] = "90ece8bfb785765f665cd15683009b1e35426b68e94205bd0b706902697fbd59"
