# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "0fdc2f3e4ec88f58fdf2c3abe97f74bf"
SRC_URI[sha256sum] = "db7eb0a2ac12b9f8809aee46b13477db28f90c6698b7f5b123e491186b12ea98"
