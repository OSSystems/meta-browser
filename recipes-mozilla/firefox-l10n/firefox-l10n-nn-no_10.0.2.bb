# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "67dfcc550adb117a55090b6dcdf71515"
SRC_URI[sha256sum] = "f0d73dc68761a9b8e906cb4c04b551482cd53bdeb76f6aca23b80057026d4e93"
