# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b450fee3dc32b484dab1291cdafddb60"
SRC_URI[sha256sum] = "13e617b0e8476d6ea2353414f5157c8f2494c2a91a06476568ecc513abdd2bbc"
