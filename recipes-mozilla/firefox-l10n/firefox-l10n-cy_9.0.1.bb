# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "37846d7261734e9e87b3a6954443d15c"
SRC_URI[sha256sum] = "b866aa9b3921346729ab1729a252bba6e9f86cdc9b0ab870ea044fd3b5b06eab"
