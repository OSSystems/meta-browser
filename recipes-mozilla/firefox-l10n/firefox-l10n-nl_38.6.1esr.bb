# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d3da7bb2905d732d8681921235304247"
SRC_URI[sha256sum] = "8c9229c5aa626a8d033d387fcfc2164208f6ad8f86d2258fa30c90f468ff6b86"
