# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "abd7bd9bd97ae54cb008433ab3f73e1f"
SRC_URI[sha256sum] = "54e2954f1d24ee9935a5c4532575adc6ff133297de0b79ffb226031eaa863935"
