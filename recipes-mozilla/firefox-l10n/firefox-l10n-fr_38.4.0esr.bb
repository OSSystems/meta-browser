# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dbd6834e4ee22f1a06f3c22dda89fd76"
SRC_URI[sha256sum] = "1609e9fff4c9f221553628be4d64c3d70e7b55fe0120a049d27f7aaaa129590e"
