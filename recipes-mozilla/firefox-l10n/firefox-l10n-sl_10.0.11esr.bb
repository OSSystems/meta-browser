# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6c55f43d10815aa4795137a8d3052181"
SRC_URI[sha256sum] = "fd2747d6f0e5949fcd39d4e7a6cc568a417fce034b1cc94615c5216070f3dcec"
