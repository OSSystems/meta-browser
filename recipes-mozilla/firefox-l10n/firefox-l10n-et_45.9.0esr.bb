# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9e85e1cd3e0740b365f585c17df60bd2"
SRC_URI[sha256sum] = "7dd39ec6f9430c7fc6fdb8c143c9c4da5104a37ed35fba593e74ab22c3d2bbc2"
