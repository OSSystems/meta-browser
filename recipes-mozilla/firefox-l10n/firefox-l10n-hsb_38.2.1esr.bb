# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d7386677d411dcc060054bca07f448aa"
SRC_URI[sha256sum] = "a6852cdcecddcdc36ddcb33513bf6df0f39734f8ee174c52c3b46c0e4284d06a"
