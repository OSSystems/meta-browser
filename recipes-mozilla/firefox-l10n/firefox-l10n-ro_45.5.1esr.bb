# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8271d9d12e01183ce1ea1d28f36f010f"
SRC_URI[sha256sum] = "bcaf90c8a46072825bad4b3f13e88a6ab6882603a28255c2b923f2c97e607bd1"
