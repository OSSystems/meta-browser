# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2cbcb8c7f0213d74ccf3322d2545459c"
SRC_URI[sha256sum] = "cb7731bbd18f44f53ef79134e29b47c1b6df75c811b2d2514b7d2ece6442d855"
