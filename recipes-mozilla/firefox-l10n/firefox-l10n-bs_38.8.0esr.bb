# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "82c07e2325c89cb23103412c1db3e72c"
SRC_URI[sha256sum] = "988d90becd128cb241869249a7e3659bd0a59ad134ce438cd585914be4d2c30b"
