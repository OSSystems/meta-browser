# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ad6fe53dcaed3015f86d78065582b7ef"
SRC_URI[sha256sum] = "0bb028b144c5cda6b0d310b91b1312e591e18c91db0b223a037b18e0cbe34f83"
