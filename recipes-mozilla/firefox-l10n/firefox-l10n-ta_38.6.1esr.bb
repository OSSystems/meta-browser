# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2e5b4a09ee8b3c942de5e275b38090cd"
SRC_URI[sha256sum] = "ee5c5fed0f00a66d18cbaf4c76e1bbf435d821f3a40fc0a535323ed1a6cd47c2"
