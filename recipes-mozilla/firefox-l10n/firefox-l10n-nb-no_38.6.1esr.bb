# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "811ed3c5c1abf77c8d74e722bdd3af76"
SRC_URI[sha256sum] = "21fdbb9143964f24bef0dd99583348ee563d3cc7edbbd3098abf25a168541b0a"
