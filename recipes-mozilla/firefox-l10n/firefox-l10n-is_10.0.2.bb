# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "a5ce1203f5cd8860c41ed641f5076cd8"
SRC_URI[sha256sum] = "d83fb6f13b2dc3e4d4ecdd77bc6786a42cdbbfb5e93560d3cbf068d84fc2a76e"
