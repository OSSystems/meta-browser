# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "12d829791944d2070f87ac4a4211cc65"
SRC_URI[sha256sum] = "c255636e39aa7211af2ddc0135dac1d4f12e7d5caa7e05550bf11f29d1facae0"
