# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6aa235b964cc50f658c59e63d59056d0"
SRC_URI[sha256sum] = "172a8c5cb771d6427bc4c9141711821286e8fe0a2a5ef5b322dedccf8a4b60ba"
