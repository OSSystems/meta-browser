# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e2982afa0e676243ea54d47187f25202"
SRC_URI[sha256sum] = "987c370767ef39c784977f15768a79833052cfccf53b90ab0ade524270fc299a"
