# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4c7d6ad8483b35a975dcdccd98e41b4b"
SRC_URI[sha256sum] = "367e6432d3760e7403eea1ba3f59babd7846721812d51cc952fcfed9f62773c5"
