# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "698d78ae51e4211704c44ecd5ab4ad56"
SRC_URI[sha256sum] = "1ee8d139df0b85421f9319976200f7e982106d7dbdd13e0763e4f44748828da4"
