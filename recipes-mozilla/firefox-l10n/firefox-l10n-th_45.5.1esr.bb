# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ab495f060448bc0eda32b4ddcf17c216"
SRC_URI[sha256sum] = "7692a802fe24043c4e890f31dd907c347159fed2e98c9cf7c9e227d11ffe872f"
