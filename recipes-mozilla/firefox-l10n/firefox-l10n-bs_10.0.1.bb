# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "f458afdf49ba8c589bfd37a26915d5b7"
SRC_URI[sha256sum] = "bdb438d24cabbf93c0789a4ec6665c9ee9893e81ce5aa64a993911ac6bd52abd"
