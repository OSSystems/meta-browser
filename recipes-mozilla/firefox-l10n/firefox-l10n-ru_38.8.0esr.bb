# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "17c7dadd526e8f478774dd36fc788dd6"
SRC_URI[sha256sum] = "456a25a33498a723e4ac4114017a1de3f54a98e48aacd07b90b1f03bc2683c68"
