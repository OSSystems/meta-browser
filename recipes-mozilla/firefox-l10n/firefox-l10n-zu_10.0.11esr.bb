# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "29def81ccb1438e471bb56b3775e35ea"
SRC_URI[sha256sum] = "26ac7353f3a526559330e800899790698a3b92d61289e3dd19a84623b43bf264"
