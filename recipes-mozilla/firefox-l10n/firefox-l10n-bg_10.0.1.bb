# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "0d524127e08f07bd0be5b0099cc1c45f"
SRC_URI[sha256sum] = "d9af0b048996b5afd0dba779221abd89c5561b43e631ee87aea21a5f736492fa"
