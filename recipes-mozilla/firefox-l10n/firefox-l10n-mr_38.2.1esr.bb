# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f6d1f5bdeb64cd2719504875e4818fef"
SRC_URI[sha256sum] = "16d656c2094e2ef767d4d6a3b6e290d10db4902f71dc8c2e9b1410358bddcac8"
