# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d6869a47eb9482c490af55f3b66a654f"
SRC_URI[sha256sum] = "cb10bd76505ad2f217bf29b7779dfdbdfb959cb42ad552c4e2bde78380e8d9f6"
