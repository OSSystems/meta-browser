# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b6e26926d38ee8299227b18d2e902abc"
SRC_URI[sha256sum] = "23cc544e74606aa72e9ad2d9c3bc2ae835c82a2bec5787a531e5913dce110d18"
