# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "33e65f0f620e5799c304b1c7c112694d"
SRC_URI[sha256sum] = "ae32215075a3d1b27a73274e0df34b8d2600c3e2dc6d6886d1954c86074497ef"
