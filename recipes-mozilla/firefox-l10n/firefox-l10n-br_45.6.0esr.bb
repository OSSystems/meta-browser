# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0a18c612977c0bbec3ebd1afb07ad2b4"
SRC_URI[sha256sum] = "5b9674c896f5a433b201c4bf57fda780f7c931c027706fede3547b33ef212a52"
