# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "867dd8d96873c1ff4604b1fda84e4bea"
SRC_URI[sha256sum] = "d82c95941c6820a878f37c6bf2e4070a855d3e8b13ee2635f88e65473c9bf7de"
