# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5883de41dc730131ba2ee3cf401a04a6"
SRC_URI[sha256sum] = "6525afff18f0e5e76ba8daa67ee86121998ba3fa199215aa207b83759a7ca616"
