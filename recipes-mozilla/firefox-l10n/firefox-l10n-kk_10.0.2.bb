# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "6c7ed99b39ac13319616a4fd18f211db"
SRC_URI[sha256sum] = "7faa096832581d7de94ee092084b6a748c423e419b31692effa68ec2bb07265a"
