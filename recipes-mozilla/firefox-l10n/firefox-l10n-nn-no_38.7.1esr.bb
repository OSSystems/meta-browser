# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ad3ca6af8e226ac8252752af76823a2a"
SRC_URI[sha256sum] = "743ea205e27aefd8eccaa22aa92f507a7a2e87a87c6c0cc032faff1eac24142e"
