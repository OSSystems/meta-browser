# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "936c0d37dc58000f75cc4cbac7d146cf"
SRC_URI[sha256sum] = "5d91ca7d0f27ecee359d0a49be2d26219d15b985cee981fcb64c0bc0c4ba0022"
