# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "598812537f744566f4a07d14b7ca6d77"
SRC_URI[sha256sum] = "1de92cc4b659074953146880f26090d060030734b050ca4e9e99ca082930ee3f"
