# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "79e11b5f97d54d867c7b926f215d396f"
SRC_URI[sha256sum] = "982fcc4c7e45424b68370aa50ab98dbf1770c55baae8bffc09e25b9bb04a6031"
