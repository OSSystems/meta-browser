# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a6056482d8b675f499898c0d41ced176"
SRC_URI[sha256sum] = "9aa99d3d6db52466bd8fb52cad7df1e30bcf65ac5183e748dde2bbdf23783f08"
