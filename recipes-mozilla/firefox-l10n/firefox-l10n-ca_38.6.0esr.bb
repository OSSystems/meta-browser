# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "37e1d0ee66945775dcffefb95d3bac4f"
SRC_URI[sha256sum] = "c33d6a7afc0ab3381103b098c180a6f648e5373f2df06fcd495b18c486730bd1"
