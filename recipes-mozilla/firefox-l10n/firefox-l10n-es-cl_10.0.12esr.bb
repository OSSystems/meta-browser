# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4158a2ffc07f753fb31066258142d43d"
SRC_URI[sha256sum] = "ecf68a7a48908246a24b6a1e498da76312dfe8375576e604f327899c241aa660"
