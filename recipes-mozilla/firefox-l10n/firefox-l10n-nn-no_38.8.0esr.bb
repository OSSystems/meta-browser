# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b15109caeb39def597e07422cee6e9f3"
SRC_URI[sha256sum] = "af3239ebf813c6f89a26d3b080e9fb1655c05dbfa52c78752f5668c67b325b6f"
