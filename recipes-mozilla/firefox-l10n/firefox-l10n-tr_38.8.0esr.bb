# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "583ce9de53ea1e5246d903813d92a00d"
SRC_URI[sha256sum] = "ab46dc4d0e61bd360d27cb89201b61ddc74c616a24b341f372bc1e7a0a790391"
