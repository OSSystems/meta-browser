# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b0ea7115c6e672d71c9f575e7c756521"
SRC_URI[sha256sum] = "e5901ff82a8845623ba8aeea5750f034aceed59b9e152ca3561bc005c0fd7e08"
