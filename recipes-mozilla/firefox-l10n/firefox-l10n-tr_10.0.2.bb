# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "274202e7fe73f70a43429dbed048b401"
SRC_URI[sha256sum] = "686866fd17909bf10e43ec03693f16f90970e32cbf68c37f1d44fd41cf92186e"
