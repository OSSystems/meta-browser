# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "88cae8acbbf69e96ceea76f091e060a9"
SRC_URI[sha256sum] = "dd40cb6b174ebabe0bf77932051c859ff79b62da54521587274ccdcd47f3520f"
