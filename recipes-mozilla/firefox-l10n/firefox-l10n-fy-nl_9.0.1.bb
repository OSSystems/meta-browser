# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "d6f2b9b225ded6deed3bf3a0045bb660"
SRC_URI[sha256sum] = "017786b85d90eeaee9594e84c76a5d1442b70fb09ea75e87287a8bb04e77ba19"
