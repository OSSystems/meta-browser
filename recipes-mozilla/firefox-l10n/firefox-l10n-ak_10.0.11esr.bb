# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b4987d56d15ade8af2a6136f1abbd73a"
SRC_URI[sha256sum] = "9aea100e427b299226ea334c47d668200bd58bf630657776440c2ff32509f4a2"
