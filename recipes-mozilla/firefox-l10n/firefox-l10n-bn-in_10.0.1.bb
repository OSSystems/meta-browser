# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "7ad916e6dfc6e167e0c3598708c2c768"
SRC_URI[sha256sum] = "da7c3aa7550f5c788948f2db9c1f6e4167202a25c873722a2b322c88a5904410"
