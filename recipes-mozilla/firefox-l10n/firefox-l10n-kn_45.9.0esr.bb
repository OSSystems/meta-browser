# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "713f7045f996781611a65d240ec650ea"
SRC_URI[sha256sum] = "64890cb88c042628cd432eaa4b9f7122192cba694871dad1112d360b134d7ac0"
