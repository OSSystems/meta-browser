# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2d71c38db1caf84eb02502d414184e4d"
SRC_URI[sha256sum] = "145b4bef6d8fa5f644d3d1726bd7fa3d5679d3dfa1c456a0e39be3bb98b64ab9"
