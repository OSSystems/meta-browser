# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5c304a20179f5a38af4de523ce9f83c0"
SRC_URI[sha256sum] = "fd835c7ac82c1b112f4b9a509842aafa2bc25dfd7452870be07d9d04e220a0d3"
