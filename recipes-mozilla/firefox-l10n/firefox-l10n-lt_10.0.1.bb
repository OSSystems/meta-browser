# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "3bb7c9267a859ee25e4b4c150e043ca2"
SRC_URI[sha256sum] = "5971027a413beb7e4f8323af913f6b3e12d767ab2d78f34e3fb45e8075479f33"
