# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d84eddb128c2828ad489a31ec01c1bd9"
SRC_URI[sha256sum] = "63d6827d7c747f98082d43c7ec674bb986738a5eefe39763a06c28eff78ea48e"
