# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2d7a0e96a3f6ee5092cc34f7771378f0"
SRC_URI[sha256sum] = "3b5a43bb9175bcd12d81f67d3699b7851dc44ef79b25f53aea87c292ee670982"
