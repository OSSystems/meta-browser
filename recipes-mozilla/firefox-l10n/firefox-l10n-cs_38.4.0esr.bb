# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "47e38593e63d4cef6d9db97afa42c605"
SRC_URI[sha256sum] = "7e5c23a4e3926d2dc1d21ac59d616597312e2cd92a3e13322f0a8b767ebbf1de"
