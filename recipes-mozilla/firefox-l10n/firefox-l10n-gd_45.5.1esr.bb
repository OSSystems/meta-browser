# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9edb81b78d0b4d678283dbd13667c268"
SRC_URI[sha256sum] = "3184ebcf00bccee3b57ffae3c1ca787d5cd248648425df61a4401e58acc43979"
