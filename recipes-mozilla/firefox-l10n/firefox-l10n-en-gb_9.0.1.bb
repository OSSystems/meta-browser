# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "062680078e479373a292f69ae8583916"
SRC_URI[sha256sum] = "958f290ffb4bca4e778451d82c7e42aa0b272bd64a21c8a74ffdf1abbef85055"
