# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "2733f4b3a775cc003a925fd87f4d364b"
SRC_URI[sha256sum] = "c41915300e068eb58fb1aa17a22a5f9cf67d93485875f0b6c3e4619c7413509d"
