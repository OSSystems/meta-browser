# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "02366aa12fff5d3aff879521e32498c6"
SRC_URI[sha256sum] = "8916066abc92d6ddff59b248ffe79bc09e42ae2e553abee68cd96f81f7c9881f"
