# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "965d058f4854aae82c409c9c4a3eb53b"
SRC_URI[sha256sum] = "bba72bad3ba6f21ca3085bafc0cf81ac1e369d07122f56536ccb7a7f5707299b"
