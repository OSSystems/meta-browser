# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0524312ec31ec9bd4d6f9259e62f138f"
SRC_URI[sha256sum] = "3e816ca3e65cddfbe4fb2bc3955ec32a21c47481e9f71b6770017856065aff82"
