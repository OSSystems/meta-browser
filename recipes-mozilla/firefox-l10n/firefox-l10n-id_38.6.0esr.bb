# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8939e31bf0ab29eacf30c068ea7de190"
SRC_URI[sha256sum] = "34fc6704d13c6bad38932eaa9c57221fe7b54e5c57acf2e49a184d0c7c4660e1"
