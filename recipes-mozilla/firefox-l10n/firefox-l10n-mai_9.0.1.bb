# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "9b66093ea67f4476e3281fc1bf190981"
SRC_URI[sha256sum] = "fe7f4eb72877ca8c26f3e98d5585d53be1c3eae56422340d06ea4ece65c868ac"
