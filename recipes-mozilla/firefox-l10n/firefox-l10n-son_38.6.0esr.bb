# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6634ba752e8111f3afcf7a191729bc8c"
SRC_URI[sha256sum] = "0c80545bab1f7119067bafcecbcef0f902393fd3451a71dfc90122a6f0b8701e"
