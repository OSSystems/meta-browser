# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "464ea8fee0f0c2da0e093d3a344cd1d9"
SRC_URI[sha256sum] = "5b9f3769a67c0211eaba899a03ad5bd54aea33a4759c342dc1db57b43342562e"
