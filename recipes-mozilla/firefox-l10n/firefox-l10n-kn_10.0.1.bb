# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "a0373680c996376782836927d64d0fea"
SRC_URI[sha256sum] = "ef21cac9519ec6cdcba88d5fe567262cb7682c03e268dcdd0017e98c47acb912"
