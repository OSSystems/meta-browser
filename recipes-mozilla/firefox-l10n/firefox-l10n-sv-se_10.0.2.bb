# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "6bda3609ddf8d02d2d9c2214bcc9337f"
SRC_URI[sha256sum] = "c49fb957cee13c0bcf48b65065e96bab1bee701cc7cb71f7facde6deb40efd25"
