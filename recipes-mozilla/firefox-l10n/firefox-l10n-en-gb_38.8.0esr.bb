# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cbb893d2b44f1fdf6cb710f0e4c0938d"
SRC_URI[sha256sum] = "6cc59bde924d3fa2d72fc62e2c7c8552798eb6c8ca635a7ded2321c0ce8fff93"
