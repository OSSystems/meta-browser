# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9d05693bbf607f619f410d54468557f5"
SRC_URI[sha256sum] = "e8d4352c5aae8a0134eaef285d1a29264ecde26362725fecdfa156033353e834"
