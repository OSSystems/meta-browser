# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b3da4d1a61f01f48126f73451403e8ee"
SRC_URI[sha256sum] = "9de19db6fee44f52c838dfe28b823b6420ec01ab771c6c967528cfd0015c5ccc"
