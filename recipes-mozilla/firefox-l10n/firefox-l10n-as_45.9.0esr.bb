# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "937042dbf33be457b1bcce37c2179795"
SRC_URI[sha256sum] = "7285f41bf9be97811e56bab6889f74a68703b3a7a61a1c23b353086a6a7c9398"
