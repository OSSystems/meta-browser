# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c802292bddcd7f8f52f4f06ae8dbc6ce"
SRC_URI[sha256sum] = "c58eab87d4adb52b54c1295852253f92ff5afff666a63c1eada1178aa638c4b9"
