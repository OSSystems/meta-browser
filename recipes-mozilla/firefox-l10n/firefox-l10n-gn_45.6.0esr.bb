# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4e3ea863abe46a5bb87b9edb973d394a"
SRC_URI[sha256sum] = "5fb792f76fd0d222f80c028b44ff1e005c369323b95123c4e052b80a238795af"
