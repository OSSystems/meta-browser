# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d6a3dd40badb2b60d628b77eb2f98ea3"
SRC_URI[sha256sum] = "79cc307c3614fd9d48b6b2b7eb37381804c2de852994e79104472020fa350eba"
