# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2d15f5f02aa6ef4c4dade83898eb3818"
SRC_URI[sha256sum] = "a3c0e348ed81dc0b6a26b7c7ff9666e3ff225cba5da0ce139ef7257b92c50f7a"
