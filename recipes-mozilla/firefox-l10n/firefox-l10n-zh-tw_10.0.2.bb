# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "01af6c3654a1211f257be2dfd1951a02"
SRC_URI[sha256sum] = "b17a795360b8272dfdbcdf4fdd4a67f544405a0c5557fedf31448ad962c66923"
