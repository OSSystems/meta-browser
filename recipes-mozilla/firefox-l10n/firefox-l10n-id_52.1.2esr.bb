# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "10b6f5da2eef0d04cc6623dff34cfbd7"
SRC_URI[sha256sum] = "1a38fec5f0d75c7732306d0be9f2030d0d6539814ef3b5c1ad426c55ca848947"
