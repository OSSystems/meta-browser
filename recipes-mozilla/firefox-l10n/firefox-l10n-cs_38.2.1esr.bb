# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "292daba64a998206ad3780995eb9457e"
SRC_URI[sha256sum] = "d8c4ba79e4725029dc4073e065c65a8ba1d97fca9e2ab53f7147184211801178"
