# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d4b33e731a21a0a55a864a186b267467"
SRC_URI[sha256sum] = "73806827db64d54ed75827258e2d7b728de3269d24bb0ee2247b10f49a0fcfbf"
