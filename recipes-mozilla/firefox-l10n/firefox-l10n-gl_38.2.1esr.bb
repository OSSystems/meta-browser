# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f8e55dd851264f7e63120034c6f9a813"
SRC_URI[sha256sum] = "9253cb864e13ad8f86350e3560a08705e3b411f5afb69b66fcc739571a5a9697"
