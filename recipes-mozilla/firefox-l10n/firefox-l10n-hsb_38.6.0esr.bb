# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c258ff97537616174412295d11d08f18"
SRC_URI[sha256sum] = "194a7950be8a0062e8b6ac9205025ee5ea6394b67c9a8af7642878ea84e16161"
