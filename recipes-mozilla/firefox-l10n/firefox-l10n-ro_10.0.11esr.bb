# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "50abc165ca5b92e39f686080c80e702c"
SRC_URI[sha256sum] = "45d422e0719308cd2540bd331b7439579b265e9679de1051e7f8e006ecbf0899"
