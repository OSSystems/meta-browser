# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "070b6959f29291d626c4cabfa8bd471c"
SRC_URI[sha256sum] = "878360c5b569183c794b241bd9bd3ccb79f9bb5d739795ac9b0c46960b6ebe18"
