# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2848d58c37fb21e2b1dc2dd546db78c9"
SRC_URI[sha256sum] = "3ad5612cad4039146181a33b738f51e6ab91293e7ce1b13b16613bc0d51a93f2"
