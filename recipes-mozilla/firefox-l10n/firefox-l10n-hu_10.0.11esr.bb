# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "34f5e62b4674cdaf3b3f4ece56540406"
SRC_URI[sha256sum] = "dcccb43804ff627cb2bf6404e961b0cc7beab8d8c1318471ad7117fc1154a2ba"
