# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "027ab81e8fa06c4e92bd514fc8b38535"
SRC_URI[sha256sum] = "0b008ed2230d7646858411d0b2225458e319f14661330e90ed11cf4955a31aa3"
