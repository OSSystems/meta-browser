# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f9cc484a6054bf50a39c88aaf03fb9d4"
SRC_URI[sha256sum] = "bfc5fe681d846d57ff34b69916a2a67182a020652d7c4949f6835e84ea296f22"
