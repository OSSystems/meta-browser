# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "47fb1043bf0b46c466252f7a3e30786d"
SRC_URI[sha256sum] = "35603ddf758d0c288b75a5216d8cc64217073ba49812c527888a61fdc50dee2a"
