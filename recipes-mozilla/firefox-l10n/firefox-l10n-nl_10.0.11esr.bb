# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "99e92201c8623356cef2a08f98ee014d"
SRC_URI[sha256sum] = "b05fc760572c72dafbaa53c2b249e19b5fe119568cff724ee1a7410bcb8eaaa8"
