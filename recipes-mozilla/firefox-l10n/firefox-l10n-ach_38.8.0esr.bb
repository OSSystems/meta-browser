# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "17a5b41c3c4fb088f6f8ddaa6c7bde5b"
SRC_URI[sha256sum] = "c638763d5e5c506dfad6deae20040459d28d52d271401f76ef7b0ed45f4a26a5"
