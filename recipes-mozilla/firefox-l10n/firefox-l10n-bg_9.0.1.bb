# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "460d91b06c623fee0598e240f2bb5de8"
SRC_URI[sha256sum] = "6561480792b4751ca036bda6d620ef7a0eda5a486c9e5601ebb76c8e819630c9"
