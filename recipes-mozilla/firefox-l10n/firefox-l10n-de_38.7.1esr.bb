# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5fbc888c2f51507a36b29d1d187d13b6"
SRC_URI[sha256sum] = "02ab0f297dac17e189eb8aa19c5a11e5a7f7d93a59c4734847ccdbe6c079f4d3"
