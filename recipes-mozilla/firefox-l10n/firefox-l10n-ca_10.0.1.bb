# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "48727c92bb723648ee60959351f6fbac"
SRC_URI[sha256sum] = "9688cef04c511e503a497dc3dadf3ccda7f900c1b37d30dce7436ce128c56687"
