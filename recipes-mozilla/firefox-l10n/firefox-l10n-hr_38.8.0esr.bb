# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "04ac3b812798a0af0f61a3f36e91012b"
SRC_URI[sha256sum] = "2f4bd0d8c03e470579a072a00d7736ec27f490e94d37690980f1bbc5ceda07df"
