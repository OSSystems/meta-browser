# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "6f6ffa9946556d0da77b7c2f924882a0"
SRC_URI[sha256sum] = "f7e137fdf10eb1b3c3f24b40b10be75daaa0fc598b96cfe3af38d4f2a2bacbef"
