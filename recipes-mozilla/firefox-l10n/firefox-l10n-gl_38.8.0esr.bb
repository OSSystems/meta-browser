# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e3c906ba564cc586eeeb433cac513735"
SRC_URI[sha256sum] = "c0da902caa09da65980a422872f1c8e9346c06721db1a75c42c7cbdfe2c3b83d"
