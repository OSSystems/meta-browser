# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "015158fda8a89595c053625a72c4a59d"
SRC_URI[sha256sum] = "40b2b7193da6a0c3f96cdeac34afe1fa58e1469ab5ec99e9e22dc7cb4b665109"
