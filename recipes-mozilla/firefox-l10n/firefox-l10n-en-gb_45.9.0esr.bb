# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6b37a48c6b55f25a56e8f050258b0fb6"
SRC_URI[sha256sum] = "74e6ac0521766b904ff631283da1509201762c3168a48a3bdfad89da8c2428ee"
