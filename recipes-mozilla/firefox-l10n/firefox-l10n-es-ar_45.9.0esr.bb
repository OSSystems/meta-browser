# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6a9dfc5b0bf7efd900c62011c858145e"
SRC_URI[sha256sum] = "a24703321d54a08d55f32fe181faaac94546f280728f93c7b801bce44ed86aac"
