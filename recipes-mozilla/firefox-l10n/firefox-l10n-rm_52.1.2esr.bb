# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "20964acc533e07f6466b4495d04f2c5e"
SRC_URI[sha256sum] = "b70b45cfd52f44de9b3907ba1c3c221d4b53214a886b0f92cb21b66495edf83b"
