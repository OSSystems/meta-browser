# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5b411b7a0f7d384c21a66e62c7752d4f"
SRC_URI[sha256sum] = "eb6d35bcb9ab62fd9a38609c40299bbc79aacd1ef102c2fadaac5c9163afa57e"
