# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c5bbe4351cb586659845d67463f89a26"
SRC_URI[sha256sum] = "964f0c93adde0188ff3664c73ab04bb2e50201a7e4156200e4d471ef9a10772d"
