# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ecc89948ef1ef237396186c6491ac32c"
SRC_URI[sha256sum] = "78dd06c63acdd8cff52f2c08604f612bd98f2ac9029b6da11913e9a5053e0f50"
