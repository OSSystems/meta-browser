# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "118d6346b27a20c17220436cddc99db5"
SRC_URI[sha256sum] = "962dcaf24bbe27239c3b5a1b3d96fe37b11a5b8954237a05556215af96414d5f"
