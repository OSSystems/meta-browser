# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "911b8d155e48215f6fbf1ae839a4acec"
SRC_URI[sha256sum] = "c8e771db33a32763d9772e8c7e27887d15ca2bf9068415d21d8dff8147fcccca"
