# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "e330e3fe565cc6538d3f17024c6c9387"
SRC_URI[sha256sum] = "9fe64c82e31464747bf231b8a98482b3b8b83097df689d653fb316e2bf495ee0"
