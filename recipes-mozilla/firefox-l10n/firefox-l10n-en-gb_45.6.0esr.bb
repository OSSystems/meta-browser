# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f8b942fbbb2dbdc85c47e46587996ed3"
SRC_URI[sha256sum] = "76263a88c5f1e919cf6a865d37637a2409d7775dd11f823e45922ae594f5e040"
