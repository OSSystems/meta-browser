# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0d99708f70bf85a0440130f3072a7180"
SRC_URI[sha256sum] = "8069f637402678c1600a23e35c956f5ed9f16166a43e8dccaa48c2ee406929c2"
