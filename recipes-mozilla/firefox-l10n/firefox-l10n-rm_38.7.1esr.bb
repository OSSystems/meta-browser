# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d32a921f7fba5154aa331c97ced9af34"
SRC_URI[sha256sum] = "23a00150ed90672462ce64646b960afe7e93c365407c900d64b5efdefc9658b0"
