# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "03d30ea0590b4834808252ac780487ef"
SRC_URI[sha256sum] = "860e3b0627aff036012a0752d6dabd9c8608d276f01a8c1b771a15976ed3eb64"
