# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "168419dcffde0c5afa8b3266ce9bf31a"
SRC_URI[sha256sum] = "299005aa0b813bf6ce711214abd89f116a907be84e14076620bc54d54b0e5fd1"
