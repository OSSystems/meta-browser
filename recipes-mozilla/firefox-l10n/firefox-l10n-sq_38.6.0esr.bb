# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c605a933bc36e68d57787086fb16a135"
SRC_URI[sha256sum] = "6f3d9fcfff460a162fc3e0cfe75a8bccfbf5eddc8d683117474c99d07f47100b"
