# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "569f76ee14830f48300e623413df6054"
SRC_URI[sha256sum] = "27f14ea9c4ead1cffc36f560f8a998ac453dea76375adcd889c70106da43eb1e"
