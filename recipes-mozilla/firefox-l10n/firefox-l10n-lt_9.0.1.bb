# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "42e381d0510bad0b3ec921cbc57b3c19"
SRC_URI[sha256sum] = "9849f8c5dd52730dfdbc7b66ff67a95fd04b1c3ecfb8731b3a26ca4f74ca15b7"
