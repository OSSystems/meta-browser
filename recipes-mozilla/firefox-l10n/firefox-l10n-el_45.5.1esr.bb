# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "30020428298e48183908b2ba188efc4f"
SRC_URI[sha256sum] = "26dd726a8f2f5a9d8260a1bb157fffb0fe97962788a92e8f211435d325afe84f"
