# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "acb74472744f8f3046e9122a7bcb92c0"
SRC_URI[sha256sum] = "0e45539bd39deb9315070726b44c01a8c12c9edb0d1773dc62bc606c45263500"
