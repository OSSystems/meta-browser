# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "19059d24f2ce311918f57415f16c850d"
SRC_URI[sha256sum] = "b717de2ec8d8012b4b609d7263eab5ea64d6bac17ade1cbb97406cb7c5f8901d"
