# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "1f7c0699652dc0fc4a851e41d5e73240"
SRC_URI[sha256sum] = "bbc5c4bb14b27a9b1b28081135495a62e32e089fa958537be808fefcb96476b2"
