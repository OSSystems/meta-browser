# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "04009805d6e5d16aa20ef3a7f3cbf26f"
SRC_URI[sha256sum] = "84c7b297a4319dd5d0ea5653fff3de6ae5eacb38f1f45feec90f56a5db837bde"
