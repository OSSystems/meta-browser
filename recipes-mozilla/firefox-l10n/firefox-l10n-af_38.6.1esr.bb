# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a25a2facfa140d3d8ca2907d892ec6b5"
SRC_URI[sha256sum] = "91f97c3c51218729a21e16ffe0a629aa1a10e59945190745db76d7febc3eac42"
