# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "2310a609bb5690c6f57d83ada587a835"
SRC_URI[sha256sum] = "b215fff64302f79febb18b1d631eb0598f2d9fb82077f7f1679e0d4054a6ba30"
