# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d00374915a5e5b1c74b9c41b16d03861"
SRC_URI[sha256sum] = "2150be83227315de82333e41e5496da5d3b823645a98404ef31d2cd98f6bd1e2"
