# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c0ade45028a29846093ba6c1fbff8d17"
SRC_URI[sha256sum] = "788ab280792ffe954cc410191f30f358e74b8f786435616d62c371087359f799"
