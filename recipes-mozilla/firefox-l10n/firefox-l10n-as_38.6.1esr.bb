# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "30a67abc2d2cded7bf7c3fe020551eea"
SRC_URI[sha256sum] = "2d5b2360425108eed107b083a11fa0f4fcc42f66d63b3c4b98040aa7a105fb68"
