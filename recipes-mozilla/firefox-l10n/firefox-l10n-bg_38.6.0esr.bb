# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d72cb36c46ca299254b703baf00bbb6d"
SRC_URI[sha256sum] = "d25359f143a0c4dd23fcfe4804b3f01662d4e97206be8440881d39d15064c6c3"
