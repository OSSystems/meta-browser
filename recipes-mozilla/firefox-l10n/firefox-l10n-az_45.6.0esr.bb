# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d212eaf49487edfd7ccacd19868495af"
SRC_URI[sha256sum] = "b8ae594bf9948275818e2f15b1ad657602961391f498110512a19ffd2941549b"
