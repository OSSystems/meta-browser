# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "10e4703183c43a9d498826676c667a35"
SRC_URI[sha256sum] = "41fdaa5bbde164b7b5d46f1c9274869fddcdd07f204bc986246c9224591463d1"
