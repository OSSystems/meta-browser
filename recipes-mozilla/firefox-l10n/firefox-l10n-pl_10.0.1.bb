# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "608a30bffbbd5b2f331bb205e1f2273c"
SRC_URI[sha256sum] = "644e3332e1661ecd04a9d36e46be0648937cd6f7852efee20195b67c821f2f00"
