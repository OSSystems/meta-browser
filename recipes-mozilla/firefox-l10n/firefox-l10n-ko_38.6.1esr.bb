# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "78cbfc26ce26c38be9e4099f469cd069"
SRC_URI[sha256sum] = "7c46f9d87aa57f038ba5b5c81b06f88e9ebfa9882d44237debe45b55eed7a83f"
