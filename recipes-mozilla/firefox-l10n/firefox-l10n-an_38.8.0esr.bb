# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "14328fdcc4f6245c0795848b8e93ca0c"
SRC_URI[sha256sum] = "dcfc9d536b1a8730e383526f1f6c03b87c3ccc1abe0e4096e2b172d43cc1d227"
