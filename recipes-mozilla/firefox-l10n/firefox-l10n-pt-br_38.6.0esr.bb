# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e164b7c94559a6faa4a0e84b6c32fb72"
SRC_URI[sha256sum] = "396e9bfe5192511c0ad67107dcd8e9bcda83de94d62095ca10f6af4433d59100"
