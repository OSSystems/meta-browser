# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8de8521ae43fea74760145104beed758"
SRC_URI[sha256sum] = "844ae2069a614fb33beb18d95659bae3af62dcb497ae4d67e155ce5ec05dedd2"
