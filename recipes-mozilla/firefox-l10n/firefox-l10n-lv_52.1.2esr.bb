# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2d9ae2cb9a2d70694af377344c52bc1e"
SRC_URI[sha256sum] = "5e4ad43ef8e67daa9404f2a7502b6f0c5c9e37ee3604a57086fe689ac4971ac9"
