# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2f984ede1513f79f7b6b4ea047339416"
SRC_URI[sha256sum] = "3e75a7a03bb794f84ff83bffd0729a0c966b620323f1850b6e19d909a6b8cb88"
