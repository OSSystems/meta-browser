# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5059b996132743d1b1b56848db1ee5cd"
SRC_URI[sha256sum] = "a9992a670f7c2412202b6c87e849c59d23e68f793770d06dd436ca274ffa921f"
