# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ffa78b68ae85b0c922a2fa1aa9e1ec2"
SRC_URI[sha256sum] = "ac140ec1ca39a0f02f1a9899d4be2f487c909e5e9ab43456b5a79796b5c12f70"
