# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f8499142a5fdf2c1c01177fdce388da7"
SRC_URI[sha256sum] = "15859c3fbfab379725578e6e37c279d7ef2000f8c8366c5e521011db1729532a"
