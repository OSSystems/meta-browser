# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c70c847410fd13697c0207489c6b6558"
SRC_URI[sha256sum] = "f8ce9f8b945df93d6085382cd9dc38e8ab4159f5900dacb0cfaf693f752773f9"
