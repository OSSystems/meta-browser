# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e0a33407f29ff7f42eb4d07f2daf48cc"
SRC_URI[sha256sum] = "cc9d95a297c309bb34fa7356cacef58daf913b5357c7c4661b51e64bd989f798"
