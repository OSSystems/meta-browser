# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0139ce2f3a563900de1dc9f6d6262bf4"
SRC_URI[sha256sum] = "75312cd630c037ddc2e50a43597e1c0242634c40d6b8353e20c5cf6b3416f187"
