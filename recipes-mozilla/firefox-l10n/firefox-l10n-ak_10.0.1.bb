# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "a593b37ed001fcff4e4af576ec006727"
SRC_URI[sha256sum] = "c79ac0a55a0d6e627ecd7bcece7aa6e5260565ebedf33d404b7f91370f544828"
