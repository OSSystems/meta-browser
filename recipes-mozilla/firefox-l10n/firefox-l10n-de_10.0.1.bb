# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "0f7ed48fee343b0c2eea60069714f1d9"
SRC_URI[sha256sum] = "011a764ff081f3e6a4a44ddba104cc10680b3c37429c629f952ec702b3aa8424"
