# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d92ecfe030c05515720bfa1b9293a280"
SRC_URI[sha256sum] = "027ec38f12e038834bd9c4d5938257e2856364768bed7452d9d0a99bff95ca97"
