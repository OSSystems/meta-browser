# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "23af6ecc67918d668407f65352088060"
SRC_URI[sha256sum] = "a0058912493ce8f9f8103a7f0d006ea55297af86c23932bf4c1df0f0f6065fd1"
