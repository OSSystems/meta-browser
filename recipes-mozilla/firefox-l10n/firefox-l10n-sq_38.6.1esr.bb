# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "270da91276d3bafe31cd416eb5213b7a"
SRC_URI[sha256sum] = "debcd2b1e1cf8c565acfa4c1234468a972675539d1c99d1a3631389ac42ed480"
