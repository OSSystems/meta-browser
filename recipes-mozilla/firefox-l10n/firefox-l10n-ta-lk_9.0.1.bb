# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "4bc9e6ac4fcc3d71d3a252ab71fb147d"
SRC_URI[sha256sum] = "d3fee1bbb9d92bb855db9ded81e43a1d41142950c6ac2cec558f7cd5aa13cbd7"
