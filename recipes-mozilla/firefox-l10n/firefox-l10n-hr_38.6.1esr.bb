# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fd8365b259555ff9055b32abc76484bc"
SRC_URI[sha256sum] = "086e06d26a1a4f299cce29575266d382615654734170a5f6601d822cf33bc8e6"
