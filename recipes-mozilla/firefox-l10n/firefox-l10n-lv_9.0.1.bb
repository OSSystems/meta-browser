# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "152b53a3a579fb0fec516a9a426bc139"
SRC_URI[sha256sum] = "f3f2b87c1df3c67050cc98912b594c3d5b559e6893ec9c9f8f7bb403e4dec900"
