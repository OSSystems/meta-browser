# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b6f4db6e193bbaa6ee83e2494d33c7d7"
SRC_URI[sha256sum] = "953da2f75c58c449e82382a773c1c98453caad1fe8ee028740fb6aef9c6d0693"
