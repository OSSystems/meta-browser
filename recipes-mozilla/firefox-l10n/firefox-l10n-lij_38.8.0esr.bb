# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f98af4b015f9b74fb155bc4b14548ab0"
SRC_URI[sha256sum] = "0660b6bb2733942bd8420239543b359464aec22bffb90d87097ff617a75bbea4"
