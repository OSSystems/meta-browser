# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e55e3836d045e4f067f41a275c2f6106"
SRC_URI[sha256sum] = "53e28ab8af1550d6f913841afc44c098a3118a3701aac0de8475250d1059517c"
