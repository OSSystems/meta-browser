# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bcd2bdbec7143a45d0424e2b80e8d9fb"
SRC_URI[sha256sum] = "ab6a5b27d32c19a203d5f2b7dbe4fa35fbc6b44c68458bee3a4c4bdb21c377e2"
