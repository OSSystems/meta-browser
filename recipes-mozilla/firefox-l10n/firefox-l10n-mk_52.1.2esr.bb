# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ecf5201af6f8fdff0834d6517520406b"
SRC_URI[sha256sum] = "327db8540272fd64e8306178dd112e7edabf1b272f61967391797b8be9f7f324"
