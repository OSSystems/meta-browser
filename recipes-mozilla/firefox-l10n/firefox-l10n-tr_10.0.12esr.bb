# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ea3fa8983c858f090dbefe7ab0b4e10b"
SRC_URI[sha256sum] = "2b05d41c7e8013166b69f5d89387760636efc44a23cb30f6dd822ece6442c9d2"
