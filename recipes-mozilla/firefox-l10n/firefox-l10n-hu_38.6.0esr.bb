# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ffa225dc5838b000ac27fed96d51144d"
SRC_URI[sha256sum] = "c5423d6a3f9e67c6ebc5db09befee3bbccf4d9de16f52533a1fa08c22b5f2ecc"
