# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "573d8ca75380fd4a5bae81bb287bb3f4"
SRC_URI[sha256sum] = "a8dfde526878ec3139641b2684b33374b3c8efe2437daa3b61eae55435a241fb"
