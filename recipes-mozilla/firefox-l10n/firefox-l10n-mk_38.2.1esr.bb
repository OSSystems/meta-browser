# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e1ffc30646f180eab48f0f59b1f37715"
SRC_URI[sha256sum] = "b57c5314d1b3824396a0cf6a4bc7d8cb70bc01730443dfa791bb393969841daa"
