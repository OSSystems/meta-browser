# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "28d5371fd65972ad4b88362545da9b7c"
SRC_URI[sha256sum] = "f01ac3cd7c09b8855df905acac57daf053f0e5dbb476f8c58fea23c3034ccedf"
