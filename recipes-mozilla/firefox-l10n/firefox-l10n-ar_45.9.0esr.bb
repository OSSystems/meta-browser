# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "83352f0e5883f6a2e564ebbe3ad51d91"
SRC_URI[sha256sum] = "7d732db42869cc522a782751cf739b1e13edf6483de11bd2f034e21fd6375700"
