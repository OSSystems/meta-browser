# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "17f49881c65f063fac035fbcd418807e"
SRC_URI[sha256sum] = "ffb7d4db11f3fa641281cdfa2eb146971dba5b5c74c0fc84401ee5f5779d6f52"
