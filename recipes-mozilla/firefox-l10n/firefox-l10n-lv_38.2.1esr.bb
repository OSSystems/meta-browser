# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "da470c7f53420628a3331ff8050776e7"
SRC_URI[sha256sum] = "b5b427806e1b7172110b0570fe381bd40486790c415dfe8720343c2a34c41a64"
