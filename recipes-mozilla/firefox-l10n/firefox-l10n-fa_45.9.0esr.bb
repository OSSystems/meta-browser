# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "392f514c2db6bf84251fb8e00745dbe7"
SRC_URI[sha256sum] = "2612c82ae94f471cd131f46875bec4f5af09e9b69aa24c59da6cb3fbd5021e98"
