# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "9810f80352ad8d07d615510ad93c7fa2"
SRC_URI[sha256sum] = "8d5a3ccbba009f415036abcd81165afb744548ec5bb2bc1cefd72be1e0caf0f5"
