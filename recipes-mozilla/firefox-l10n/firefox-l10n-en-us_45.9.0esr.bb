# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "680d46bdffaf18f6a835edc8f82eea76"
SRC_URI[sha256sum] = "e7921b0d5f0f3fc72961e31212053a6042440c5072aafb901bbbbc9e4d910ae0"
