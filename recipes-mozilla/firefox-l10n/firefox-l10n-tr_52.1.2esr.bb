# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6c777052863d9fea62a7bee3dc450543"
SRC_URI[sha256sum] = "e3175db667074c30cea7edf6749760c61988fa93bfd46d6fbfeea2af3bce8119"
