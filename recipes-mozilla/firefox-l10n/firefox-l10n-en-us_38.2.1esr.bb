# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "076e73314f9e24d78dd9eb5ff8f7a7b4"
SRC_URI[sha256sum] = "44e81da1c90cf56e4190145e981c7bab9d6cdc559366c7b707c01e0df84db7a2"
