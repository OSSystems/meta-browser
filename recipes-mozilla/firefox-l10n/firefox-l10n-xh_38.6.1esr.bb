# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "45d19b39d5be375c3817969ebebeb1b4"
SRC_URI[sha256sum] = "56df68f2b0c131632d4ae7a55d6922ff4c65d0332a1ff43edcfe594e78d9a7af"
