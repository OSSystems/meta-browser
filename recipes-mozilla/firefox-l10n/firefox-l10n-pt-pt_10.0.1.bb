# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "85c8075353e0527c9fe3f34e4df22bc7"
SRC_URI[sha256sum] = "648e52756b4c3ff986fe57b915c2cc41e5bc9cb473e16b9a7f272b806eaf9d66"
