# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c94aa3a1ddb50d0f57d9f5d3b1689260"
SRC_URI[sha256sum] = "6c7289473ca231e00036940c87c87a8b1139c289e80a771f9f1b8f74f9ecce79"
