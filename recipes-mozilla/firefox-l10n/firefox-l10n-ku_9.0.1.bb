# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "ad250bf2d35c8cd195ceb2ba882dda6f"
SRC_URI[sha256sum] = "e357c6132168f2e540f6d24c6b6f993c01be4759f9dfb6d079eea9476cd5ff30"
