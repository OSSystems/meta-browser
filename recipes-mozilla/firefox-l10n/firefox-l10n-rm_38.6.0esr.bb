# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4db9c2f5f1e8559ede2d048abdcb0fb1"
SRC_URI[sha256sum] = "7813fc4421fb3c08ec81e60ce955194f9f2a376662262da4a0f320db5caff342"
