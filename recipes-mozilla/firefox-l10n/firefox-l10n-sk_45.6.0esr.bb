# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6bde743217ac9e92c0232a77ab75f917"
SRC_URI[sha256sum] = "97bc8abb6ef48a1a48bdccfc74ea330e6baaaef45bf062916f918018d28e360f"
