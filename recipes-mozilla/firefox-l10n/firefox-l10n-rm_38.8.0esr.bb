# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "75f32f4fca25d483ea7bc6d58196c63e"
SRC_URI[sha256sum] = "ab5a7caef3f9668dada5cf4bbc7d4699cbac36ee13608c351b99fd877f988270"
