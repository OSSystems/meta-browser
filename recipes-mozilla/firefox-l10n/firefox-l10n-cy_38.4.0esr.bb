# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c2c4d3c195cfb900f35c4ed9e48bd439"
SRC_URI[sha256sum] = "cd6d186edfbfb28e9fd1a5629dbecd6f6cff3a664ef4402ba1aa6e78b0bcee94"
