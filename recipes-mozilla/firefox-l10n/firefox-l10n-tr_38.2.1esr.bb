# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0e23be6e06d6fb4bc489dffa377be071"
SRC_URI[sha256sum] = "9f508923bdcd00b802bb9fb6d20cbd69ca87ba441e9119ffb76b243d7ebb78b4"
