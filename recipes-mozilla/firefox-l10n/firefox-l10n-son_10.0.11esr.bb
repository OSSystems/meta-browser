# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b28ae14429ec3c78df05b5c40b808525"
SRC_URI[sha256sum] = "01fe863e1bd6a0d75d7d64663f8550e70501f63454eb3d919e5c7d3ccb806610"
