# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "402b2412a87c468a2ab5c106f40decd6"
SRC_URI[sha256sum] = "d61806e7f8080d3fe3b57baf9448ccbf74fb9a668365518322b0fd2fe67a75e2"
