# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ea6d61cbea040d02257019b094aa44d1"
SRC_URI[sha256sum] = "41983f3463e23851d9783eb49aff5a5a887a987382122942d43edb8c6ca5b688"
