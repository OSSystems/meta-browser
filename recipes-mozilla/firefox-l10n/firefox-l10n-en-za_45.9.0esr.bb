# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "162337e61bb1143796500f813662f4c7"
SRC_URI[sha256sum] = "f056e5da4ba0d569105801b6921db8f8cecefd656d5f09d0a87049a1a752a8da"
