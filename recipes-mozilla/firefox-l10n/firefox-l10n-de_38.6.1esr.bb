# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ecc36b200050f8fbfb35e77808749811"
SRC_URI[sha256sum] = "ae9d6c7500e1d05f7d63d88644573f3bb019521d174fbf662d49e28aaf6170d7"
