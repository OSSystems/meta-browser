# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "284c963aed062fe4c933f2dd69c3b38e"
SRC_URI[sha256sum] = "54ee9948a047eec9827abf0ea62f4f80f963edde1e681f7a3e8b22a518468c32"
