# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dde18b05648aa41e2b6ece6c981ea230"
SRC_URI[sha256sum] = "c9bc19005e8c2bfc705b957b27a5a691a457bdcca0f4d0c65b2ed460505034b7"
