# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db60a38982509666a2202ca513d8cf6f"
SRC_URI[sha256sum] = "bb86e201c5eb5395eab16edfa2ab4453cf2d0a1053a6ef8392ee3da5883e39d4"
