# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "15c9b211dc61bcfca544048e20b2fc64"
SRC_URI[sha256sum] = "c39aeb6943b6e9a83d5f2d499683e8125cbe4a585b3c14bf357664def646cb81"
