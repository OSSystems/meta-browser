# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e30eece2e2141a936eed91738e94aa3e"
SRC_URI[sha256sum] = "97728e96773600e5d5f532bc2683fa2f2e5f2e6995af592b70778784444d4fbe"
