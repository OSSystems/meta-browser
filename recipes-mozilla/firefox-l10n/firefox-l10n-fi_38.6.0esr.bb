# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "42c3a9ba27ee9510620952ec9040f89e"
SRC_URI[sha256sum] = "c574888f1b30a6e360b4b1c1cacd84cbc2b18108fadcbd49ac4ccfd47e924b65"
