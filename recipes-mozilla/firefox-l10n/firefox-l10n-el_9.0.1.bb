# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "5f0e5ee5628eb37550304e88d4417045"
SRC_URI[sha256sum] = "e2ef2203a0eb76d4d2252088b3f7729702ced4732d12a8ab97d72aba46d0925f"
