# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d5c420a2bf622c26c7ff8b63cd91e3af"
SRC_URI[sha256sum] = "eb39e6b9b3bdf360f6282a43895d3ce2bf709770f1c14169fb422322e04dd451"
