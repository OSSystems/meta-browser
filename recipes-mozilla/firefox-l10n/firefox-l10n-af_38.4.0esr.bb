# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4dcd9a161b9342a464db9f96acc88626"
SRC_URI[sha256sum] = "d88130018dfd2909551e1fdf93ef17fde5423218a1bc75cc051eadc828861d45"
