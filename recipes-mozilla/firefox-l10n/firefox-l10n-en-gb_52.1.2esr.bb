# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "16a3500482e810f6cf7d2f325108e9cc"
SRC_URI[sha256sum] = "32c1542b100deaa784cfb1be850d57d2eb336d54c6081f7daa4ae1f5a087569a"
