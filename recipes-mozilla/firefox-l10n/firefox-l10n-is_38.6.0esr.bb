# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0184c33452bd54ed3f64e04aa2127898"
SRC_URI[sha256sum] = "9a13253adc716018e7fa522915c2a9aca3a4d7daf5cb12b61ec77a7df4c2f3e1"
