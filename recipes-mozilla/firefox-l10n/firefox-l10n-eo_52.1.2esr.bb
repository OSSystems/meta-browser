# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1a5133a599ff0e73dc152b70077c92be"
SRC_URI[sha256sum] = "76f6fcddd8c0b405319023bac8af5ff5645e884fcb1f4481222710c1033ee46e"
