# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "87a52ae34c6addc4ac96db55c63d3cfd"
SRC_URI[sha256sum] = "cd1bf9c1e62694a1490ae4b46528aace88fd523f9f8cd51c219fab8d6cd2f81b"
