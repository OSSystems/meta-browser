# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "632de7efcef6e3d31b6b3022b61b3f67"
SRC_URI[sha256sum] = "0fd5795640498f5887b836a974d5392b2f8b83c3e3658587968aa6102aab1219"
