# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b19c280346ef5da619a7b3c20cedfae5"
SRC_URI[sha256sum] = "9f78e0b078724d2f81e0a510c89388de42573086ca999c1a7b98af665761ef58"
