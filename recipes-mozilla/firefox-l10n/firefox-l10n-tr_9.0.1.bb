# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "b761c3e3879bf9068cf65d718fbb9efb"
SRC_URI[sha256sum] = "787b8b4ded7d9a11ce8ec0afcc6910da8bc59facf231036586d201faaea15302"
