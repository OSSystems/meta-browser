# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5a8d6c07e4f6a3d5c4eb8482c51ef451"
SRC_URI[sha256sum] = "0f8b69eb5ddc9b2dd3980f643a0961721efec591c88810fb089e894b8a22ddc3"
