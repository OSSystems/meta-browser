# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9cc0d1c0ebbf69334dd48606d4ad1dbd"
SRC_URI[sha256sum] = "57f7b8740e04ce686d49a4cfaf0364346c5918c12417983ad4d7e9e58f96a660"
