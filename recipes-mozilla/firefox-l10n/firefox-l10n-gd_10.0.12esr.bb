# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7cf6eeba11bee78f1db75d44bd498dca"
SRC_URI[sha256sum] = "62b166368da8b91a7c593801c2fb8c791e0579c6a12685bff5389301b9692a7c"
