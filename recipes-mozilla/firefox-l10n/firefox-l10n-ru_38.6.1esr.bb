# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "53b529fe57cf1b31ecd3437d95cf8ae0"
SRC_URI[sha256sum] = "fb59260748ed9d01ae54454754ed1b897fa92b3970befa31d737773bb1198297"
