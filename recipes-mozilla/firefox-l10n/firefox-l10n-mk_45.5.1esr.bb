# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e9f472fcd76c838be8a5039bc54de7f8"
SRC_URI[sha256sum] = "ce9c64776e6e763f023cf3ac15e6d4463d3bde4ef61829413082269db97d2377"
