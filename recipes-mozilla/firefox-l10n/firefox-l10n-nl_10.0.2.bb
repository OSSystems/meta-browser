# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "cfee821757e3d4e3c89492f6c48a5c26"
SRC_URI[sha256sum] = "f07ab4dd5165eeaa614e7bf396dfa6f4bd74cb316d9f67f158efe7376f3e1b96"
