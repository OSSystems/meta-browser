# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "6a9678a1f59735ae77fa0ca0620931db"
SRC_URI[sha256sum] = "bab3d43683e505f50614c7bf7511c944ff369fbad40593ceac17a2fa9cb23796"
