# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c28c8bdf0d0807dd20e3db34309a4a72"
SRC_URI[sha256sum] = "4b0bbbd5bb310711abea9a347747cea6778dd3e5c01a325023e86a5cc710bb3b"
