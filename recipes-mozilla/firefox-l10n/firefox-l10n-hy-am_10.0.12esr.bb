# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "327f2ea498b08bb119630a23ba81c395"
SRC_URI[sha256sum] = "e0606d14afc0607dc4308aabac6c660146571e4494520fc97158dcd71fdbef1f"
