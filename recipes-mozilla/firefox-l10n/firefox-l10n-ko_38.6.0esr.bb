# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "954c37b5c786e37e73c696e19bf37d9a"
SRC_URI[sha256sum] = "6be4f4e43fed606021d2218ec2cfe3712c63c737692b9116296a85ffe11650c5"
