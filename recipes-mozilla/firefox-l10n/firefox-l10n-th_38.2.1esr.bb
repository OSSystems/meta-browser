# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ed06d876015e36233d1c0fedc7f0fd5b"
SRC_URI[sha256sum] = "a5975df8f977fcfc7e36a2ea53db17d15d1a409f1757922cf02e08895564a054"
