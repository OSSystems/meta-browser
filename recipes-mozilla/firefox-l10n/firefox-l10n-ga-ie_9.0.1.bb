# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "a4effb46c91c2ecb3e3d4de588f0afe9"
SRC_URI[sha256sum] = "e9437cdd8133deb46085e73eacb141e349640ab17c778f182767a8b4af60dc14"
