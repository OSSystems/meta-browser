# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "238bce5de56e71eae984ae3b03673121"
SRC_URI[sha256sum] = "09f2155650ecb5319b4cf2514c7f88582b9926ccdeb2a86481dfaf72cf43ab91"
