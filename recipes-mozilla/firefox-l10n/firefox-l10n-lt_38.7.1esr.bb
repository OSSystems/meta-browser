# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "793e78cf1ab56d52624741f0af46c98a"
SRC_URI[sha256sum] = "e6c4d6219fe9615ceeaf500e3307ea2e918e596ebf302bedf3621e39f08b4b81"
