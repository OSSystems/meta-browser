# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "31fc9941de358a2a9fc82e9e39eb4e95"
SRC_URI[sha256sum] = "59143a40c46c5d891f522e0d8c9ef77528f6146dbef0b125d802334e44c421ac"
