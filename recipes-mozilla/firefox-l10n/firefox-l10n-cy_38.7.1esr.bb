# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3f22de8c0897af73b8d51198f879e33c"
SRC_URI[sha256sum] = "4b23251868fbaf581186e19f20b5fc661ea5f015e769b782470ed0790ab2c25f"
