# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "73eab1c85ccda56b67e383e8572b1785"
SRC_URI[sha256sum] = "245d5150c762c0c7206dd2f8869b2a8a8b734d0b48ece4985d332815ba71691d"
