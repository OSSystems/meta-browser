# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e3e447089663c3021363121f45296102"
SRC_URI[sha256sum] = "8b7fa38d503b146f8536b216c9088ee84d6877ab29c0507e6d4247fd2ebf1631"
