# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "673fb9db9844c53b58543c97d068bc73"
SRC_URI[sha256sum] = "825d25c1d7b7fd15919579e5930bc6d146dd9c39ba31ee544bb78da7ba1a9b5e"
