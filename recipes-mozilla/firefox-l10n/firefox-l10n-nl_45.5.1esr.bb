# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "afe5505cf52a2e46a58d9309646ead3b"
SRC_URI[sha256sum] = "05b4caf7827fe2081666bc23c35626477aabbd21af655ae1ee95d9b868dfb0ab"
