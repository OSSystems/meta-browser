# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0ce7d3dd89c950fcaef10196acce6aca"
SRC_URI[sha256sum] = "abf50e17d78c016d4bd28951c9b0a44785bd727f2b336aa6a1c380f2b115389f"
