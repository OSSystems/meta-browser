# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b7a76a57290c0ab9a286fc7c196e5b8d"
SRC_URI[sha256sum] = "51207ccd5b8e7d57efbf2e18041d37e7c04bcfa72f325b72bff3ffc7f71496e3"
