# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cc6c0a30e735fa8cdf19dced48391d2d"
SRC_URI[sha256sum] = "e988601279701e17ee8b4d93d48620526acc6bee55f10a7e1f663a6f2e85a539"
