# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2d2a5f0fcbc2fa60c805b63a1298ecf7"
SRC_URI[sha256sum] = "c789168594f6575a1127f9e6e9fc7b01516410a9af8dc6c54b3e33539893320f"
