# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "40319a20c369399a1a95b597c50cabc9"
SRC_URI[sha256sum] = "20a6c9f6ffe85900bdc615e7f833586fbc51e49d0a68d46cc637f1af978515ef"
