# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f254271d02739e8b2d1658b5a38ef0f1"
SRC_URI[sha256sum] = "f9b41e8fa739b7c012ca5b4dabc24333688a1798c51f44108096ff27164fbc7a"
