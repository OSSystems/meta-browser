# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "727a5f86c61001d29b2d501a62d93d9a"
SRC_URI[sha256sum] = "82c1559a88593516a357b366d21d41946f2f521946e9e00101d0b13bca1b3f02"
