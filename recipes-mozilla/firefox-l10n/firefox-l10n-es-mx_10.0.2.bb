# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "a06b8bbe3d57474a6e8bbee7fc8eb054"
SRC_URI[sha256sum] = "2f4035c80b7c2b5d8085d3a2a33e7e2e60e064843676b9571d3ed1f358bfeb7c"
