# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "388f6eb8212ddadcfc0f7a20adb2a4a0"
SRC_URI[sha256sum] = "9784161ef50ecf8a0037901fc867938575c2fc8691f1726bba303efd6b9be776"
