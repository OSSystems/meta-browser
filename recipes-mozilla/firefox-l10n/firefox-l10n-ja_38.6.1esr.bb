# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "edebdfda81254052974ce530eff856f8"
SRC_URI[sha256sum] = "31f0819188bffa21bb8e460f9f93238cca32c882fd60e0f545e382b0de45be2d"
