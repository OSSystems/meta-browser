# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7d8482919d5c6ef6965c442bb84d0e62"
SRC_URI[sha256sum] = "4dd4676e59048de312bd3fe6084663281076dd90ab63725b2bdfe3862089b686"
