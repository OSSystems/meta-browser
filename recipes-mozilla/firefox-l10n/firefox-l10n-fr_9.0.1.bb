# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "a872f48c660aaf93ab73ab02015b6f56"
SRC_URI[sha256sum] = "199dde1020f4814d491c918fee1216e76a7baff71c27b419c7ce30513bb44242"
