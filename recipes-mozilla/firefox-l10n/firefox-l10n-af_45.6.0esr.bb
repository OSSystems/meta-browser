# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "664b0b5c3a92f92d2f3d0641b1e69f27"
SRC_URI[sha256sum] = "38726e81586b9e76dcc0e363ce7ff8a0f8499ac75d7111bb46d32672f792041c"
