# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "22032937d1dcf8abd7d562bf19f0d0e5"
SRC_URI[sha256sum] = "66d4a337278df1a72f14abcca57be904cb9b53ef36076e9f62f724913f995ae3"
