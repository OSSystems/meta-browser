# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5787518f1a1590d1344393df8332a667"
SRC_URI[sha256sum] = "13e71176b8ec9d27858aa9536e3c702b1e30b700f9e68016beb78d29353cd838"
