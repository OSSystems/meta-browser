# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "af88d2a3dd602bb7b84357ecaae0548f"
SRC_URI[sha256sum] = "28942b5f6d1485e3aa6fe2852b70c5fd671db662f02c125456f38d61a44f1e9a"
