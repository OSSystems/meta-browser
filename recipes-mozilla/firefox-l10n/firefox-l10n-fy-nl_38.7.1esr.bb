# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c42bf12ae3b1c8790de1c4bd1a66b3c2"
SRC_URI[sha256sum] = "2dfe6582cf7f4b38bf7ab1ba4d929764144d9fe0d9981f28a0371a3c201a6e10"
