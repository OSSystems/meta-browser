# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "47e01a95dae8dacbc39c36106abf5e11"
SRC_URI[sha256sum] = "c373c4ab74165e94bb09730741bbfd3b88c54635535500798d403fd00b186dea"
