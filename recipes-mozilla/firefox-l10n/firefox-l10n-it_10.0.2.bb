# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "42e5097e7ac595f104e295039f2868b1"
SRC_URI[sha256sum] = "6d2556c7e4c8bb4fb1a710dce95589042dcae1866e3ecadab0f71a82af8acc76"
