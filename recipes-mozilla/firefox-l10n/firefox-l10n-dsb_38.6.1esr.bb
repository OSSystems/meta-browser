# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7003bb9f2e14e1d6943fc3f58c033548"
SRC_URI[sha256sum] = "03ea2abf756e689dcbf43742af475410aede92aebef2c63e5253a68f085f0d1d"
