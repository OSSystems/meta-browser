# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "049bc6d40c88486f1b0c848a4783810d"
SRC_URI[sha256sum] = "4fd293bb1949a4e66af02842be18d848cf99962e4f1371ff01f7c87ac42fadd2"
