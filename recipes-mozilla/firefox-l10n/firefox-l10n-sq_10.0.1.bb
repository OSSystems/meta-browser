# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "48f7fb92270ffe9d3a35d45fbb57fc8f"
SRC_URI[sha256sum] = "446eeac115ab23355e5a5fa913484ac42d558b2a3c7b1cbcd7c83e00518f8153"
