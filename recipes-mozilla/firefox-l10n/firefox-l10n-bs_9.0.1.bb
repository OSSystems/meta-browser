# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "36df740c09663483a263e5248ab2a298"
SRC_URI[sha256sum] = "f989bade33cf71c49b2679c18211e9eae0e2a60008e66efbe156b5109e95bfee"
