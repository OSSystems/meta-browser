# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "4f2967d89a5a944a48685d88717dc125"
SRC_URI[sha256sum] = "34705c150939fa8e80d096209ec358c3cb149dabedf4fdb6fe04b1fd2bfc3c77"
