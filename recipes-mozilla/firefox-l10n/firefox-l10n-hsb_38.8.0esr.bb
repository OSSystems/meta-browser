# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ac207b0d88e8cf0ffca1a2dc03c246e2"
SRC_URI[sha256sum] = "aa2c1b76ac04123fdfc69d5a1f456e78501c4a8e98faaca68858679be48b6ac9"
