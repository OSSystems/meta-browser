# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "31f5800936c2b7b1f104e5c4013bf265"
SRC_URI[sha256sum] = "02ac98674f658a239c264b0631d1339e8c454f444fa9261db64f250033eccfac"
