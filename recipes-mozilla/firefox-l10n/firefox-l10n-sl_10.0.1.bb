# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "f64a5f4767f451862ab132b83aa585ea"
SRC_URI[sha256sum] = "3e5af9a4da42c8d5d50a6d942c64191dbb8286e08eda44120e41c4d78f842e34"
