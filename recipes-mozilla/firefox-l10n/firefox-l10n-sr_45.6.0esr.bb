# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7a87639bc54a52a123780b6e322bf1d6"
SRC_URI[sha256sum] = "3b590326481cc5455f8566087afdaeb44e398e15e86f1cf9d023c67070b921de"
