# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ad1276b39d6bef74c4e9f73aad118e2"
SRC_URI[sha256sum] = "1cd26312aea78e9a346443e137a02d455cf844f81bd3b4881c53cb099ba791f3"
