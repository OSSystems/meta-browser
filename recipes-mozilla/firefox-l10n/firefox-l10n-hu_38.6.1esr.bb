# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "df94bceba9b5c37efe85f4c5c5190782"
SRC_URI[sha256sum] = "dfa1bc4728212bc0cd43f71af102d6ab665dfcfea879e77cf77e2518e639bb46"
