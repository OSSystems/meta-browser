# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "53fd480e6758d0e4e2bef061b3456058"
SRC_URI[sha256sum] = "3c47fed453e6c37129a0c578b01305127c6b612701e5197662d8148530df2fea"
