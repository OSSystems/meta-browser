# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a5b5488979696ec13c62dabadcf93eb4"
SRC_URI[sha256sum] = "9b9d0bee17df92ae143e1894f7fa3b628495c43263589a13a0c5b043c61a3ee3"
