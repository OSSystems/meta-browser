# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "14e1cfad168a0a3ed575ef6918deaf9e"
SRC_URI[sha256sum] = "adfea7204e49f629aa1432364cbe876b2a40b339e4279fa9801d650d17920aaf"
