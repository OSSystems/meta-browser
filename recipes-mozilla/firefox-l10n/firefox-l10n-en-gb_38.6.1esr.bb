# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f7f39583731c723421f0b4f97fb0eb0d"
SRC_URI[sha256sum] = "e40dbc5cac2eb0d0d399fb853166cc964011f9f49e1a48424ac527edc3594bea"
