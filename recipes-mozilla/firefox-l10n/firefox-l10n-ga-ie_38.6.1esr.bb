# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d53687a5ea3085aa4a88ef69fc59e86e"
SRC_URI[sha256sum] = "db2ea2489a71b80b8ee759ff54fba3d44f8181349853aed2a3c94f48fc85676b"
