# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "bc6aaf0074c94539d12df8f537ed9d87"
SRC_URI[sha256sum] = "ab7dc6ff2120c388b008514f557cc46f5fe055b651920d06d2226084b66c2086"
