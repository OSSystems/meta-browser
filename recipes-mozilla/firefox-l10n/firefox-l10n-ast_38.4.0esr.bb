# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3f56509e3f22226a9307e2e005e64eb7"
SRC_URI[sha256sum] = "895e06fdf8b0bd232fe89fb5254b9c2b114ff7bd8257a3a93062ce0549a2416c"
