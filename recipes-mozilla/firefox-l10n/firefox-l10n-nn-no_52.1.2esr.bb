# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f6d906966b56de0780725f1f58cef630"
SRC_URI[sha256sum] = "cfc13641db024fcfecb9f056ee646974e52bffe3936f833377749ceecc93ce09"
