# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f744275ca8cbb8d8608313f4f9fc765c"
SRC_URI[sha256sum] = "dfeb7ef5786b400232b1672a359a2c12d6d9fabafa421b9f16c92b01da14670c"
