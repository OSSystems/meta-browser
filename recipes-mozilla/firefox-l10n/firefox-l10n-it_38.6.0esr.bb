# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cfcd5f5d7fa00b7b837dda78719f62d3"
SRC_URI[sha256sum] = "3e78f0900b56104b61baab01e636256e8cd6d1241f142e2957d566b86ea79ba0"
