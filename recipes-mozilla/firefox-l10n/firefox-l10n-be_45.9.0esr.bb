# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7794466d967c180fd5306ddaca6d06b5"
SRC_URI[sha256sum] = "7a5a316926251206f9a325906cfe18c02ca749949c5180b36bef803a4ce646dd"
