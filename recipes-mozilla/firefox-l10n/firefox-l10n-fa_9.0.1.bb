# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "a4a1727700ec03face583552577a5567"
SRC_URI[sha256sum] = "a459446a45488fc3ee50a74b08836b68e4b3ecbc732e5a665caf80272e5d94f9"
