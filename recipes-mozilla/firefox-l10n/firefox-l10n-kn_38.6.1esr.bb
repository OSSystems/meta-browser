# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f7a76cb1c55bd58a0590b6fb6f02660e"
SRC_URI[sha256sum] = "58c5cefe6ba8b23a64f94e16bc74b9945d1252a5da20f312af745720bd2c39be"
