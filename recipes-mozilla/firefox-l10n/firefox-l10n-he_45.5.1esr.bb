# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cafc48768e15fcbcd01e6b1dfc1838f8"
SRC_URI[sha256sum] = "3e359859650e3bc2909954efbf4dab9e38b007329cdbca3ca57c872cb2b29c4c"
