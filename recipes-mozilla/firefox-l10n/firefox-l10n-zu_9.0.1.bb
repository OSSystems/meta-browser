# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "212c34138e9e080cc8db196da9b0c507"
SRC_URI[sha256sum] = "03ef075dea3dad6f653fa65723ca92a5056b9dfd795f83b5a1ba1b07fed75835"
