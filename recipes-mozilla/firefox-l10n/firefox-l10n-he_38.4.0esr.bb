# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dd7b5755979620b86b5f1e9937466e35"
SRC_URI[sha256sum] = "2fafcb398ae4ad3aab1498fd22f8ab713f966f96753301fc2385f0c5d0ab1568"
