# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "939d58242cd50b247e6293705519e955"
SRC_URI[sha256sum] = "2f58012a0f4cd304a920392674096db784bceee5fd5b6e2766130836fe080d55"
