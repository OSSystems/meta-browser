# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "bb82903931ed1fbf8dac4e3b473a4c61"
SRC_URI[sha256sum] = "5f338afec8b7d82b38e806cc62dbe4a8543d81007ebba9425c30a5065bcc65fa"
