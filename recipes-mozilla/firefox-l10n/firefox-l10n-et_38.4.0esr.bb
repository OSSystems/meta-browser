# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4e75622a5a8c06cd40bd50d62517637d"
SRC_URI[sha256sum] = "c0ac4b4ef61e1ca128b63fb88410788c9aaf54e0c6a8012be379d093f465fe07"
