# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "311662c41432eb1a8cdb25b48c4f5fd0"
SRC_URI[sha256sum] = "fe39cc3c54be8647bce103e6c0f04e8ebbe842a65e3c916aa82660f1b4a1cfe6"
