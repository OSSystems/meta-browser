# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9b01c9afb70869b6acf3f4fe05591468"
SRC_URI[sha256sum] = "b0781182df3a057e95cf2397b686baaa8c625bf34044b669fab213d3caa0c7ed"
