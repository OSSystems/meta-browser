# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7091cfd3856a3985ebf448e1e7820242"
SRC_URI[sha256sum] = "6224c7816d0b95d3b07a59a1ebb7707f3d078d2a806e9f565c27a42df3743447"
