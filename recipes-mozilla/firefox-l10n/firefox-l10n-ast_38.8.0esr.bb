# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1150ab817dfc467bdbcb8dda84351647"
SRC_URI[sha256sum] = "fd745a4b2aee7a85d8300abe19b96f5486a3d1a1f782bddbfc1bc8316d5d161c"
