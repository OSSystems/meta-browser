# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ec3cff5e2e57ca3a68f878731811bc05"
SRC_URI[sha256sum] = "6af56a87ca9a55587d611543cfa7a5387338293b3f3a9608a1c6017920719b74"
