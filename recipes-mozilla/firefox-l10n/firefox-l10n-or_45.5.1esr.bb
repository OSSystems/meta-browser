# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "754b73500d10509cf567689762676f0d"
SRC_URI[sha256sum] = "108b3ee326cb80395970661a8fba4e24e6a22b659cc3223f2c7492148e05dc7d"
