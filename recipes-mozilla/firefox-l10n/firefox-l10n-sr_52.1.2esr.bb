# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c9534924d7cf06ae48faabd895e84265"
SRC_URI[sha256sum] = "5f3db7014bf08c80cf45adfe14b36ac0777b34497be729b0495a88b708df5953"
