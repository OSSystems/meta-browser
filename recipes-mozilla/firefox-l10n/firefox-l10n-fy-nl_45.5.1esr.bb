# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2c807971deac4d329cde2a05978322dc"
SRC_URI[sha256sum] = "37cdf7d49c7b0bd74f13cc5343146bb2f113cd3df22e99ec352aaa89dbcf2938"
