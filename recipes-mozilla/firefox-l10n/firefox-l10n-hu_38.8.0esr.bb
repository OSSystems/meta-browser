# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b9893eff712581c7235f56954537ef44"
SRC_URI[sha256sum] = "30e20442f6997d7d1a45a6c8cb44f87c09007605a2a06c2f5cbdf2ca03cb5e80"
