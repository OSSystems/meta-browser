# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c179ce49c9683edf8b078e468afff2ea"
SRC_URI[sha256sum] = "a57a326d2820c9542fdaf023fa2043f1de10f8bafcf313ab468e9b122166b352"
