# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4ea673f2cf3dcf3663924d03cc8da384"
SRC_URI[sha256sum] = "241c60ceaaac71783bb6dfdde51876130ccfa09360499a0da8dcff56251a819d"
