# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a17e04b45b12297a9eadf5d9119d29a3"
SRC_URI[sha256sum] = "cfe29da7a6308836ca25531c44ab458e3e1bb484d2f743655d2157a31ef5d98e"
