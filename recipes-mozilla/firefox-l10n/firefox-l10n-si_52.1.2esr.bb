# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "70d0ea9dbd1eaacab87bd09bc4101bc1"
SRC_URI[sha256sum] = "e615af562970d2066ce665f685b9e0a9695a98d9a3c1e779b37941519f618fd4"
