# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "075820eee6f9f63f93824875ae5ac47c"
SRC_URI[sha256sum] = "cb330410d3894b7b786be927d94eda5f9cb606682ee5cd3ca44eaed5a5a36dae"
