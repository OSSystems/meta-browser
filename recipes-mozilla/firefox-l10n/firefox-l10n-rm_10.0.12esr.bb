# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d4f2b425ed92c865cf2460b86248e3b8"
SRC_URI[sha256sum] = "9cf6980f8db99b1994c0bb93cb98b52022fe3acbb1ca669cdd00adda501903f9"
