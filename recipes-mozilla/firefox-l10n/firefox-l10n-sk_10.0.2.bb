# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "6fd115213b097ac203cbfe5988e394cc"
SRC_URI[sha256sum] = "8e5c79ef138bb89b8c35120bf44a38bfc8ff8b9b73d1ecbc839c05e7ea8139a6"
