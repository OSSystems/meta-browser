# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "02d60eb662b08a152110e44387137fdc"
SRC_URI[sha256sum] = "7656689234fd8dc4a72fad8ddb0e440d59fd4c2d58babb3e806618adedba601e"
