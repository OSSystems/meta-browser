# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b4d899b640e336ef447664849258eda2"
SRC_URI[sha256sum] = "400e4b8e3469f1a01c93686c0ad2b64bd2bb3cffcb673b959578b8690bb36d26"
