# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d27f645d7644598ee16a677f6c6c8877"
SRC_URI[sha256sum] = "16c444c562ab9336558ed70c3da71826c06f4f4660dd394cd5150034382e3232"
