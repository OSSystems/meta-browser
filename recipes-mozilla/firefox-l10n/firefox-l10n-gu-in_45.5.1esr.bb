# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cf52916f39436ff4a09e06f82cbe30a6"
SRC_URI[sha256sum] = "ef94734a82c95824408e2a94d0e3c0b72fc6a6172eaf0bc455404159a28ea8ac"
