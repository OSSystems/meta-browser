# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "1c0072d639560da4d21a563fb0ee2d7d"
SRC_URI[sha256sum] = "6f32259a0e8da61b0c80a7f05a0c7e495121644b57cdfbe8972951961766b468"
