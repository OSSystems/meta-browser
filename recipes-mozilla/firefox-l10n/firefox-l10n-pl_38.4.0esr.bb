# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f6ddaabe65c9824d0afd5a3aba2c51c1"
SRC_URI[sha256sum] = "cd5d694904802f1aa51d84390423f37500bbe6d2864e47bc0e09d2bc19a2c54d"
