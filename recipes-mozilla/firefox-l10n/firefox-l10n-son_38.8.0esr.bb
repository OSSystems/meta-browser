# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2f9564da04d257bb6749cc8f2dd2d7dd"
SRC_URI[sha256sum] = "4b1d59d32d2f7a5d59facd72d33856fb2730b670efe4665575f93af6ae44d6d8"
