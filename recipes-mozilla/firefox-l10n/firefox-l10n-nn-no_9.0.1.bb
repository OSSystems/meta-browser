# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "8367eff7d1e479bdae3e77c53b14e1eb"
SRC_URI[sha256sum] = "4bf63c9fa00aa683ce4ab57c520e77699b9f5bc80a8b07f1d7908692de319fa3"
