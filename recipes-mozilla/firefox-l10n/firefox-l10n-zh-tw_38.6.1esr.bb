# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a69f3ceb5bc6d1a5064f4919586a0187"
SRC_URI[sha256sum] = "740f7a7933fc624216de2c84492608941ac2aaa228b666cd55b8dbcbdc147e43"
