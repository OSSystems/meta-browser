# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bb4ea9e3e29cc553967fe9104499d548"
SRC_URI[sha256sum] = "3da71382a7b258a52972ded1993322ba620042703616578b6bcf4da60553b5ea"
