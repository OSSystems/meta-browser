# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7a281ea8a4c36de891b9082f24523edf"
SRC_URI[sha256sum] = "c996d3affd0ee0238f86438eaaae7cb9c3512d1aef1e59f170dacb3f35c49fe8"
