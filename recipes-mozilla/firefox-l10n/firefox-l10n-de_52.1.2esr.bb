# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "be89bd9d585944d83a5ce3e244de11fa"
SRC_URI[sha256sum] = "64cc453ecad956f94c847790c1422483972ce6b9a2dcc84d91e7877f2e45e139"
