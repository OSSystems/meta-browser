# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "dee12dd1499ca5b14cb8f1518b007a8d"
SRC_URI[sha256sum] = "abe57b3712ac59f7585c55f899dd068e98bcba7a87c32765939ad54f76afe1cd"
