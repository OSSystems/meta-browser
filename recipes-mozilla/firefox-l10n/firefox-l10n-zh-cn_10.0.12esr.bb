# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "198b459a7b52d4a7488a7e47b1231f5b"
SRC_URI[sha256sum] = "229e4467145b3f44b0eaef711e1c79b60aff5cd48691ebeb5d73a171d911e3e9"
