# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a9e5ba044e1be63c712b4918eab512bb"
SRC_URI[sha256sum] = "f1b47a7c848a1d25f5bb3744497a94807e550c96e2ce34f06a07055e0eb5879b"
