# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d90f7c7a0068aa535824a4a23195c537"
SRC_URI[sha256sum] = "5f2e8226cbe93c1f7082b21725bd87ca66ebd20f2429e7c65ae43490eeb5f447"
