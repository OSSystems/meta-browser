# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cd6cd83d6bed23f2b117ea0f5a968690"
SRC_URI[sha256sum] = "4e3bd7e6a26a636e031a9afefcca6e54ba2a2c8ad5435d3471a9d41267dc3588"
