# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1c2f216e9277813438f3a74680059350"
SRC_URI[sha256sum] = "320c41dbdc50cd778bb524767306323b29c33bac64c3a28bcc021a72e7b175b4"
