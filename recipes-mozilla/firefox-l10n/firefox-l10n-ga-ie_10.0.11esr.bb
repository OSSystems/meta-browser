# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4b2f6454f3a7094882afc0e3ab494bad"
SRC_URI[sha256sum] = "33cc30bf1b2a4bc028db85eb83387a393c8e306f703b1b6e2b282e661d71f584"
