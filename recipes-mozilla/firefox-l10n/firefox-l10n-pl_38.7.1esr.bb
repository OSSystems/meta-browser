# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "57013b4d8b28f1c468f8e7fbdc25260b"
SRC_URI[sha256sum] = "126d7277b112cd5e1016e970dd966002a00c1bcc168ebb076380eba0b93b8e9b"
