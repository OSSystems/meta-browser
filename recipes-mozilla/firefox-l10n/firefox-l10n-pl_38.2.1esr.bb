# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2a87ee81792fe17e0aaefbce043fa9b6"
SRC_URI[sha256sum] = "651bdae9f95b09fa28db0dc6c47aec3271d628d2ba508797750a5dfbfdb6af8a"
