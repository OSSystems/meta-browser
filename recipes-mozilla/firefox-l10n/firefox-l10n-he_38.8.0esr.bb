# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "55ebd98194bfe9790dc5d3143feae78a"
SRC_URI[sha256sum] = "41b2868d6b3c656984f49ef4c983789adae3e2930cbbc1b307b329364fa43aa4"
