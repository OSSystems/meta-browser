# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "59e0b08e13cd121c0ef98250a9de177d"
SRC_URI[sha256sum] = "e4cf1401a5ff7f5f838862913e02b51c38157d7456d940d346997542e97ae0eb"
