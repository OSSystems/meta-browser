# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7454d404a0fd129dc26ddda889e18c81"
SRC_URI[sha256sum] = "294d298024e333812504bbd269f104ac362e32f5b71b4bcc21591acd05cb52a1"
