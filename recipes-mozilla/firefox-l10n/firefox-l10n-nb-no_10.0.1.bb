# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "26f06545a45d3250d217db18beeb09e3"
SRC_URI[sha256sum] = "f546cdcc2ff277253c799838e07f66fe3df7198ca071b77ccb4c123b5763ea2b"
