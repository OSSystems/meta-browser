# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "25f9482a49e64a8bc5653d6f9680e50b"
SRC_URI[sha256sum] = "162285aceb265fa4ac2bc00437e199126355d3d9680b9c88e8764c00a5b2e1f9"
