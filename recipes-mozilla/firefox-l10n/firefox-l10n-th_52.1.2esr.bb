# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6d39117094ff72a2057e605524049d82"
SRC_URI[sha256sum] = "7a483f1131f5048e8aa91208aa7553140a02679d510d5bcb2038d32b84f416bd"
