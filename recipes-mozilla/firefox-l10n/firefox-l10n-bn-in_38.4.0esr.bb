# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fea75baef297440280c1fd76106df050"
SRC_URI[sha256sum] = "23e256860312a7fd7287fb9734bb4cd23a054c7658ba50d0eb0a0aa59008ed0c"
