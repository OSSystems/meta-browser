# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "78f717e12a170b3f6ecf1e6cb5fdc86d"
SRC_URI[sha256sum] = "74935811d24720241412be814e4de91b2b6dd027e2bf9072ddc2ab4e03a59c77"
