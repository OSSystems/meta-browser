# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7f497000041f4432bc9e7b05ac20e64e"
SRC_URI[sha256sum] = "125890d7466872240603261f4bf653757cff2d39c0289b9aae4fdff8f92a42f1"
