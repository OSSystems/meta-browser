# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "1ee1656e08c7cfc4b237343a11dae0d8"
SRC_URI[sha256sum] = "330fe9a49e28b8a183bbd9d9e7d9d9cee2da654b2995bce3579312eee0da299c"
