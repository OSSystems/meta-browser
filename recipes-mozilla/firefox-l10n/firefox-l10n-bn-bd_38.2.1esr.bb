# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "618a629f13f44c171f38ec16835699bf"
SRC_URI[sha256sum] = "8acb41f8dce61a494f04e2d3f43eb0a23e7f21179928b803d6f0fac42ee1b4a3"
