# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f605765c37d87a661f2eab1e1e5fe267"
SRC_URI[sha256sum] = "63c1da0d3154a93224dc259016036a54b93452b2b0338f8e5d30669af868d956"
