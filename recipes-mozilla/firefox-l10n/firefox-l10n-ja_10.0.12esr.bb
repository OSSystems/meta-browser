# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5ab9664966f502711f3703a60896a971"
SRC_URI[sha256sum] = "3b2e1008033f8e80c135e4f7ee9cd96472be87d7041078cf99575e37c29caa12"
