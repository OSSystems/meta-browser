# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "46a980e81aa7b56e12604474a1b6061f"
SRC_URI[sha256sum] = "8135fe98ac41e348624510020b243fc256b24a47205dfa81d35b3d86b0efed28"
