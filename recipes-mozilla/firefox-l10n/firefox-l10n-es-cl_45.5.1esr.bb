# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ef9c5d3a615ffe4b2159ce99bffdd65e"
SRC_URI[sha256sum] = "ef9c2ace7a74f1f9fa8ffd2f7af6dcdf6f1798b799be871bba6242b8ce078d74"
