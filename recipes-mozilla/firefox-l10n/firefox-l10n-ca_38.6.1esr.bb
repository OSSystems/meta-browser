# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6c8992c5797c44b6cf7ea7dced1a63a1"
SRC_URI[sha256sum] = "136c1cfa8561f73a551bebc19ce22d97203d46a6569d0bb28c26477b6f201dec"
