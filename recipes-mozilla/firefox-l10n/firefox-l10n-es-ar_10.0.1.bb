# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "a09907dfcecd6ec3d703245d3ac22b56"
SRC_URI[sha256sum] = "1eaa96672473ea0805faea4c2111c38d9e61d637b89068ef05f4577b1a3a752a"
