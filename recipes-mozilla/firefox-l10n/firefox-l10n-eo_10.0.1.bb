# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "19c1f78f14e6bb152022ab48700f82d9"
SRC_URI[sha256sum] = "dcd2bb4b442b20aa29e7672c76b14186f576cc785cc36f695a82741c687fdb01"
