# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ad5d1ee738d92d90c66339df464352a6"
SRC_URI[sha256sum] = "2260adecec6b2a7b117112cb84c389dbeabe5b02be617442c48b29e3ea6820ee"
