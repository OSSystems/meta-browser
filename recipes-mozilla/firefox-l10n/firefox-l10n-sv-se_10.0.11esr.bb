# Copyright (C) 2009-2013, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "c90b91251e08f822f8105d0a8921a72b"
SRC_URI[sha256sum] = "0e35b899fdcd77a00a76833911862079ea2777f705da904d0b7693d4a1e7958b"
