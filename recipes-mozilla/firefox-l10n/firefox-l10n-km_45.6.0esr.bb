# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e575ecd427c65bd32034da82f76efaad"
SRC_URI[sha256sum] = "00ce78af19868767ab7e09f1b77bf765b7d9935424a77b6858e149163d3b495f"
