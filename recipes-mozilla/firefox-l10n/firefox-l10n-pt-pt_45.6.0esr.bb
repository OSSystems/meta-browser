# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b9beb3e4b2544d866dc6e841bdebfe28"
SRC_URI[sha256sum] = "8e9ac6965d6508d2d9c88f8ff86360bc192aff55757f4c10e767b7337be4a901"
