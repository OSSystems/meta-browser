# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "849ccebe1734608daaf100d76af642af"
SRC_URI[sha256sum] = "b6d3c5d340c5adad2859d57ef9879d70b515f03da07006152e78e1d84ed9210f"
