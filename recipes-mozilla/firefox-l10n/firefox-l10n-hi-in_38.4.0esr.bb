# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5514e3cb8d61537ba69d981df8ddb529"
SRC_URI[sha256sum] = "c2b5eed1fd8ad921f79feaca0ad43ac969e3171e8d1d579ae99c2c1c17202379"
