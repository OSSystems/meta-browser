# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "934cc67e2254448c384292be6711ebf8"
SRC_URI[sha256sum] = "a9ba7ba490dfd33458d269d6140232d1ece1acedc170ed67ba1f995b3e91dd14"
