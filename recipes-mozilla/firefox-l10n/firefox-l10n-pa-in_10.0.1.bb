# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "512da586d066aac6e8edb78bacb2a088"
SRC_URI[sha256sum] = "6992f5a16db99a510cb71fd308d5ebe8cf7ae8a0fc92a842b8f7e7755bc20d49"
