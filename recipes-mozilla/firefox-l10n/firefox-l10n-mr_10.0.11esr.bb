# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "99a341a891a5ab9b9630486c1440d104"
SRC_URI[sha256sum] = "f10a7722375b3ec12065beb08ddd0c1da87e6d6bce92463a7ca15765d54d52ea"
