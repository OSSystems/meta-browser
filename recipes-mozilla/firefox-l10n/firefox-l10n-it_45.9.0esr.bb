# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c81ab042166262a171f9231ab0a0cf4c"
SRC_URI[sha256sum] = "e5c0504c5a1fd7f4b66a21f635a55e52c09862b457f21a829f67500e86ea3787"
