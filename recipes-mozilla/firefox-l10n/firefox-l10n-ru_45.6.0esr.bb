# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "546d3969e217005cf4ccf4239c76ff4c"
SRC_URI[sha256sum] = "c3157ddf5bbdb1527f1aaec459a5f16d10383ad077e2b1ee64f5f1cee6b9367e"
