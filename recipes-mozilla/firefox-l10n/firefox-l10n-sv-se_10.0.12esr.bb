# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "851871dc4c8f5a83cc4cf98ff6e53e08"
SRC_URI[sha256sum] = "b8c52caed67af9850c4b54d1ab8ab84a984d361c1531260d6560aab23b002553"
