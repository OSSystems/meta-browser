# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "68615a0e0b3578ca26d200ce82dc4162"
SRC_URI[sha256sum] = "b18721f0e3ff559201179007b6e2a4bc52528f5d4fd4b633472456a2d9394526"
