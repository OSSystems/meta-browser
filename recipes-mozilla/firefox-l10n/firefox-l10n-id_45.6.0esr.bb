# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7075888ab45d01cc7576a205078204f6"
SRC_URI[sha256sum] = "8460beaadd76ca321cab90a19c62a08ff8fe3f4e0d7686af8a1da491b654195f"
