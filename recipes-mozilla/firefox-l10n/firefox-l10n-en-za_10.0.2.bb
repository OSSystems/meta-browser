# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "56644b8637d12ebbb465baefee45cdb0"
SRC_URI[sha256sum] = "e64bee6d33633bb79111b1b3e5196adaf6dbb7c525c51146e17cef7b348f2ab5"
