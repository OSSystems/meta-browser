# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "77e98b3925c53e04d5a28fed0210b40f"
SRC_URI[sha256sum] = "b7b1eb46574c2de9540c737b8e321ffb6c618b7646ff685fe6225d92dadfabf7"
