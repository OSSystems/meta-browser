# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "75ec28198ce998e30b14bb7711d8892f"
SRC_URI[sha256sum] = "e07ef11f7e5f0fc0f5ca6590d3561f8c7cc55391cf68f31e3cb0a29209fa802a"
