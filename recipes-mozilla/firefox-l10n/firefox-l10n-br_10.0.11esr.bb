# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b14a15949dab8dcfa8cf4c650ab7f7ce"
SRC_URI[sha256sum] = "2ca127fc72121b42cfa879bc83614041388da802518668c16511b9d252c9f8a9"
