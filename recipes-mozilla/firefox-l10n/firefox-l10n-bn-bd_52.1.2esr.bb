# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c5f78d5c8be45652eac1597ee8c75178"
SRC_URI[sha256sum] = "a0c96291353229cf7a06492eca051f065bf749598e1d1c1ebb3e65740765fd4d"
