# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "7138b05e9ce85d4aa81dd8b138fb36fa"
SRC_URI[sha256sum] = "a61d551a818fc9f0d5f44764ead7ec39d29a170c8f9459758e17584ac4b7e939"
