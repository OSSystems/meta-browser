# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3045d84487718f294278ca797968d5ca"
SRC_URI[sha256sum] = "366a0dd2e0f362675e9dd7d07b8bd568b80dd85ec52f5f2f48495cd96b04e86f"
