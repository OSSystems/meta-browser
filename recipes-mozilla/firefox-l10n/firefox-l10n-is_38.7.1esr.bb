# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "527f2b13d3bbc0a6cddead02f1d06216"
SRC_URI[sha256sum] = "4e4d5d646d985da2f1c2199919edfd123153229109137aaefee806d7aadb6136"
