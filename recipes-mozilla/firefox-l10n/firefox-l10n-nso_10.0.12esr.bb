# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "033bf193c4251a1d3a333ee781d65b02"
SRC_URI[sha256sum] = "3913b62c517495eb80f15d47d0a8a27db3d42031ebdeb8c9eb6e8af0a05d5518"
