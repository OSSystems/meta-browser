# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "777f7f0329210450ebdc79e6dad363e7"
SRC_URI[sha256sum] = "bf1fd7170359bf1dde30bbb6e67df575ee7ac26bd26d2d3627c12688cf689dad"
