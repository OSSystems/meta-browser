# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "82d16693611620c4ad3334354762d9c0"
SRC_URI[sha256sum] = "f7ef3bf15aa344c29aa2fe135dbcc8f747891db12024d67474c1888a5782fe9e"
