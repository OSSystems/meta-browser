# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2fc7ba67f076f3e622b54dec6597309b"
SRC_URI[sha256sum] = "b1fc4b5bfcef5f016170ca4f5e1cc1585364175a0f4becb0f582183a5cbd611b"
