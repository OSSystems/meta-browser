# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5b6eac8b4e0a91ae79f71383d251dcb4"
SRC_URI[sha256sum] = "75ef6f5fba0b8174ce1d6415579b57153bf60551e89c05632dea43e5a6044a96"
