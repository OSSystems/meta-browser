# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0b74b2964b44555dd94945536ce57f15"
SRC_URI[sha256sum] = "18a012130ca0501a6ce700639d4223837738886a1cbd70b5573011c3769a9c54"
