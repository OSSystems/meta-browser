# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b3704d3903ac6f6d29f5a9561006685d"
SRC_URI[sha256sum] = "5004a06d292ec48b7d09f95396d89c7d45a9307f102b9cbcefbd08b7b296ff80"
