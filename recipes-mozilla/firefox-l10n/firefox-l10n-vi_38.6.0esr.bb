# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3bc9ff4f2b90a43a8c9fad3b506e35ee"
SRC_URI[sha256sum] = "3c07c24f533e3eb27f3189cfa384ef815a55cb8d160e706e0506f9d676a9ca9d"
