# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "987cdb03a568ce28195105d4b808090b"
SRC_URI[sha256sum] = "0b2752ae75b2306d5b01731cf470cc02da75b759ac7fd4b0bfbad76e85214b50"
