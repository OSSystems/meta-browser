# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "554072868ccd43279d1701f660c343fb"
SRC_URI[sha256sum] = "f498644ec1cb0eb653f009391b9a33405ba8acc8e54abbda7848f712e70138d7"
