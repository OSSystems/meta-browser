# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d1ee568d8cd9c87874a79793213027ef"
SRC_URI[sha256sum] = "f130c735897f87788add259808b1ba63597c563d16e13718f1c8cc252435afdc"
