# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7f56b9af9523ff1e23cb558dfaa6aff7"
SRC_URI[sha256sum] = "0b34622317c71e5d4ef73a2c91103c81bb93e00ec6745d815f5b5c5e0a4a80a4"
