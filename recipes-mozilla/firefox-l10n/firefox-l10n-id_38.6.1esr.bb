# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "abca1a5445c288b8ec2e5dc4567ff318"
SRC_URI[sha256sum] = "fbce720771e265c464a622a2f086e3111835c20897b8cf09494d6176631e348a"
