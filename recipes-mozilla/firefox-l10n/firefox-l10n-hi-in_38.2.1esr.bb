# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7ca721d0d07bce558b9258fee37b5558"
SRC_URI[sha256sum] = "df8683b412ccb2d4142099354b0759e59306eb96be12760c7c0f58b7b48d9411"
