# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2e91360d183740dda00c4562c046c359"
SRC_URI[sha256sum] = "c9668fad6190cc7c7d1d71c8bf01aa46c9ee565ff0f08959a8be3a4343e68f96"
