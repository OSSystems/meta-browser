# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ebc5c2c40cec252af6ac6c15e48f2c84"
SRC_URI[sha256sum] = "f518976f47472b555834208eb190cb13cc3e625a0f2784d35e1c70d58ce5d991"
