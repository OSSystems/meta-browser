# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ad32543cad5c6e1134790f6d596deb04"
SRC_URI[sha256sum] = "acbc237c0efc7e5a65069799661030527db13efbaa996c26ab4eebc4eb067ff1"
