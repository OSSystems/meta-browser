# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "9bc7eeea1ca1d3d94a666e49cbc0211c"
SRC_URI[sha256sum] = "e6f7a957ba96f0502da88164055f5af61e42a4373b13689ba4e3c040af3d528c"
