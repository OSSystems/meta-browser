# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "723fda901f6cf1cfc8d71e731a9cffd1"
SRC_URI[sha256sum] = "d3dedf9389f98ec92e4e466c65b43ca18a5fc318229c10ee20adf4ed8ad94b5d"
