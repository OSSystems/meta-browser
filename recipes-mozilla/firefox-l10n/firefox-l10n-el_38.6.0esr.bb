# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "668b1efe1b8dde6a6ed09fd506cea5b5"
SRC_URI[sha256sum] = "f746ebe43d8b4848fcca795e753f4daa52b83e1fbe8b5148f460d7eed993f7a4"
