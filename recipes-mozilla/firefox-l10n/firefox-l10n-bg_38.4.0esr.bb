# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9061486552b2056947189a555cd88ba1"
SRC_URI[sha256sum] = "ed0f3767bca984504cd14925eac0a85555b794669fbab204f6b66565fe5572d4"
