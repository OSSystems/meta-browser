# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "23928c032ff024fee398f325a0405af4"
SRC_URI[sha256sum] = "e527a326a558be79a787fc53cb1e1333cbc99d555f256c4570ecbd7f79ab927b"
