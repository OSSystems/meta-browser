# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "eb8f58688655fc1d263c2329a99eb029"
SRC_URI[sha256sum] = "c77ea31f83bc1f44d15d35031a124da263fb6a2e3ef49e3752bf2091b9eb1ea9"
