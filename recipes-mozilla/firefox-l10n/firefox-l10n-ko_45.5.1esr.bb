# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "949a07e17a9e27b331a746d20ce3f1a0"
SRC_URI[sha256sum] = "ae2063d06023d835f59bdccc98875bdf6e7b9141e16abf6380a5617c77e0a201"
