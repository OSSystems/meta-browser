# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7db3ffbf3758d76bf267aaf64166dfeb"
SRC_URI[sha256sum] = "b78492a8826850ef2a3f7d7c192c15af573b59c64871a2b849c98277eea28234"
