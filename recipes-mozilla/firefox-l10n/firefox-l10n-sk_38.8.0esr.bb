# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ad90b1712e990af2bd51f502f23b8652"
SRC_URI[sha256sum] = "c33bb4fafc0f4998cf4f0eb07281fea30473833f107f6c8bc1ba8c2fd0fe79cf"
