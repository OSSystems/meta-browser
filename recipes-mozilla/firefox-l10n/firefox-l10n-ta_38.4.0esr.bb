# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "810231b34263d97883966186320013d3"
SRC_URI[sha256sum] = "5ed639206c9b42064972edd8296163ebb517843aafab2cd6d5e1dbc2ae72af89"
