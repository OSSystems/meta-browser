# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f644d3ce9f3d56e91364ad81540c3468"
SRC_URI[sha256sum] = "acc8fe0985022151bb001f3fa7b6c8d6a63d2928bdf77ba2000870c83d56bb15"
