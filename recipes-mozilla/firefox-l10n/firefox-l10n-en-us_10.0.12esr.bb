# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b13987e7ef607946556f5110d4ffd797"
SRC_URI[sha256sum] = "6d5b7decc1b537153b40c8fc31081da50122268ba8f7a7e87df7b4c2ad819a09"
