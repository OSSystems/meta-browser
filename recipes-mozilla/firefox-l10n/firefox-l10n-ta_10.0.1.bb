# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "f426c025c231f30a5f9aa4b9a0b22a36"
SRC_URI[sha256sum] = "42a0146ba3a27cbe285afa47b9a7b6ac7004f3fa791a80c2a6f21d29e46d5590"
