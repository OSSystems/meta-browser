# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c30cf67ce1b16a657aa1b1734ad5c4d1"
SRC_URI[sha256sum] = "605d8bf0293967b7e55ff3b7107106230817249726c1bdbf513a18e4cd6a4adf"
