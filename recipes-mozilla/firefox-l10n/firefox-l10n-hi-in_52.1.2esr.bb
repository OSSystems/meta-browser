# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e52d7698fc1f2ac607f6ff311a4ca3ee"
SRC_URI[sha256sum] = "c1b9512d1c8b150e2d427049aacdc85f05db7d7e1f855820db30e68249a0a088"
