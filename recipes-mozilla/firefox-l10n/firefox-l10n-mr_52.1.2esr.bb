# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "533f8f508bbe7190a313d064bd98af4b"
SRC_URI[sha256sum] = "7b892400f94a8d3d51e5f602f7666ac9268db82f51b3fec5606a7a18fa2eb219"
