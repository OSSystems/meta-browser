# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "850f253f7d91a1bfb6b71faf480f84d8"
SRC_URI[sha256sum] = "902d50e925f2dce387a30602595428ff183784d96727b7fb11a52886430476ef"
