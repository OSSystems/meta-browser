# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9363a6752d4c65832185d4c9fd391c2b"
SRC_URI[sha256sum] = "9a59584de8d1339950c085e486d79a59dc3a40c04cceaa06ac2fc335fdbdfb7f"
