# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "1953bd4b32e8bad15aeb490ebc7e827a"
SRC_URI[sha256sum] = "a33f506653f8a2c166e1fe6a8af728913ef459ea59859940e641f2c442669d88"
