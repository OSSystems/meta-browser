# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e853dc9ed6c20de5b81e3e3a69a9ff7f"
SRC_URI[sha256sum] = "aac006ad04fd94454de660eb22615386659c9d7cb76a76661c87c7fe9a0ba2e6"
