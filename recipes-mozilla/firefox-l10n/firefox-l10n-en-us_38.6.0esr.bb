# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8730c677576b7bd5b84bc0f8145fa0b9"
SRC_URI[sha256sum] = "c71966224748f8c4b17cd465c61a12d6cd0b442d31af0851212a93c2fd611377"
