# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8ea086985950522402a328732f62d671"
SRC_URI[sha256sum] = "288f473e35d4b682e45a2b82d2219adbddefed8bbe33d051ddd8d8de9fa9adc9"
