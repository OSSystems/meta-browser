# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0a51785e7122a08ac93db806c58f1450"
SRC_URI[sha256sum] = "70d123916f587b933ee1724565bdcd5033ac270b2556b7342886fd76cae56235"
