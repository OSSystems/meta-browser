# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "668f3b1e7ed99b4dcc42fc402d8870c5"
SRC_URI[sha256sum] = "f0f73a21409f0a3e927f70880b40efb0a027233a35021a00c66cbb6f01b64b36"
