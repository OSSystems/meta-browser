# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "29775efce751b7e93e4a7b0428450a56"
SRC_URI[sha256sum] = "357a5a05bdda778076023c3b95cebe60ae253053c01795a74488672f4d531b91"
