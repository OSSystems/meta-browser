# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ad4ad50ffb633eeaff2a51642840eeaa"
SRC_URI[sha256sum] = "a3665c8972749057b3cc68a7191d2b358a96ed05e9f3dd21a05fc83dc8e2559d"
