# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "a0afc60ea438c11838f1baba7172f719"
SRC_URI[sha256sum] = "642f8860faabc144c0ce2dbc76a93e635b8e977a1ee2f284947220be7498b955"
