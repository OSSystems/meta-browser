# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "20986a4ce01ab032ac9340394f098119"
SRC_URI[sha256sum] = "04e9ce1235b1fa0d726e0925472fdad4a9ebd8b6baf80392f77e9f7f44afc665"
