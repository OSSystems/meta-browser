# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1e0740a8cd00bd617decbca128e2cfc9"
SRC_URI[sha256sum] = "af6d63813c6870ac5993860940f06c91611fed21cab87da34f7dc58d566fc751"
