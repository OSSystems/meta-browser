# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "0cd6526db231075101f19f90b759b1b8"
SRC_URI[sha256sum] = "13bb31fc6ed5d4d3541e1d51b96d4fce797fef7be9ee0b884cb8d3d86359e499"
