# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ecb7c10c79629c19d9fdb5d18fcff6e5"
SRC_URI[sha256sum] = "07131063fc5caa3a3f20d9f6140d3e0640c81e842389cd77c26ed722ddb195b0"
