# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2c034166c1f1f6340f4df67b5c08d25b"
SRC_URI[sha256sum] = "ec5fa60642854beacf8a031b17f6657c55666cd2fcc025829fc94c0ceaf671a9"
