# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5ac2f7fe64fe4c89a32f63791135eb3f"
SRC_URI[sha256sum] = "193730e08a92f2bff40c900193a800adf5298436ffb7fcf605f9ae03b75fd884"
