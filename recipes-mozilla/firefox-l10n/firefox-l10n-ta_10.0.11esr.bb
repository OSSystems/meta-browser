# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "53fdd689b4badfe13121cda96150548d"
SRC_URI[sha256sum] = "5ba580f167a9bf1fd28d7a1d82b33f5d0727693b926ece0e28813250542d0345"
