# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "401716d1fb94ec5b4ae6cdba3751a298"
SRC_URI[sha256sum] = "7dbbebe69ff4ae414909e02eadefd1db7b7585ebbf450c6906e515cd55ef5144"
