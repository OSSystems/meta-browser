# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bb49a2774bac5f9f632421818f3e7bd9"
SRC_URI[sha256sum] = "eec4af39f46367dcc9c282e298e6b947b4da62e8e2f4ee75c03de11f277d11e5"
