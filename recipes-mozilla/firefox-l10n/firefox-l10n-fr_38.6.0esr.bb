# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9621834ca64efa94f2db536308fab46b"
SRC_URI[sha256sum] = "da189e63a07aa2d26784e5ddcb7041fb969dc63c3f147f566290e5f55581d083"
