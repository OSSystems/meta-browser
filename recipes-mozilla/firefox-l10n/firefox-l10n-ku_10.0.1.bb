# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "ec7b52688be006b530ac468cffe6c3d8"
SRC_URI[sha256sum] = "cc4654f2dd1a1d3036067fc5209b298ecd5ec37f447d6be7d98a4f689213476a"
