# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1ab62fc2df5bb6c12c4fceba39b333bf"
SRC_URI[sha256sum] = "59bf429bf75054269dba7ca789581b6b4bfb501a8ed902690fbefcb3f3f7ae84"
