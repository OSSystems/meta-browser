# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d92b53b195c2113777d4ded0dee377ab"
SRC_URI[sha256sum] = "0c0959fe02ef5da26ffe65108426fb155670b14da8af112b4ce1411eedbcc6ed"
