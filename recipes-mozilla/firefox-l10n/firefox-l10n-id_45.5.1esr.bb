# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "49764a0bd16a0eeb58451ff8dc4dabd4"
SRC_URI[sha256sum] = "aedfc36977b658f77b75db21d9fb21d6412209c80098c4944d0557213b736f11"
