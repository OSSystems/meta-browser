# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "92200ad3a64a99563fb407d1a0ed4e08"
SRC_URI[sha256sum] = "04a1cc52ff79d7ab5371a83efb2217dd4a2b27807dbdc055b0a7080ce6c5d0d0"
