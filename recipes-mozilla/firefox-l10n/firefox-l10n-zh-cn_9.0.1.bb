# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "56ab31069f39363db73c3f947842b58c"
SRC_URI[sha256sum] = "76229b97e4b3fd24e2ea1d8945d5d43c92016d82c3af11105c6b59a2e2572419"
