# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4140c88810681af113f740ddebe7b9d3"
SRC_URI[sha256sum] = "530c487310ebbbc5fdba19ef21ed8bac6014d9e384b91bf81c683d01b163fa82"
