# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "95c7c9417902d01bf418cef45dfc5e2c"
SRC_URI[sha256sum] = "8bdc8b5e21eb9f2c8c5a179cc60e7e23f2b3e34debd5bef69201d6cb347f3b83"
