# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8fc2f221cdbc24a57108c5916c936d0b"
SRC_URI[sha256sum] = "c5393d7d9a3d77cf7343a40712b62ef778c748c9a780d0f4073483a1bd46ae99"
