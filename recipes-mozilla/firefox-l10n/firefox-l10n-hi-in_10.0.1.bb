# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "d641ea96aac23f30c5ccd8fb23f3c235"
SRC_URI[sha256sum] = "56f6e3ec4d03256c438dfd4a1525601aceff82c9b803e543d4cdf7e2f63aba78"
