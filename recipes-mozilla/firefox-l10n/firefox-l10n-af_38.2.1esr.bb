# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "04ef0f30c7a80add9d098f700318d0ed"
SRC_URI[sha256sum] = "2939af5389d2d480ad9b0b5fd4e13d725a07b47f1e025d7abe232e25bd6f93f3"
