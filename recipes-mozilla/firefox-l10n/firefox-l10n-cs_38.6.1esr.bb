# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "23f978e11524b4aa727a7995d7c946aa"
SRC_URI[sha256sum] = "37656a3d2907f88d43603eda525bd7ba1f7bba2bf93e42750f86ba1b0608fb5e"
