# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f1319904fdb10c1b3ef6f12f28d319fc"
SRC_URI[sha256sum] = "768594a4526184c4e8e48698f3b87ad94c325b2a8a9dc98dba106a1a702a5f1b"
