# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db9a433cf1f1ce11a4f75cd6bf04d317"
SRC_URI[sha256sum] = "4cca1a5987ba25b7d516e006e7286bd88b9d87db24b295a21cdafeaec1d8b42c"
