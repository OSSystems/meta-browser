# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cba8a89a32009dce0dba66d20839d760"
SRC_URI[sha256sum] = "a1d6e88c47714eda526f932a396db6ad092ebda696dbc26bdc4996056dcc3e68"
