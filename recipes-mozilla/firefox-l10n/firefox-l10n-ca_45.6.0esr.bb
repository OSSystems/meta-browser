# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7d401c2bf4b751f66dbbff2acda252d5"
SRC_URI[sha256sum] = "0a0144e5cea1ca0aada35f163b4827008e8af394c3d2a93adc43adc269d6c13c"
