# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "4632a0087e0cefd04acca6a2eb5f8d93"
SRC_URI[sha256sum] = "96cb88ae1df73e85e0bf2683d624ef83ce37f0892d8c24df91b923b02d573022"
