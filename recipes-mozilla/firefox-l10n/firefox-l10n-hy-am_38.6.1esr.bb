# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "113c39989cdb3361b0b5e4770a31085a"
SRC_URI[sha256sum] = "b8c2e84195a5993efe15f8026fc481b3693c8abe6273eb7777b6af90d0d24bbe"
