# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "f31deeeb72b998fc451a605a1a01a655"
SRC_URI[sha256sum] = "d3aad06c88b104ddc7e35d9c1db166855ac50053e291050f9be4cd68842a0e06"
