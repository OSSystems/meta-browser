# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a1fde519c462001d0b7e92dafd0982c9"
SRC_URI[sha256sum] = "d6a971d9dada695989fc6a93233a8c74976faf9c72c988e33da32f95003b21ce"
