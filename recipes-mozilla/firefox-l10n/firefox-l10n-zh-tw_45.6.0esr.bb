# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5243fd4d5c94cc2059f64c689e673e9a"
SRC_URI[sha256sum] = "80f55f03daa55e6b081f46a5badde962da433c54de5e4eb1a39c203a4a3b7dee"
