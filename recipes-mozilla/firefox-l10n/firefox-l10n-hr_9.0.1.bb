# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "75b2f685dcd052b5be0b5d029d7657bb"
SRC_URI[sha256sum] = "b4994dbb3a612b93133389debcf1c01685005b3f780985708a89b8cc0844a34f"
