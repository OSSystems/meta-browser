# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "99e16b013b264732b0330b1e90a982ac"
SRC_URI[sha256sum] = "c009652b9800dfa3f38e07b5d89e9bc6b2f0e8056926420afbd99ec9aa322e8d"
