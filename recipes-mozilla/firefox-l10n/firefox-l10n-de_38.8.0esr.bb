# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9277bcf83d7d1b2aa3a740f2c2b44148"
SRC_URI[sha256sum] = "9948f1fa62112a5b3f49dc314efbb6bcac7fa9767ffb9412ec600f030fe4308b"
