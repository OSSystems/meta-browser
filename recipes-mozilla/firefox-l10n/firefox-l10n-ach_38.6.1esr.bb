# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "12b6c2972bf35f6671957ccd8bec332a"
SRC_URI[sha256sum] = "2a259275291fbd0cfe343f1df03e7099c94e006b3fa00033f0a6a5961a047fe5"
