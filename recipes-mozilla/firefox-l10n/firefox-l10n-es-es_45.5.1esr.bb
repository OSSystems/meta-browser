# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "73bf87923edfcc05608b2b57872856bd"
SRC_URI[sha256sum] = "b23501e76d1e9422340ba817e223939d9f3655d69d63d80d527bb988f1d76b31"
