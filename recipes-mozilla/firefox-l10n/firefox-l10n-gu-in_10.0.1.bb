# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "0e2f1811cba9ca078e02fd253abf0435"
SRC_URI[sha256sum] = "b490a4d8441baf734a017fd29a70710160c5e18d2e5b41c57dcbc819267bd05e"
