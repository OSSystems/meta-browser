# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "657afba75647ed1e0fb65b4056994f3e"
SRC_URI[sha256sum] = "85890bca4c0e415d4888f9b2e66cf47237fe07a5fc7132b8578492a8d3454f68"
