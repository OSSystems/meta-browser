# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "68c39c42551f3460ee8f94c73b4776db"
SRC_URI[sha256sum] = "e2799027cbc0197ee0cab6f95943d5ae28dc84ba51067a7481f5c6002b7e062b"
