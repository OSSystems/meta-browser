# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cfdc130aa57083d0e8001c4a324f5589"
SRC_URI[sha256sum] = "4408ba162ce3dbef002a7e36f3d53399595abb196a10d9dd3f08e011e47f0f1d"
