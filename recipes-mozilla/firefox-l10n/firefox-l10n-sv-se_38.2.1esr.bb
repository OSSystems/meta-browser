# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1249eae2178150978dd699dda16a65d1"
SRC_URI[sha256sum] = "536084e596a969fc8d26c497b1155a3a41f393cd86fb8c962e75b142247dbe11"
