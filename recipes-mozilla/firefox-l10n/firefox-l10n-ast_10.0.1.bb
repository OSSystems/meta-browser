# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "ce86ea08545a75a2c8f40722357a9b2d"
SRC_URI[sha256sum] = "bd9b5c0b26936133fb9a53168a53a16389db9c760c7fe834927d88b20aa18cec"
