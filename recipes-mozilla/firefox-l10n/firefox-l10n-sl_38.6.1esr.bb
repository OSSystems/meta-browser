# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2a0d5cd3755b43ee3df1be9c2c849813"
SRC_URI[sha256sum] = "374a0ce9c092c43cf2d1310f2e1da6915c4fda8fae438631ba746cb5f8bef52a"
