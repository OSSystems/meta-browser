# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "95df8585d4ae60b10761913efbff2b0e"
SRC_URI[sha256sum] = "e367f3c203878066a133a507d01e16bce926734eaceefcd9c9be2421f7491781"
