# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fa3243c042caab554bacdde603ab31a8"
SRC_URI[sha256sum] = "531f656fb578e8335bd3400272a94bb0fd55418dd40399ef7bb9afb05f66342f"
