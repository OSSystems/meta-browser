# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "585076bdaa13bf5766db5b9d9bf9906e"
SRC_URI[sha256sum] = "d341caa22028cd297f5231c6006d88c7d33e96efb1a20ab6521afa16063dab34"
