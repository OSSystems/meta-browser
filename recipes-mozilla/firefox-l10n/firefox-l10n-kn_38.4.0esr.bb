# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e39c98248be86346dcb4e61ba2e5f201"
SRC_URI[sha256sum] = "029c65dc35f6b7e4b1f9f4ce968fd239b8a5ec79dedabff81d167fc91fffd4a3"
