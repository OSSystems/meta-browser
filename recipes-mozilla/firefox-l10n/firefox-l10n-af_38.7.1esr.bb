# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e2b0fa215d2208c79e7aa25d145089ec"
SRC_URI[sha256sum] = "495ba9aa6d33b913ceb89be4eff01746574b6315d87b038ae9229d9ba0217adb"
