# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f64c928d07b745642aa3e7fb7adc56e5"
SRC_URI[sha256sum] = "6b2387cc699b80360ec43e48f44a2600bff1bdf6c424ef3cdd6ed13813802b51"
