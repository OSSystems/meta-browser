# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6885925dd224a6be3767d7d11085fc0e"
SRC_URI[sha256sum] = "63d7ec720acc6dc77e8b735156b67d0b98cc130ca6160b924047c95da6a0bbb5"
