# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2ef0c41cfb132fe867b7e9a0d5a752c5"
SRC_URI[sha256sum] = "c5ee43e5a4a14d8476dfc7299a6f87ccb91aca8c954b85168a9248d91b3e3fde"
