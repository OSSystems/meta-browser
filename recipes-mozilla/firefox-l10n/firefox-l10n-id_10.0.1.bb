# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "0a0b515d29c282a08d3c87088d4776fe"
SRC_URI[sha256sum] = "f335838a8bcb1994f03769b95508dc260d786eb049307d444a2df17f7ffd88b5"
