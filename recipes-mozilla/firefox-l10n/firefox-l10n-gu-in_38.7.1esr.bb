# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "56318a913776cc7c382f230fa51892f8"
SRC_URI[sha256sum] = "404df6179b7d422ca170c8b5fb473a3a4deb31382876f2944f311ab716bb261e"
