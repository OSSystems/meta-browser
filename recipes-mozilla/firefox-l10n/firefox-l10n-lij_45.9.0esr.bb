# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0aa19ce5ee4eec1b0e750f8ee79fa05a"
SRC_URI[sha256sum] = "4ee9b0d76fea704a2d5be0a4ffec276ac67b50c5b14cb4e53c92ecb884a436db"
