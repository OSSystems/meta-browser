# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "655007d049083dcbb98460616e812c28"
SRC_URI[sha256sum] = "93c480f521bed6bd3e5d39d8fdb9738d8f046f61f38449e6a011673e85f7a19d"
