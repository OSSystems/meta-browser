# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "5fd16f723604d049f222c2e54fac4da2"
SRC_URI[sha256sum] = "47cceb14616339b93c564a2530959455d50da776f1d933b9f7d5c9562c593b1f"
