# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5346de37247b93ca3c0d6e4e9fc6a953"
SRC_URI[sha256sum] = "0ff3c6e8fcd716047daf002ed2b58254fccb82d22c5de1a7fe780d1eea7d771f"
