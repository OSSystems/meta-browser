# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7a7f2491aedd0e8ae68c8c4cf3435ba1"
SRC_URI[sha256sum] = "72ccd390f9ea546953771275b105fd4170f7e4318ef4806a083c81ee356c1df6"
