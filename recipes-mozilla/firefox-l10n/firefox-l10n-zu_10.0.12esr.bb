# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7d9d9d7a48a7e4bec69bc12a554210d2"
SRC_URI[sha256sum] = "c91bfecf01d45e6c36dd31a5eacee1e5b6a2262dafb19a43da60beb8da6da747"
