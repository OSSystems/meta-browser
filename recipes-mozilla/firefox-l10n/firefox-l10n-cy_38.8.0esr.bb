# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cf03affbc68d3973ff00b47ca60d8051"
SRC_URI[sha256sum] = "cedeeea29b5ee1e0d059685f0e9568896be5ec57d51a86a27335c409729e02bc"
