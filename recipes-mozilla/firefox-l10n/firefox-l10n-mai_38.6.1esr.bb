# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9d82f47a28042bd808a80857eaaa1ff6"
SRC_URI[sha256sum] = "a14ff6b63a09b67eb75b01351e562ea3b2d28f45123eff7170d145a87c90f9b8"
