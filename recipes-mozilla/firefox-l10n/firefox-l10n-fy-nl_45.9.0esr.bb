# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a7f3740817f1fd01e3f1d4450db95609"
SRC_URI[sha256sum] = "92576180b0ca061cc42a6e5e0414c6ba2834347952e4a045657fecc65887dd3c"
