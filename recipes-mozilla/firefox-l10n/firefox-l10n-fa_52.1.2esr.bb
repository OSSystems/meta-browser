# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ca1123ebf9f403044d4e1097c54224d9"
SRC_URI[sha256sum] = "c8bc4c536f0eb98253d0cb04d03203acc633f7360971d4203bc4d099ce2d0eaa"
