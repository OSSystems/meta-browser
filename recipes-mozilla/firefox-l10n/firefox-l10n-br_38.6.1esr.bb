# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7acc7a17a0d070b94c49af4e05c919db"
SRC_URI[sha256sum] = "aab264c5e15554a2fb8c6590dca6507a612a1fc2c63dbb8463c1689c467a2208"
