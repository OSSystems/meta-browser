# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a35f2199815d210ae1bac494a1eceffb"
SRC_URI[sha256sum] = "99998ee8edbf815796cbe6709bf8d313ae88719ce98d3663e95ed954488ad332"
