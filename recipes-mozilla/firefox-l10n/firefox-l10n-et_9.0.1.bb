# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "02380947b887f1e2ad2586ec7811a77b"
SRC_URI[sha256sum] = "dc26b0356c7c00b2acb9f8559515929fa1b98efc4d86a4664dbdafbeb0b356a5"
