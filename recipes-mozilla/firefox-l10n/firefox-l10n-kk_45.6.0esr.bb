# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "86bb298a03e9c40dad091c68f67ce039"
SRC_URI[sha256sum] = "71f683c2c290095517fb014dec274bce06edcbd1ed184ace151341a5a6cc7dbb"
