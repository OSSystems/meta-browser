# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e8b5700de5aa3f914e33b8eb8d775b09"
SRC_URI[sha256sum] = "a5cbd1cbacdd7d17c7f0d5d62583a0174e69e0905ffb22d0b7a4e936729862c7"
