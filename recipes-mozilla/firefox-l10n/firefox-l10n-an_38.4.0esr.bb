# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d68cc61859a1e687529c37c3843fbb16"
SRC_URI[sha256sum] = "46a554e2edb3d825a8831551f2c6b939f45c545fba05e3ef0be2ac3c36dbd883"
