# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3280f083cef39db9dd8842c788322d9f"
SRC_URI[sha256sum] = "e9cfb15ab559fdbda026b660125840c1a82db123a62c3ce15353052b7cd92201"
