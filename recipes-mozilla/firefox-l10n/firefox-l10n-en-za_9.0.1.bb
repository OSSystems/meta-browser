# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "573b2b1b3e4d6aec1a60e1f2e9f40320"
SRC_URI[sha256sum] = "40461149be19827a8f44c9569ee9df5162abe39ab1a1e300505ae650c3d2efa7"
