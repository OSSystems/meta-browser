# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9adb77fd15ca08d0dc3e5d91b7783aa2"
SRC_URI[sha256sum] = "39d5673e876e9bb802cca774f9fd73afa3381e19460c3298a9443b304fd1e79d"
