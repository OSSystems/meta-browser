# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "00ab1d3470c1d0349330ddb8ea0d2f24"
SRC_URI[sha256sum] = "88515d3980eb3771a0edee67ef63b642e802736a7d13d49a2f2ab92a7f621316"
