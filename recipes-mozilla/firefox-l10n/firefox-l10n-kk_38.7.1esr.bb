# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "31f4b92be6efd208f64bedf513941212"
SRC_URI[sha256sum] = "575076851a9ced7683cca17e642c377cceeedc645bd39d065a603d6acbd94762"
