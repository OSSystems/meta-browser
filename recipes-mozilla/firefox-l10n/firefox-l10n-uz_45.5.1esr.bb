# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1434e7dbcd834a354755e8407dcb856d"
SRC_URI[sha256sum] = "7d44d131f9f8e134bfc07d368be77d293a6b56aaaa3c818395749a04b15d2812"
