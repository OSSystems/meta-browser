# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "23e007aa74f6ecca5865da689907b6a5"
SRC_URI[sha256sum] = "20e4a96ac76793eadfc43c5094f92aae81fc439fb0df94204b48bbd022df5247"
