# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "6bc5f2c67dbf687bf7f840e1757cf19e"
SRC_URI[sha256sum] = "ae9c01938819f4947c2566cf59b45b7b4ff88d89b64ed34f147425e57d54185d"
