# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cb5a4e892f96a214311bf3eb742c9d2c"
SRC_URI[sha256sum] = "7968f2e7b2a5da76d82312230d5486f8c8b59ddef18d43d0c3e43581ebe717d8"
