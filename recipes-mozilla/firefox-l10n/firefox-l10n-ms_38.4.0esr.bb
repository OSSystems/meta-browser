# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "befda7a6f57ef5ab1df782f9bcf5cd84"
SRC_URI[sha256sum] = "70dff1a3bdcdeba70d01e9e7d86191d0ad81bd1cf064e98b227f1734222e0729"
