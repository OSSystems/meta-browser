# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4d168c27a9f7f8c7ebec303f4df905fe"
SRC_URI[sha256sum] = "942f7d98417b5887efebab011ef559b1f5a745d1a13aae8819cb95c1821e8a9b"
