# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "77b9119c9929e80588616b1781ea3257"
SRC_URI[sha256sum] = "e41aa8a9b5cd65abaca3735e2a87065671d1fc30b7627187ca1e4353290549f0"
