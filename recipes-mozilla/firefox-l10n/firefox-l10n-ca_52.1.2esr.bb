# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "93772fbc288068dc27b9bceacd824038"
SRC_URI[sha256sum] = "84b36029b1c6644fa5fda1c0b51041e19ebf6b4300020c151371321d8ee75150"
