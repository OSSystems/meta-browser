# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "38e2e9dd21e82318b50958a04327f1c6"
SRC_URI[sha256sum] = "2f01fa76716bbd75b9f82fc4a5ffeec1cf87dbc5875e7860526ddbeeb4bf34d0"
