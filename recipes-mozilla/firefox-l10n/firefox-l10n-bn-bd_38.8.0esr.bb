# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "78405c587c52fbd042b2caf8ef4e8ab1"
SRC_URI[sha256sum] = "2bd48ebb62cc863a12a8d85ca3883c73a746480160e0936202d3d8086c47d1c5"
