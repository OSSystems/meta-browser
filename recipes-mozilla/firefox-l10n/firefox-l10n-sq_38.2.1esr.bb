# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "be9dfcfad0864437c7e3556c99f8ac9a"
SRC_URI[sha256sum] = "2674faca4612734588e56946796c58725016082689e026ca8b805249447c97c2"
