# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4ac5c485e4552562c484d5f27a1ee88d"
SRC_URI[sha256sum] = "a981e1d079c72e9a0047a3360cee0f4dfa1a546d2639b697bff4655ac045e8d2"
