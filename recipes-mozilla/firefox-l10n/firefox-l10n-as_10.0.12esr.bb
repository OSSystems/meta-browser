# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fbb0fe62d7b57ccfe04181d454cae8aa"
SRC_URI[sha256sum] = "26e61ee3a18eac733e5c8b8feb55df78a97c1d3b0c619c78531deeb7c4bf5f95"
