# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6e5bff63bb2f2822c7ddc9d45b94b643"
SRC_URI[sha256sum] = "747843ec27dc7905ebf5c1984ec4bde9b838480d04c496b7acdc152b45d4fa07"
