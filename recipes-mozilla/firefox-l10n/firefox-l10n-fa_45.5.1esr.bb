# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dd8328c80bd266afcc9491558dec418c"
SRC_URI[sha256sum] = "5d592a7043007991787d5bd348280d91458595cc2c7aeabd7d84f785b8d499f5"
