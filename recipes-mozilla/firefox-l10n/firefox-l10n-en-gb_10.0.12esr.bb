# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ea8b587ae206d988c34b970ac0eb6c88"
SRC_URI[sha256sum] = "4d74084f6b1a95594f4fdfadbce98bb795ef6419bc3cc6d83f019de16674dd44"
