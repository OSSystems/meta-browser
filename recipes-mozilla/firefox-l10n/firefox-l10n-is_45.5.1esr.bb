# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e10b43ccfc708eab05d8e95a5630777f"
SRC_URI[sha256sum] = "48cfd7ac429b58d9be92f019d24076c3406f23b5fd26da92d3e53c5aa3bd1c64"
