# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a9010887c3a79687e9255a94c572d0f0"
SRC_URI[sha256sum] = "33eea4f409d500598b3c0ea08568091d539cbf8c0ed38398827ec477b2e3b80b"
