# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fca95afd94c93c298efaee1f202d7fa8"
SRC_URI[sha256sum] = "7df70432dfaf748eea5edfad608a3fcce377f1c3d06d1012f2fb28042f872ae8"
