# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "282b2732b10f1c2b7593bbcd9f46ee28"
SRC_URI[sha256sum] = "39b3b8b39d6c47e797ad4de782d11fa1c7482bb6fbcb3d3b6f07f70e27f2cd7d"
