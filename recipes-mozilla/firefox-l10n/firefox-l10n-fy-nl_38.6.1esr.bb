# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "20d8405c19b92827c3257279ccad6928"
SRC_URI[sha256sum] = "6c6de4698124089e4e57ebe130f7df2d9579c1fbbeca434080b289b374705126"
