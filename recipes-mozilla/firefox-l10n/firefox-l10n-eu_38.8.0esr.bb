# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "31f1d96857e143bf2962c35573a9fd53"
SRC_URI[sha256sum] = "92c785c932680469c0a90a1d9c5b94fab68a1eda40e92479894dff38b32ab068"
