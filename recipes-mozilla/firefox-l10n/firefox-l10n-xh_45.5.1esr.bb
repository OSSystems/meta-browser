# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dd64e14f7632f5b16f65ed4252283951"
SRC_URI[sha256sum] = "5558cb4f9704bc592babd1d8966e7bbaa684039615b4e7a9b528235ced01fe9f"
