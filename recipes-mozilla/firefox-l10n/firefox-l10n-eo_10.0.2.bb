# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "95053c7f6f40caa4b63abfe5f42e3ae0"
SRC_URI[sha256sum] = "2492cfcfa007f3c8a42a5f528b8db6a222473fb73d683e471daa7b34763e41fc"
