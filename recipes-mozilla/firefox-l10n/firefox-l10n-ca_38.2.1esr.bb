# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7bff27fdb28a69dc89b3e1e65add1d9c"
SRC_URI[sha256sum] = "9a7838b932bf3c356da9af568718ab058c86076e435f5d0be4a082bbaff190bf"
