# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9cb7c820e3b1a6dc2cb5fd2c853c777f"
SRC_URI[sha256sum] = "f72f2fe882022dffe962065dde8795562e6ced4237460f62eb628af4bf19dc3f"
