# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b24520463c1ea8f25eceb197620a5199"
SRC_URI[sha256sum] = "5beeafba0a7a1cf2bb14de27cac8284ac713712c3584e2d056bda5fa10d754ae"
