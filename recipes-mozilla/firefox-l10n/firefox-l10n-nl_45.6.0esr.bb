# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5573448d9cc8b8f69af116610378e05a"
SRC_URI[sha256sum] = "d5451bbb75b9be00fadf76a6b7ab5b48899d87729da2473e17929b83a5f76714"
