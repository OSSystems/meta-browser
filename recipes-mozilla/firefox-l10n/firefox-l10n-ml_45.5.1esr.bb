# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6831d32fe188bc085b688bcedf5b9154"
SRC_URI[sha256sum] = "bea1ec1d7cc230718db6ec04c8e217d1297e3b700259c2bb87de7bef73505102"
