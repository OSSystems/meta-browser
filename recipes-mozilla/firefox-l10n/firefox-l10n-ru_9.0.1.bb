# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "7134f3896ca93b6eeebe18226f7933e8"
SRC_URI[sha256sum] = "344d466a163682eddcfccdd72ca5204c0f5c8fc800ff9eeb90e7fec6c419ec76"
