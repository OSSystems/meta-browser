# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e91ecbe1d03e81c70c813fc9503dd99c"
SRC_URI[sha256sum] = "34d5455052f0f7e43561795998b9a9f20683bbdac54d740e2ccc952dbe35840a"
