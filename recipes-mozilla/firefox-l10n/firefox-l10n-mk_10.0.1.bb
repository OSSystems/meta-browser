# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "3fea35228a7a352a378482037150c953"
SRC_URI[sha256sum] = "02dd54fe5188d0c57d0ff90f8293cf13135ff1b8d1858cd40b3085f311b1dc0f"
