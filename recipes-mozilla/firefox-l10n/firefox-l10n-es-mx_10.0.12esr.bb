# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "58dad5b3a614b161156f7642c4522890"
SRC_URI[sha256sum] = "a17d54a81de9a3f81a7f56adc25f4f040b7e29a28ab946834c5a2a08152fe0d6"
