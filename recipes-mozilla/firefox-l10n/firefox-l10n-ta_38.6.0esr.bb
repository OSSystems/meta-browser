# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d530dfd437a7b2074635b3a190ab32df"
SRC_URI[sha256sum] = "57decfe700c7e047c10f39d8ef0a5d0a9f6f606fdbced530dff906cdba42bc43"
