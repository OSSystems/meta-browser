# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2aee8e4ae4991cc23ed33a067d877d4b"
SRC_URI[sha256sum] = "6b36c34fc846032af3ef67707662c997704d6a410c1d672c2cda7cd7c172d6b6"
