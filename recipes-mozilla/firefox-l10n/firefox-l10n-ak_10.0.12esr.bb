# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3b4bbc907198a0e7d0e7919347b34a9f"
SRC_URI[sha256sum] = "1f001cada0cdb54f475aff5d4b565396ec7d17c4523aa7b25e359199661530c6"
