# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "72e57bfb22272e16b11b6eb9bfbbb3b4"
SRC_URI[sha256sum] = "6ddaed17b7dbe398bd27080307e74dec1e5e4deade498fd6cb797a660f92647f"
