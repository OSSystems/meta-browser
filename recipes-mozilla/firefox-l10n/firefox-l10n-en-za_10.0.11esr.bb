# Copyright (C) 2009-2013, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "fdbec5d8503ca928f674acb068e5c385"
SRC_URI[sha256sum] = "e481c04f33ba14f4760258ada9ba5727ec501a3399a4ab1bde5a5446184f6146"
