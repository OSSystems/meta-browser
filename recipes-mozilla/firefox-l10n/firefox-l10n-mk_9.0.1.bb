# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "70d9d7034bbd8bd65f82ce400086236d"
SRC_URI[sha256sum] = "7642ca3b4601a48798cf0f71a4d756d8ed9ca1be72dd21ac91977eb817ead520"
