# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "018cce83b15469a935811433f4043179"
SRC_URI[sha256sum] = "3bf6c3ab74b58c1630577c0ac16bd7f1da9bfbb089d840dfdeb2cca2c0cb8fdc"
