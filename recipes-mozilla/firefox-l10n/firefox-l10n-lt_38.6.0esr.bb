# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "616a9543e761cea7745295ae4bc35c24"
SRC_URI[sha256sum] = "824b6142ec3d13f31d4ea77b9a548eb66eab4942e745a719e197fa5813578ea1"
