# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "93f65159f6e6416a93aebbcf6c589ea7"
SRC_URI[sha256sum] = "729f97a591c74dd823735623474e36d73415505091341913bcd2eea17f4b091f"
