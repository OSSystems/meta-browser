# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e4c0a8e17a0624d6bd2a3b7546de3bd0"
SRC_URI[sha256sum] = "0630d0535e6930818ad685567b8d83a860ea3a3f5791bd5d1f0ae20a8ec95dda"
