# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b269bd02363bb28ddb6881b25fa50939"
SRC_URI[sha256sum] = "567f923ab879afbda71121a5b52660fd179c67e97e43ea5908bf155d5a4c99dd"
