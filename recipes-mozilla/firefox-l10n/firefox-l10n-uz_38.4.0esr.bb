# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "00223fd3aa20db7e73edba8687ab79e5"
SRC_URI[sha256sum] = "d6735f56f2f3b590750bef3d00b9f1a9287e4c7360340406b4fd7477f79c041c"
