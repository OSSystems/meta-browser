# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "386df8e82c9882ab79d6d19a18c6351c"
SRC_URI[sha256sum] = "92a21d086f18945d1b1a4d86c77afaa5b4090ff603e9f8d41302137768550009"
