# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "480fea7e61c3b0d7eff0541ea0ddb853"
SRC_URI[sha256sum] = "d21b0687c2650829fd1e055331a3bb1810a11f9da59fcb8a503390074d299817"
