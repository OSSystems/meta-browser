# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "08e688b5227bf30182bbc84e33f67725"
SRC_URI[sha256sum] = "c2959bb77a4b2328533063d02b46af99622cad972cd44789be2958fcd3a408e1"
