# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7ef90cf8408341bf6d94efffb96275d6"
SRC_URI[sha256sum] = "b5ea8d81cecf8dd0608dda3c54d07d928d5fdb235ff689338e8baf127a47ccb2"
