# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "34fd3044b00efa993f701385828189b4"
SRC_URI[sha256sum] = "9abe8bdfc09c11bddcd92f052760edad97fba5396c535b3382f2add3b0ff6834"
