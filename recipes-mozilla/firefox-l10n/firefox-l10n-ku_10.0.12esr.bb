# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ea842f8bb93e6182ad41772051754acf"
SRC_URI[sha256sum] = "f5a5d768af61c1336c1f532f1cfc68e847799c19561591015b70551aba7ccc44"
