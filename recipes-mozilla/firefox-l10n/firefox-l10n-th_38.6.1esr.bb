# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d3e443f46b63aec9a6420e8c8d1f61cd"
SRC_URI[sha256sum] = "0defd0f41ef448f9751907071fc967521b08b1ef04515e6dc774851933424014"
