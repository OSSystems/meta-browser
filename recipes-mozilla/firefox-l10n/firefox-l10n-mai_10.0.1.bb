# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "dd782446f810c2932a0588ebd474f77a"
SRC_URI[sha256sum] = "54c839cd610e7771a843c6c31ba83c2bddace35a26ce4e7cfd1f0fdc4e6e7f08"
