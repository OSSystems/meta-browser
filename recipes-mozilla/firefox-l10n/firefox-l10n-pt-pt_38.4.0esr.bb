# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b0e592815c6a936a278e0391cb32bec8"
SRC_URI[sha256sum] = "eed43d8ae9b455983b05e288f7368114b6caf92ff801b1fd22e4bbc49bbb7288"
