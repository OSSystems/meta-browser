# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4912298aa808c4c5982687540e790554"
SRC_URI[sha256sum] = "50aaa09a46d1de6909fe2a9affab6b82a356837b2d6bddc82ee3dc3271dd917c"
