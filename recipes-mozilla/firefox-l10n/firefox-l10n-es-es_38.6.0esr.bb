# Copyright (C) 2009-2015, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f4a57efa7581f3e9d71bc3bab4b2fd97"
SRC_URI[sha256sum] = "a444361e1c0a3003f0f51285429096abea71309e358b3d308266a95773d7b3d9"
