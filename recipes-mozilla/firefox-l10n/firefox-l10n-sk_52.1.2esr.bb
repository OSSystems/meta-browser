# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "40b0e6e781cd8fc670dfca57538a1f8f"
SRC_URI[sha256sum] = "bed39b86536bba3d18a8655969312ddf3e5e895b33894ccd763bb6b93a34b13e"
