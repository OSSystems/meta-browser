# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aa52424d7f9e7b24f55b6b3c522e8cd3"
SRC_URI[sha256sum] = "a54e0d916a2b5b0b81e68f24a3f0263458311435204013fc1c09aed94161bea5"
