# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cafeef82b686760e03399077e8feddad"
SRC_URI[sha256sum] = "765c0a8f5e2e50c9ce69c8244dd5ce8c2485900b12382e436a0eb10dcc1f43ca"
