# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "a0adb35944f631ce8b4756ca3b93cf68"
SRC_URI[sha256sum] = "802aa30b5c4a8bb905929786064c5cfd56a8ba2380cf348bf04f0202e95d5ec9"
