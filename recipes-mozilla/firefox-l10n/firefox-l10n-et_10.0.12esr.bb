# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ee8e35e6bfee1814610ba195fd936789"
SRC_URI[sha256sum] = "4e04dabb3f5dbe5e763f764e48f647f152eda393b0f525aa32f2c0cb42531e9c"
