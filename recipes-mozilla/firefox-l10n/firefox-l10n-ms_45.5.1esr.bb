# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c6f0ee904e2185596bee64e7936b1579"
SRC_URI[sha256sum] = "5bc80a1f604e308dde247e1c4b0c916a4990148c4c505584dd8f344fd7bde943"
