# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "7460026a644fb9c09320851cbdda0d3c"
SRC_URI[sha256sum] = "cdd662b558dd6e420a08cc0b03d3daa0d59b714243f6f5756f14ba88b2f5f328"
