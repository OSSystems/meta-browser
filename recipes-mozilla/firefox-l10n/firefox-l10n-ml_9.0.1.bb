# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "73718a78c01fe41111edb2256eadaf20"
SRC_URI[sha256sum] = "6d8d58ef3217f1d9631cccceee2515c4fd1ca2bf2aaefe9c5d7ad6b9d94fd33f"
