# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "b578e7ef198c2f05e0afdefd28f66927"
SRC_URI[sha256sum] = "84a537338c886d208a05923ab1742d029409af40017e718318b9ee10d9822315"
