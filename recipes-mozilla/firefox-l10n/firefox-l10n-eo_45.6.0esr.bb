# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e5ba464b3e2424559fb133c8ff7e0fa7"
SRC_URI[sha256sum] = "28912cacd69ed38d8b87505690b8e34cde467661ce71276bdead3c4d63dc3d42"
