# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1d80cfb3f1d9c712ac00b4501d8e3886"
SRC_URI[sha256sum] = "bf6c7077b91a8b030091d0d7841619df74b9b82b8a248ccb3dc665a7413088cb"
