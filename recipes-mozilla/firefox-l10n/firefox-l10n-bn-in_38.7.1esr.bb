# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e23b6e876d61b64cb35d5df139897238"
SRC_URI[sha256sum] = "d7558c09adcc9c26cdf0ff1d5e66813336c8e1e50dfe759510553788e0bc887a"
