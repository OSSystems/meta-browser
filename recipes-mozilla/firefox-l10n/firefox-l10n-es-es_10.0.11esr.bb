# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0b4a2bca0ff661336294437fcbd0763f"
SRC_URI[sha256sum] = "fb3617624d8606a3155a224078a26a48a01cc7537f3dfa63acbc0b17c21253fd"
