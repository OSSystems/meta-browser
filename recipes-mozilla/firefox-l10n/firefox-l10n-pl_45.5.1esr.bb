# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "38097247d7554bb8f1e63a4fd2e1476c"
SRC_URI[sha256sum] = "7a8d586af73712f8187e777266576a158634615481b4a46f3afdc9b346d1e004"
