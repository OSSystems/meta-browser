# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fe630c0a8b553c1ba19e37cc72b0be9a"
SRC_URI[sha256sum] = "3353de0d6b62d5b604bce992504354d3da22c61aa591392833058020b00bb182"
