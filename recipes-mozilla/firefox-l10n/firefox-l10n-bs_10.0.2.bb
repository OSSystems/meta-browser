# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "ceb884c8969b5be251727f831b1fc3bf"
SRC_URI[sha256sum] = "529c0973398e5f2202d40f90f3970587090397a6a3da294d3024bde8fe490383"
