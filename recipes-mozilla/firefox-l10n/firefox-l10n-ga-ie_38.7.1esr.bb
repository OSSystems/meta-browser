# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "223ad3f1039d1dbd62bcedde0891ddfb"
SRC_URI[sha256sum] = "d5f98c255c96505b2303780ae939db1d63280b8d757c1a33308b0fba3e6a83d3"
