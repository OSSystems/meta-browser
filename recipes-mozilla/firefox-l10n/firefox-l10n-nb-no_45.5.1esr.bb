# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "06e61b3f17974aeb1b1ca74dd5854a44"
SRC_URI[sha256sum] = "daf747f93c2d610886ff4360fa8b2e3c3fc240f82bbcf4e92fa0830998e4ab32"
