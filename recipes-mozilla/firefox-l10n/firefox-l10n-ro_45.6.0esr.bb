# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "45c94ba5cf994eec4516ef6fcd6ac036"
SRC_URI[sha256sum] = "735f430dcf7e9283b2541ab8f9b65c9ab504e1185e828461a9cd35a911ed092e"
