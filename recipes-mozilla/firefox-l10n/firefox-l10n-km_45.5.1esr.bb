# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7a2577f93c290a2d54ca3b73f0d509a8"
SRC_URI[sha256sum] = "f8db2c89f7cb0648d917d28250bdbc965d9ed171308d619521a39a6ca2bcd27d"
