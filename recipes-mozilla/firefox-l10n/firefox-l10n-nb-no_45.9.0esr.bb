# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "62cad8dfc7cb835d2dc07d860e212ce9"
SRC_URI[sha256sum] = "122e714059835d0499396a59946a87f3c3a7e46f4452f7069a11d441df7634b2"
