# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d6823e528dbf84f935cc755a8258431c"
SRC_URI[sha256sum] = "6b7c10f8a21a5038f3a770ebfb37b10207ac9ce2702abfefe8f7f4225223a84d"
