# Copyright (C) 2009-2014, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e81b1d71dbecb02b8a9556dbdac45dba"
SRC_URI[sha256sum] = "e4ee31393e42505360a466e870abc28890c648a23f7fce8041dbf8b464628de5"
