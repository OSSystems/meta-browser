# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2385ba66cba1fdbdeeede5921314b8aa"
SRC_URI[sha256sum] = "f2bad2c40e75db159b54dc72a97199f9f0c8f479fab295bed8f4dc43b3b77aeb"
