# Copyright (C) 2009-2012, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "e812f9147c11d955fd1241fde0acbd65"
SRC_URI[sha256sum] = "fff73dadf6e3ee67945b816c944582a43201cee2b92234f2c55f43981c45f7a9"
